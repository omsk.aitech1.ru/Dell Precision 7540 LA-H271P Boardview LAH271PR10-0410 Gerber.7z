# Allegro board LAH271PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SW1_EDP_N2_C: length 4.5
  TOP w0.109: JEDP1.34 111,44.92 110.78,45.14 110.78,45.61 v2(110.69,45.71)
  BOTTOM w0.109: v2(110.69,45.71) 110.79,45.6 110.79,45.03 110.6,44.85 v1(110.6,44.7) 110.6,44.02 CV5.2
SW1_EDP_N3: length 2.8
  BOTTOM w0.109: CV3.1 108.74,43.1 108.74,42.68 v1(109.11,42.31) 109.4,42.02 109.4,41.87 109.46,41.82 UV64.36
SW1_EDP_N3_C: length 5.5
  TOP w0.109: v2(109.36,46.03) 109.46,45.93 109.46,44.91 109.98,44.38 109.98,43.38 JEDP1.32
  BOTTOM w0.109: CV3.2 108.8,44.04 108.8,44.58 109.45,45.23 109.45,45.95 v2(109.36,46.03)
SW1_EDP_P0: length 3.1
  BOTTOM w0.109: UV64.46 113.46,41.33 114.06,41.93 v1(114.06,42.09) 114.06,42.09 114.76,42.79 114.76,43.14 CV848.1
SW1_EDP_P0_C: length 4.7
  TOP w0.109: JEDP1.39 113.52,43.38 113.52,43.98 114.17,44.63 114.17,45.55 v2(114.27,45.65)
  BOTTOM w0.109: CV848.2 114.75,44.09 114.75,44.75 v1(114.72,44.77) 114.17,45.33 114.17,45.55 v2(114.27,45.65)
SW1_EDP_P1: length 2.8
  BOTTOM w0.109: CV846.1 112.92,43.1 112.92,42.73 v1(112.32,42.12) 112.32,41.42 112.26,41.36 UV64.43
SW1_EDP_P1_C: length 5.3
  TOP w0.109: v2(112.66,46.09) 112.56,46 112.56,44.74 112.52,44.69 112.52,44.01 112.5,43.99 JEDP1.37
  BOTTOM w0.109: CV846.2 112.92,44.05 112.92,44.93 112.56,45.29 112.56,46 v2(112.66,46.09)
SW1_EDP_P2: length 2.5
  BOTTOM w0.109: UV64.40 111.06,42.08 111.13,42.15 111.13,43.07 CV6.1
SW1_EDP_P2_C: length 4.6
  TOP w0.109: JEDP1.35 111.52,43.38 111.52,45.14 111.3,45.35 111.3,45.61 v2(111.4,45.71)
  BOTTOM w0.109: v2(111.4,45.71) 111.3,45.61 111.3,44.82 111.12,44.63 111.12,44.02 CV6.2
SW1_EDP_P3: length 2.8
  BOTTOM w0.109: UV64.37 109.86,41.86 109.92,41.92 109.92,42.23 109.53,42.62 109.26,42.89 109.26,43.03 CV4.1
SW1_EDP_P3_C: length 5.5
  TOP w0.109: v2(110.07,46.03) 109.98,45.93 109.98,45.12 110.5,44.59 JEDP1.33
  BOTTOM w0.109: CV4.2 109.31,44 109.31,44.36 109.96,45.01 109.96,45.92 v2(110.07,46.03)
SW1_REXT: length 14.1
  IN3 w0.081: v2(108.4,41.76) 108.11,41.76 106.87,43 103.17,43 102.75,42.57 102.75,42.23 102.35,41.83 101.73,41.83 100.83,40.92 v2(100.83,40.57)
  BOTTOM w0.109: v2(108.4,41.76) 108.66,41.5 UV64.34 ; RV835.2 100.08,37.55 100.08,38.9 100.4,39.23 100.4,40.15 v2(100.83,40.57)
SW2_4PH: length 32.3
  TOP w0.203: v2(254.47,139.66) 254.55,139.58 PR1146.1
  TOP w0.254: PL1203.2 241.39,129.34 v2(241.47,129.27)
  IN1 w0.254: v2(241.47,129.27) 241.47,131.35 244.43,134.31 244.43,138.59 245.43,139.59 246.56,139.59 248.74,137.41 251.66,137.41 252.55,136.52 252.55,135.84 252.81,135.59 254.85,135.59 255.45,136.19 255.45,138.68 v2(254.47,139.66)
  BOTTOM w0.109: v2(254.47,139.66) v1(254.47,140.23)
  BOTTOM w0.203: v2(254.47,139.66) 254.57,139.56 PR1161.1
SW2_DP2_1_AUXN: length 106.8
  TOP w0.109: v2(186.81,123.89) 186.81,124.03 187.02,124.25 189.46,124.25 190.07,123.64 190.07,123.18 190.73,122.52 190.73,122.19 190.64,122.1 UV8.27 ; v2(157.53,48.75) 157.53,48.41 158.18,47.76 158.18,44.02 156.02,41.85 155.49,41.85 RV809.1
  IN2 w0.094: v2(157.53,48.75) 157.53,48.58 157.6,48.52 157.83,48.52 163.3,53.99 163.3,55.17 180.65,72.52 180.65,75.1 181.04,75.49 181.04,78.19 181.38,78.53 181.38,81.86 182.22,82.71 182.22,88.13 182.68,88.59 182.68,90.53 181.43,91.78 181.43,94.38 182.76,95.71 182.76,100.31 183.24,100.79 183.24,111.59 183.67,112.02 183.67,119.39 184.8,120.53 184.8,121.53 185.86,122.59 186.92,122.59 187.72,123.39 187.72,123.76 187.26,124.21 186.86,124.21 186.72,124.07 186.72,123.98 v2(186.81,123.89)
SW2_DP2_1_AUXN_C: length 2.9
  TOP w0.102: UV67.59 151.74,41.75 151.8,41.81 152.25,41.81 152.59,41.47 153.2,41.47 153.24,41.51 153.58,41.51 RV809.2
SW2_DP2_1_AUXP: length 106.8
  TOP w0.109: RV808.1 155.93,42.07 157.96,44.11 157.96,47.67 157.52,48.11 157.35,48.28 v2(157.06,48.28) ; v2(186.81,124.61) 186.95,124.46 189.55,124.46 190.29,123.73 190.29,123.27 190.95,122.61 190.95,122.2 191.04,122.11 UV8.26
  IN2 w0.094: v2(157.06,48.28) 157.1,48.32 157.91,48.32 163.49,53.9 163.49,55.09 180.84,72.44 180.84,75.02 181.23,75.41 181.23,78.11 181.57,78.45 181.57,81.78 182.42,82.63 182.42,88.05 182.88,88.51 182.88,90.61 181.62,91.86 181.62,94.3 182.95,95.63 182.95,100.23 183.44,100.71 183.44,111.51 183.86,111.93 183.86,119.31 185,120.45 185,121.45 185.95,122.4 187,122.4 187.91,123.31 187.91,123.84 187.35,124.41 187.01,124.41 v2(186.81,124.61)
SW2_DP2_1_AUXP_C: length 2.9
  TOP w0.102: UV67.60 151.73,42.15 151.87,42 152.33,42 152.63,41.7 v4(152.91,41.7) 153.53,41.7 RV808.2
SW2_DP2_1_HPD: length 115.3
  TOP w0.109: v2(181.71,113.66) 182.03,113.99 186.71,113.99 186.87,114.15 v1(187.24,114.15) v2(187.92,114.15) UV8.48 ; UV67.19 v2(143.5,46.29)
  IN3 w0.081: v2(143.5,46.29) 143.87,46.66 146.49,46.66 147.22,45.92 147.8,45.92 148.06,46.18 148.06,46.45 149.02,47.41 153.97,47.41 156.95,44.43 160.32,44.43 163.42,47.54 163.42,50.35 174.67,61.6 176,61.6 176.95,62.56 179.9,62.56 181.96,64.62 181.96,68.2 184.59,70.82 184.59,77.2 189.34,81.95 189.34,83.09 190.95,84.69 190.95,89.84 191.43,90.32 191.43,102.03 191.91,102.51 191.91,106.16 190.98,107.09 190.98,108.31 188.23,111.06 188.23,113.84 v2(187.92,114.15)
  BOTTOM w0.109: v2(181.71,113.66) 181.29,113.24 RV903.1
SW2_DP2_1_N0: length 103.1
  TOP w0.109: UV8.49 188.23,113.75 188.09,113.61 187.23,113.61 186.87,113.25 184.26,113.25 183.99,112.98 181.52,112.98 180.97,113.53 179.71,113.53 v2(179.41,113.83) ; v2(144.43,50.45) 144.68,50.2 144.68,49.29 CV892.2
  IN2 w0.094: v2(144.43,50.45) 144.65,50.23 144.65,49.81 145.08,49.37 152.78,49.37 153.78,50.37 155.4,50.37 175.06,70.04 175.06,73.85 176.72,75.51 176.72,78.56 178.64,80.48 178.64,82.39 179.17,82.93 179.17,84.03 177.83,85.37 177.83,88.18 176.68,89.33 176.68,90.99 177.85,92.16 178.09,92.16 178.81,92.89 178.81,95.03 180.11,96.33 180.11,97.87 179.7,98.29 179.7,100.69 178.2,102.18 177.51,102.18 177.25,102.45 177.25,104.24 178.95,105.94 178.95,108.72 180.27,110.04 180.27,113.36 180.01,113.62 179.62,113.62 v2(179.41,113.83)
SW2_DP2_1_N0_C: length 3.5
  TOP w0.109: UV67.15 145.1,45.7 145.19,45.8 145.19,46.54 144.64,47.09 144.64,48.08 CV892.1
SW2_DP2_1_N1: length 103.4
  TOP w0.109: v2(180.06,115.26) 180.45,114.86 188.07,114.86 188.16,114.95 UV8.46 ; v2(142.65,50.44) 142.9,50.19 142.9,49.28 CV894.2
  IN2 w0.094: v2(142.65,50.44) 142.87,50.23 142.87,49.57 143.66,48.77 153.15,48.77 153.97,49.6 155.46,49.6 176.08,70.22 176.08,74.03 177.37,75.31 177.37,75.86 179.25,77.74 179.25,82.06 179.83,82.64 179.83,84.54 179.19,85.18 179.19,91.81 179.84,92.46 179.84,95.16 180.73,96.05 180.73,100.6 179.71,101.62 179.71,108.59 181.28,110.15 181.28,114.66 180.93,115.01 180.3,115.01 v2(180.06,115.26)
SW2_DP2_1_N1_C: length 3.7
  TOP w0.109: CV894.1 142.9,48.04 142.9,47.78 v4(143.6,47.08) 144,46.68 144,45.82 143.9,45.72 UV67.18
SW2_DP2_1_N2: length 106.2
  TOP w0.109: CV896.2 141.2,49.36 141.2,50.12 v2(140.88,50.45) ; v2(181.8,116.91) 182.14,116.58 182.56,116.58 183.48,115.66 188.07,115.66 188.16,115.75 UV8.44
  IN2 w0.094: v2(181.8,116.91) 182.07,116.64 182.26,116.64 182.65,116.26 182.65,112.91 182.01,112.27 182.01,109.93 180.35,108.27 180.35,101.96 181.33,100.98 181.33,95.75 180.43,94.86 180.43,82.39 179.85,81.8 179.85,77.49 178.03,75.67 178.03,75.05 176.84,73.87 176.84,70.13 155.66,48.95 154.24,48.95 153.46,48.17 142.33,48.17 141.1,49.39 141.1,50.22 v2(140.88,50.45)
SW2_DP2_1_N2_C: length 3.9
  TOP w0.109: CV896.1 141.13,48.03 141.13,47.81 141.92,47.01 141.92,46.99 142.46,46.46 142.48,46.46 142.78,46.16 142.78,45.79 142.7,45.71 UV67.21
SW2_DP2_1_N3: length 110
  TOP w0.109: UV8.41 188.16,116.95 188.07,116.86 184.18,116.86 183.32,117.73 182.96,117.73 v2(182.67,118.02) ; v2(139.08,50.43) 139.34,50.18 139.34,49.28 CV898.2
  IN2 w0.094: v2(139.08,50.43) 139.07,50.43 139.07,49.43 140.94,47.56 153.75,47.56 154.54,48.35 155.91,48.35 179.55,72 179.55,75.55 180.01,76.01 180.01,76.49 180.44,76.93 180.44,81.5 181.78,82.84 181.78,90.85 181.03,91.59 181.03,94.56 181.93,95.46 181.93,101.27 180.95,102.25 180.95,103.26 182.75,105.06 182.75,111.86 183.27,112.38 183.27,117.58 183.04,117.81 182.88,117.81 v2(182.67,118.02)
SW2_DP2_1_N3_C: length 4.9
  TOP w0.109: UV67.23 141.9,45.67 141.99,45.77 141.99,45.96 141.73,46.22 141.35,46.22 141.07,46.5 141.05,46.5 140.65,46.89 140.65,46.92 140.04,47.53 v4(139.8,47.53) 139.58,47.53 139.35,47.76 139.35,48.03 CV898.1
SW2_DP2_1_P0: length 103.1
  TOP w0.109: v2(179.41,112.96) 179.77,113.31 180.88,113.31 181.43,112.76 184.08,112.76 184.35,113.03 186.96,113.03 187.32,113.39 188.1,113.39 188.14,113.35 UV8.50 ; v2(145.27,50.44) 145.14,50.44 144.9,50.2 144.9,49.29 CV891.2
  IN2 w0.094: v2(179.41,112.96) 179.41,113.35 179.49,113.43 179.92,113.43 180.08,113.28 180.08,110.12 178.75,108.8 178.75,106.02 177.05,104.32 177.05,102.37 177.43,101.99 178.12,101.99 179.5,100.6 179.5,98.21 179.91,97.79 179.91,96.41 178.62,95.11 178.62,92.97 178.01,92.36 177.76,92.36 176.48,91.08 176.48,89.25 177.63,88.1 177.63,85.29 178.98,83.95 178.98,83.01 178.44,82.47 178.44,80.56 176.52,78.64 176.52,75.59 174.86,73.93 174.86,70.12 155.32,50.57 153.7,50.57 152.7,49.57 145.16,49.57 144.84,49.89 144.84,50.54 144.91,50.61 145.1,50.61 v2(145.27,50.44)
SW2_DP2_1_P0_C: length 3.5
  TOP w0.109: CV891.1 144.87,48 v4(144.87,47.52) 144.87,47.17 145.4,46.63 145.4,45.81 145.5,45.71 UV67.14
SW2_DP2_1_P1: length 103.5
  TOP w0.109: CV893.2 143.11,49.3 143.11,50.19 143.36,50.44 v2(143.55,50.44) ; v2(180.05,114.42) 180.27,114.64 188.07,114.64 188.16,114.55 UV8.47
  IN2 w0.094: v2(143.55,50.44) 143.38,50.61 143.15,50.61 143.06,50.52 143.06,49.65 143.74,48.97 153.07,48.97 153.89,49.79 155.38,49.79 175.89,70.3 175.89,74.11 177.17,75.39 177.17,75.94 179.05,77.82 179.05,82.14 179.64,82.72 179.64,84.45 178.99,85.1 178.99,91.89 179.64,92.54 179.64,95.24 180.54,96.13 180.54,100.52 179.52,101.54 179.52,108.67 181.08,110.23 181.08,114.58 180.85,114.82 180.06,114.82 179.98,114.73 179.98,114.49 v2(180.05,114.42)
SW2_DP2_1_P1_C: length 3.7
  TOP w0.109: UV67.17 144.3,45.77 144.22,45.84 144.22,46.77 143.96,47.03 143.96,47.06 143.55,47.46 143.52,47.46 143.12,47.87 143.12,48.03 CV893.1
SW2_DP2_1_P2: length 106.1
  TOP w0.109: CV895.2 141.42,49.22 141.42,50.06 v2(141.81,50.45) ; v2(181.8,116.01) 182.16,116.36 182.47,116.36 183.39,115.44 188.07,115.44 188.16,115.35 UV8.45
  IN2 w0.094: v2(181.8,116.01) 181.8,116.34 181.91,116.45 182.18,116.45 182.46,116.17 182.46,112.99 181.82,112.35 181.82,110.01 180.16,108.35 180.16,101.88 181.13,100.9 181.13,95.83 180.24,94.94 180.24,82.47 179.65,81.88 179.65,77.57 177.83,75.75 177.83,75.14 176.64,73.95 176.64,70.21 155.58,49.14 154.16,49.14 153.38,48.36 142.41,48.36 141.3,49.47 141.3,50.55 141.37,50.62 141.64,50.62 v2(141.81,50.45)
SW2_DP2_1_P2_C: length 3.9
  TOP w0.109: UV67.20 143.1,45.72 142.99,45.82 142.99,46.25 v4(142.32,46.93) 141.37,47.88 141.37,48.06 CV895.1
SW2_DP2_1_P3: length 109.9
  TOP w0.109: CV897.2 139.55,49.3 139.55,50.19 v2(139.8,50.43) ; UV8.42 188.16,116.55 188.07,116.64 184.09,116.64 183.23,117.51 183.01,117.51 v2(182.67,117.17)
  IN2 w0.094: v2(139.8,50.43) 139.67,50.43 139.27,50.04 139.27,49.51 141.02,47.76 153.67,47.76 154.46,48.55 155.83,48.55 179.35,72.08 179.35,75.63 179.81,76.09 179.81,76.57 180.24,77.01 180.24,81.58 181.58,82.92 181.58,90.76 180.83,91.51 180.83,94.64 181.73,95.54 181.73,101.19 180.76,102.17 180.76,103.34 182.55,105.14 182.55,111.94 183.07,112.46 183.07,117.5 182.96,117.61 182.54,117.61 182.48,117.55 182.48,117.36 v2(182.67,117.17)
SW2_DP2_1_P3_C: length 4.8
  TOP w0.109: UV67.22 142.3,45.68 142.21,45.77 142.21,46.04 141.82,46.44 141.44,46.44 v4(141.02,46.86) 140.89,46.99 140.11,47.77 139.64,47.77 139.56,47.85 139.56,48.03 CV897.1
SW2_DP2_2_AUXN: length 32.9
  TOP w0.109: UV8.29 189.84,122.09 189.94,122.19 189.94,122.37 189.72,122.6 186.79,122.6 185.78,123.61 185.78,125.18 186.39,125.79 186.39,126.55 185.09,127.84 185.09,128.71 185.08,128.73 185.08,129.29 185.09,129.3 185.09,130.65 185.38,130.93 185.38,131.99 184.81,132.56 184.81,133.08 v2(184.58,133.3) ; v2(174.64,128.31) 174.86,128.54 174.86,128.84 174.67,129.03 JDGFF4.F5
  IN1 w0.102: v2(174.64,128.31) 174.88,128.55 174.88,128.74 175.13,129 177.69,129 178.56,128.12 183.66,128.12 183.96,128.43 183.96,131.75 184.82,132.61 184.82,133.06 v2(184.58,133.3)
SW2_DP2_2_AUXP: length 32.9
  TOP w0.109: v2(175.3,128.31) 175.08,128.54 175.08,128.81 175.27,129.01 JDGFF4.F4 ; v2(185.24,133.3) 185.02,133.08 185.02,132.65 185.59,132.08 185.59,130.84 185.31,130.56 v4(185.31,129) 185.31,127.93 186.6,126.64 186.6,125.7 185.99,125.09 185.99,123.7 186.88,122.81 189.81,122.81 190.16,122.46 190.16,122.18 190.24,122.09 UV8.28
  IN1 w0.102: v2(175.3,128.31) 175.06,128.55 175.06,128.66 175.21,128.81 177.61,128.81 178.48,127.94 183.74,127.94 184.15,128.35 184.15,131.67 185.01,132.53 185.01,133.06 v2(185.24,133.3)
SW2_DP2_2_HPD: length 29.8
  TOP w0.109: v2(176.87,131.74) 176.23,131.74 175.94,132.03 175.94,132.74 176.47,133.28 JDGFF4.C2 ; UV8.38 v2(187.92,118.15)
  IN3 w0.081: v2(187.92,118.15) 188.33,118.56 188.33,121.12 186.01,123.44 186.01,125.36 186.6,125.95 186.6,127.1 186.15,127.55 184.95,127.55 184.64,127.23 184.64,125.67 184.32,125.35 181.28,125.35 176.27,130.37 176.27,131.13 v2(176.87,131.74)
SW2_DP2_2_N0: length 38.1
  TOP w0.109: v2(172.09,135.06) 172.18,135.06 172.34,135.23 172.34,135.44 172.27,135.51 JDGFF4.B9 ; UV8.39 188.16,117.75 188.04,117.63 184.3,117.63 182.48,119.46 181.84,119.46 181.82,119.48 181.13,119.48 181.12,119.46 180.38,119.46 178.96,120.88 178.96,125.51 178.63,125.84 178.63,132.32 180.28,133.97 180.28,135.05 180.11,135.21 180.11,135.28 180.26,135.42 v2(180.58,135.42)
  IN1 w0.102: v2(180.58,135.42) 180.35,135.65 180.35,135.75 179.49,136.61 177.99,136.61 177.67,136.29 172.45,136.29 172.09,135.93 v2(172.09,135.06)
SW2_DP2_2_N1: length 32.7
  TOP w0.109: UV8.36 188.35,118.95 188.28,118.89 183.94,118.89 182.47,120.35 181.25,120.35 180.22,121.39 180.22,125.24 179.26,126.19 179.26,132.07 180.5,133.3 180.86,133.3 181.17,133.62 181.17,134.16 181.26,134.24 181.46,134.24 v2(181.54,134.16) ; JDGFF4.C5 174.67,133.67 174.94,133.94 174.94,134.12 v2(174.8,134.26)
  IN1 w0.102: v2(174.8,134.26) 174.96,134.11 174.96,133.85 175.14,133.66 177.75,133.66 177.95,133.46 180.99,133.46 181.32,133.78 181.32,133.94 v2(181.54,134.16)
SW2_DP2_2_N2: length 34.8
  TOP w0.109: v2(172.82,134.26) 173.05,134.03 173.05,133.83 172.87,133.65 JDGFF4.C8 ; v2(182.52,133.52) 182.12,133.52 182.03,133.43 182.03,132.92 181.72,132.61 180.7,132.61 179.91,131.82 179.91,126.53 180.93,125.51 180.93,124.93 180.95,124.92 180.95,124.22 180.93,124.2 180.93,121.93 181.76,121.09 182.62,121.09 184.06,119.66 188.07,119.66 188.16,119.75 UV8.34
  IN1 w0.102: v2(172.82,134.26) 172.82,133.61 173.13,133.31 174.65,133.31 174.9,133.06 177.51,133.06 177.76,132.81 182.04,132.81 182.29,133.07 182.29,133.29 v2(182.52,133.52)
SW2_DP2_2_N3: length 32.8
  TOP w0.109: v2(172.87,128.22) 173.09,128.44 173.09,128.73 172.87,128.95 JDGFF4.F8 ; v2(183.93,133.09) 183.9,133.13 183.56,133.13 183.48,133.05 183.48,132.77 184.2,132.05 v4(184.2,130.51) 184.2,128.33 184.63,127.89 184.63,127.59 184.93,127.3 184.93,125.58 185.14,125.37 185.14,123.5 187.8,120.84 188.21,120.84 188.32,120.95 UV8.31
  IN1 w0.102: v2(172.87,128.22) 173.06,128.22 173.12,128.16 173.12,127.79 173.02,127.69 172.66,127.69 172.35,127.99 172.35,128.78 172.99,129.42 177.24,129.42 179.95,132.13 183.09,132.13 183.48,132.52 183.48,133.1 183.58,133.2 183.82,133.2 v2(183.93,133.09)
SW2_DP2_2_P0: length 38.1
  TOP w0.109: JDGFF4.B8 172.87,135.63 172.56,135.32 172.56,135.25 v2(172.75,135.06) ; v2(179.72,135.42) 179.9,135.24 179.9,135.12 180.06,134.96 180.06,134.06 178.41,132.41 178.41,125.75 178.74,125.42 178.74,120.79 180.29,119.24 v4(181.51,119.24) 182.39,119.24 184.21,117.42 188.09,117.42 188.16,117.35 UV8.40
  IN1 w0.102: v2(172.75,135.06) 172.28,135.54 172.28,135.86 172.53,136.1 177.75,136.1 178.07,136.42 179.41,136.42 180.16,135.68 180.16,135.45 180.02,135.31 179.83,135.31 v2(179.72,135.42)
SW2_DP2_2_P1: length 32.8
  TOP w0.109: v2(180.7,134.12) 180.95,133.87 180.95,133.71 180.77,133.52 180.41,133.52 179.05,132.16 179.05,126.1 180,125.15 180,121.3 181.16,120.14 182.38,120.14 183.85,118.67 188.23,118.67 188.35,118.55 UV8.37 ; v2(175.46,134.26) 175.37,134.26 175.16,134.05 175.16,133.85 175.27,133.74 JDGFF4.C4
  IN1 w0.102: v2(180.7,134.12) 180.87,134.29 181.04,134.29 181.13,134.2 181.13,133.86 180.92,133.65 178.03,133.65 177.83,133.85 175.22,133.85 175.14,133.92 175.14,134.04 175.36,134.26 v2(175.46,134.26)
SW2_DP2_2_P2: length 34.7
  TOP w0.109: v2(181.62,133.5) 181.82,133.31 181.82,133.01 181.63,132.82 180.61,132.82 179.69,131.91 179.69,126.45 180.72,125.42 v4(180.72,124.55) 180.72,121.84 181.68,120.88 182.53,120.88 183.97,119.44 188.07,119.44 188.16,119.35 UV8.35 ; JDGFF4.C7 173.47,133.67 173.27,133.88 173.27,134 v2(173.53,134.26)
  IN1 w0.102: v2(173.53,134.26) 173.41,134.26 173.01,133.86 173.01,133.69 173.2,133.49 174.73,133.49 174.97,133.25 177.58,133.25 177.84,133 181.96,133 182.1,133.14 182.1,133.42 182.03,133.5 v2(181.62,133.5)
SW2_DP2_2_P3: length 32.9
  TOP w0.109: JDGFF4.F7 173.5,129.21 173.5,128.96 173.3,128.77 173.3,128.44 v2(173.53,128.22) ; UV8.32 188.26,120.55 188.18,120.63 187.71,120.63 184.93,123.41 184.93,125.28 184.71,125.49 184.71,127.21 184.42,127.5 184.42,127.8 183.98,128.24 183.98,130.22 183.97,130.24 183.97,130.78 183.98,130.8 183.98,131.96 183.27,132.68 183.27,132.94 v2(183.07,133.14)
  IN1 w0.102: v2(173.53,128.22) 173.31,128 173.31,127.71 173.1,127.5 172.58,127.5 172.17,127.92 172.17,128.86 172.91,129.61 177.16,129.61 179.87,132.32 183.02,132.32 183.29,132.59 183.29,132.92 v2(183.07,133.14)
SW3_4PH: length 35.8
  TOP w0.203: PR1148.1 254.51,138.36 v2(254.48,138.33)
  TOP w0.254: v2(234.03,129.6) 233.64,129.98 PL1204.2
  IN1 w0.254: v2(234.03,129.6) 234.03,132.2 236.86,135.02 236.86,137.75 235.99,138.61 235.99,140.44 236.42,140.86 252.58,140.86 254.48,138.96 v2(254.48,138.33)
  BOTTOM w0.203: PR1163.1 254.52,138.37 v2(254.48,138.33)
SW3_DP1_AUXN: length 63.9
  TOP w0.109: UV66.57 72.28,31.91 72.38,32.02 72.59,32.02 72.9,31.71 72.9,31.23 72.58,30.91 v2(72.43,30.91) 72.65,30.69 72.65,30.36 73.22,29.8 73.94,29.8 RV855.1
  IN2 w0.094: v2(29.62,51.26) 29.86,51.02 29.86,50.49 30.31,50.04 32.2,50.04 32.2,50.04 32.37,50.04 32.81,50.48 32.81,51.21 33.08,51.48 35.36,51.48 35.38,51.48 35.38,51.48 35.77,51.41 36.02,51.3 36.06,51.28 36.41,51.14 37.71,49.84 37.71,49.23 38.05,48.89 38.96,48.89 40.21,47.64 40.21,45.83 44.15,41.89 56.57,41.89 58.02,40.44 59.03,40.44 59.5,39.97 60.49,39.97 61.12,39.35 62,39.35 63.05,38.3 63.05,36.59 63.91,35.73 71.08,35.73 72.49,34.32 72.49,32.16 72.68,31.97 72.68,31.17 v2(72.43,30.91)
  BOTTOM w0.109: v2(29.62,51.26) 29.84,51.04 29.84,50.23 CT19.2
SW3_DP1_AUXN_C: length 7
  BOTTOM w0.076: 31.19,44.07 31.19,44.05 31.22,44.02 31.22,43.44 UT1.N2
  BOTTOM w0.109: 31.19,44.07 31.19,44.19 30.49,44.89 v4(30.49,45.66) 30.49,47.32 30.47,47.34 30.47,48.01 30.49,48.03 30.49,48.24 29.75,48.98 29.75,49.32 CT19.1
SW3_DP1_AUXP: length 63.9
  TOP w0.109: RV890.1 74.15,30.16 74,30.01 73.31,30.01 72.86,30.45 72.86,30.67 v2(73.11,30.92) 73.11,31.15 73.11,31.22 73.11,31.8 72.67,32.23 72.34,32.23 72.27,32.31 UV66.58
  IN2 w0.094: v2(30.28,51.26) 30.05,51.03 30.05,50.57 30.39,50.23 32.29,50.23 32.61,50.56 32.61,51.29 33,51.68 35.37,51.68 35.37,51.68 35.4,51.67 35.82,51.59 36.1,51.48 36.1,51.48 36.52,51.31 37.9,49.92 37.9,49.31 38.13,49.08 39.04,49.08 40.4,47.72 40.4,45.91 44.23,42.08 56.65,42.08 58.1,40.63 59.12,40.63 59.58,40.17 60.57,40.17 61.2,39.54 62.09,39.54 63.25,38.38 63.25,36.67 63.99,35.92 71.16,35.92 72.68,34.4 72.68,32.25 72.88,32.05 72.88,31.15 v2(73.11,30.92)
  BOTTOM w0.109: CT18.2 30.06,50.23 30.06,51.04 v2(30.28,51.26)
SW3_DP1_AUXP_C: length 7
  BOTTOM w0.076: UT1.N1 31.37,43.75 31.37,44.02 31.4,44.05 31.4,44.07
  BOTTOM w0.109: 31.4,44.07 31.4,44.28 30.7,44.98 30.7,45.32 30.74,45.36 30.74,45.96 30.7,45.99 v4(30.7,47.65) 30.7,48.33 29.96,49.07 29.96,49.54 30,49.58 30.22,49.58 30.27,49.53 CT18.1
SW3_DP1_HPD: length 50.2
  TOP w0.109: UV66.49 v2(68.46,30.23)
  IN3 w0.081: v2(36.14,44.24) 35.88,43.99 35.88,41.3 36.34,40.84 36.96,40.84 37.46,40.35 37.46,38.1 39.03,36.53 39.03,35.24 39.89,34.38 v2(39.89,32.8)
  IN4 w0.102: v2(68.46,30.23) 68.17,30.23 66.86,28.92 62.36,28.92 61.13,30.15 61.13,30.54 60.17,31.49 59.88,31.49 59,32.37 59,32.55 58.75,32.8 56.93,32.8 56.84,32.89 54.62,32.89 54.58,32.84 48.59,32.84 48.2,32.46 48.2,32.1 47.97,31.87 44.54,31.87 43.35,30.68 41.44,30.68 39.89,32.23 v2(39.89,32.8)
  BOTTOM w0.089: 35.35,43.81 35.35,43.44 UT1.AA2
  BOTTOM w0.109: v2(39.89,32.8) v1(39.89,32.26) ; v2(36.14,44.24) 35.7,44.24 35.35,43.9 35.35,43.81
SW3_DP1_N0: length 49.1
  TOP w0.109: UV66.53 70.06,30.05 70,29.99 70,28.79 71,27.79 71,27.48 70.89,27.38 70.75,27.38 v2(70.43,27.7)
  IN2 w0.081: v2(70.43,27.7) 70.76,27.37 70.85,27.37 70.95,27.47 70.95,28.43 70.17,29.21 70.17,30.79 71.35,31.98 71.35,33.85 71.04,34.16 62.53,34.16 61.85,34.84 61.85,37.9 61.53,38.21 60.65,38.21 60.02,38.84 59.03,38.84 58.56,39.3 57.55,39.3 56.83,40.02 51.02,40.02 50.64,40.4 45.26,40.4 44.97,40.11 43.05,40.11 42.71,39.77 42.43,39.77 v2(42.3,39.64)
  BOTTOM w0.109: CT11.2 40.52,40.87 41.2,40.87 41.52,40.54 41.52,40.29 42.03,39.78 42.16,39.78 42.26,39.68 42.26,39.68 v2(42.3,39.64)
SW3_DP1_N0_C: length 4.7
  BOTTOM w0.076: UT1.AB7 35.8,40.7 36.21,40.7 36.43,40.92 36.77,40.92 36.95,40.73 36.97,40.73
  BOTTOM w0.109: CT11.1 39.88,40.87 37.82,40.87 37.68,40.73 36.97,40.73
SW3_DP1_N1: length 44.9
  TOP w0.109: v2(69.02,26.59) 69.28,26.59 69.35,26.65 69.35,27.1 69.16,27.29 69.16,28.01 68.8,28.37 v1(68.8,29.07) 68.8,29.99 68.86,30.05 UV66.50
  IN2 w0.081: v2(69.02,26.59) 69.11,26.5 69.44,26.5 69.54,26.6 69.54,26.93 69.23,27.24 69.23,27.89 68.8,28.31 64.98,28.31 64.41,28.88 64.41,30.34 63.76,30.99 62.54,30.99 61.81,31.73 61.81,33.22 59.74,35.29 59.74,35.75 59.16,36.32 58.45,36.32 58.07,36.71 57.08,36.71 56.61,37.17 56.61,37.98 56.4,38.19 55.66,38.19 55.52,38.32 51.27,38.32 50.99,38.6 46.84,38.6 46.74,38.7 44,38.7 43.86,38.56 42.74,38.56 v2(42.68,38.51)
  BOTTOM w0.109: v2(42.68,38.51) 42.61,38.58 41.99,38.58 41.13,39.43 40.8,39.43 40.54,39.69 CT13.2
SW3_DP1_N1_C: length 3.5
  BOTTOM w0.076: 37.23,39.18 37.21,39.18 37.11,39.28 37.11,39.29 37.04,39.36 36.87,39.36 36.38,39.85 36.29,39.85 36.2,39.76 35.87,39.76 35.81,39.82 35.81,39.89 35.92,40 UT1.AC9
  BOTTOM w0.109: CT13.1 38.36,39.72 38.1,39.72 37.56,39.18 37.23,39.18
SW3_DP1_N2: length 39.5
  TOP w0.109: UV66.47 67.66,29.98 67.64,29.97 v1(67.64,27.6) 67.64,26.42 v2(67.63,26.41)
  IN2 w0.081: v2(43.72,36.76) 44.12,37.16 46.75,37.16 47.02,37.43 50.44,37.43 50.7,37.17 54.94,37.17 56.53,35.58 57.55,35.58 58.88,34.25 59,34.25 59.42,33.82 59.42,33.49 60.65,32.26 60.65,30.85 61.82,29.68 61.82,28.76 62.69,27.89 63.78,27.89 64.52,27.14 67.34,27.14 67.59,26.89 67.59,26.45 v2(67.63,26.41)
  BOTTOM w0.109: v2(43.72,36.76) 43.56,36.93 43.49,36.93 43.41,37 42,37 40.86,38.14 40.86,38.45 40.76,38.55 CT15.2
SW3_DP1_N2_C: length 5.1
  BOTTOM w0.076: UT1.AB11 35.88,38.85 36.24,38.85 36.39,39 36.5,39 36.99,38.51 37.24,38.51 37.42,38.33 37.44,38.33
  BOTTOM w0.109: 37.44,38.33 37.91,38.33 38.44,38.86 v1(39.04,38.86) 39.17,38.86 39.47,38.55 39.91,38.55 CT15.1
SW3_DP1_N3: length 43.8
  TOP w0.109: v2(66.27,25.29) 66.28,25.27 66.66,25.27 66.78,25.4 66.78,25.52 66.45,25.85 66.45,29.18 66.42,29.21 66.42,30.08 66.46,30.12 UV66.44
  IN2 w0.081: v2(66.27,25.29) 66.68,25.29 66.74,25.23 66.74,24.91 66.63,24.8 63.94,24.8 62.61,26.13 62.61,27.08 61.19,28.5 61.19,29.24 60.01,30.42 59.46,30.42 59.1,30.79 59.1,31.34 59.3,31.55 59.3,32.55 58.61,33.24 58.4,33.24 57.14,34.5 55.64,34.5 54.28,35.86 51.89,35.86 51.24,35.21 50.4,35.21 49.37,36.23 48.14,36.23 48.01,36.36 46.43,36.36 46.35,36.45 v2(45.13,36.45)
  BOTTOM w0.109: v2(45.13,36.45) 45.06,36.38 44.34,36.38 43.99,36.03 v1(43.02,36.03) 42.5,36.03 42.26,36.28 41.84,36.28 40.57,37.54 39.78,37.54 39.37,37.95 39,37.95 CT17.2
SW3_DP1_N3_C: length 3.2
  BOTTOM w0.076: 37.51,37.96 37.49,37.96 37.3,37.77 37.23,37.77 36.74,38.27 36.33,38.27 36.21,38.39 35.93,38.39 35.85,38.31 35.85,38.21 35.91,38.16 UT1.AC13
  BOTTOM w0.109: CT17.1 38.36,37.96 v1(37.53,37.96) 37.51,37.96
SW3_DP1_P0: length 49.2
  TOP w0.109: v2(71.37,27.16) 71.49,27.27 71.49,27.28 71.51,27.31 71.51,28 70.52,29 v1(70.52,29.4) 70.52,30 70.46,30.06 UV66.54
  IN2 w0.081: v2(71.37,27.16) 71.49,27.27 71.49,28.65 70.71,29.43 70.71,30.57 71.89,31.75 71.89,34.07 71.27,34.7 62.75,34.7 62.38,35.07 62.38,38.12 61.76,38.75 60.87,38.75 60.24,39.38 59.25,39.38 58.79,39.84 57.77,39.84 57.05,40.56 51.24,40.56 50.87,40.94 45.04,40.94 44.75,40.65 42.83,40.65 v2(42.49,40.31)
  BOTTOM w0.109: v2(42.49,40.31) 42.22,40.31 42.03,40.5 42.03,40.76 41.41,41.38 40.52,41.38 CT10.2
SW3_DP1_P0_C: length 4.6
  BOTTOM w0.076: 36.97,41.25 36.95,41.25 36.77,41.07 36.31,41.07 36.22,41.15 35.93,41.15 35.85,41.07 35.85,40.98 35.92,40.92 UT1.AC7
  BOTTOM w0.109: 36.97,41.25 37.47,41.25 37.6,41.39 v4(38.36,41.39) 39.89,41.39 CT10.1
SW3_DP1_P1: length 45
  TOP w0.109: v2(70.1,26.61) 69.86,26.84 69.86,27.32 69.68,27.5 v1(69.68,27.82) 69.68,28.22 69.32,28.59 69.32,29.96 69.26,30.02 UV66.51
  IN2 w0.081: v2(42.68,39.17) 42.75,39.1 43.74,39.1 43.88,39.24 46.96,39.24 47.06,39.14 51.21,39.14 51.49,38.86 55.75,38.86 55.88,38.73 56.62,38.73 57.15,38.2 57.15,37.4 57.3,37.25 58.29,37.25 58.68,36.86 59.39,36.86 60.28,35.97 60.28,35.51 62.35,33.44 62.35,31.95 62.77,31.53 63.98,31.53 64.94,30.57 64.94,29.11 65.21,28.85 69.03,28.85 69.76,28.11 69.76,27.46 70.1,27.13 v2(70.1,26.61)
  BOTTOM w0.109: v2(42.68,39.17) 42.61,39.1 42.2,39.1 41.35,39.95 41.01,39.95 40.75,40.21 39.45,40.21 39.39,40.27 CT12.2
SW3_DP1_P1_C: length 3.5
  BOTTOM w0.076: UT1.AB9 35.8,40.21 36.24,40.21 36.93,39.52 37.05,39.52 37.23,39.7
  BOTTOM w0.109: CT12.1 38.36,40.24 37.89,40.24 v4(37.54,39.9) 37.35,39.7 37.23,39.7
SW3_DP1_P2: length 39.6
  TOP w0.109: UV66.48 68.06,29.96 68.16,29.86 v2(68.16,26.76)
  IN2 w0.081: v2(68.16,26.76) 68.16,27.09 67.56,27.68 64.75,27.68 64,28.43 62.92,28.43 62.36,28.98 62.36,29.9 61.18,31.07 61.18,32.49 59.96,33.71 59.96,34.04 59.22,34.78 59.1,34.78 57.77,36.12 56.75,36.12 55.16,37.71 50.92,37.71 50.66,37.97 46.79,37.97 46.52,37.7 44,37.7 v2(43.72,37.42)
  BOTTOM w0.109: CT14.2 40.92,39.12 41.38,38.66 41.38,38.36 v1(41.58,38.15) 42.21,37.52 43.63,37.52 v2(43.72,37.42)
SW3_DP1_P2_C: length 5.1
  BOTTOM w0.076: 37.44,38.84 37.42,38.84 37.24,38.66 37.06,38.66 36.56,39.15 36.37,39.15 36.21,39.31 35.93,39.31 35.85,39.23 35.85,39.13 35.91,39.08 UT1.AC11
  BOTTOM w0.109: 37.44,38.84 37.69,38.84 38.22,39.37 39.38,39.37 39.63,39.12 CT14.1
SW3_DP1_P3: length 43.8
  TOP w0.109: UV66.45 66.86,30.09 66.93,30.02 66.93,29.43 66.97,29.39 v1(66.97,28.91) 66.97,26.06 67.3,25.73 v2(67.3,25.35)
  IN2 w0.081: v2(67.3,25.35) 67.3,24.71 66.85,24.26 63.71,24.26 62.07,25.9 62.07,26.85 60.65,28.27 60.65,29.02 59.79,29.88 59.24,29.88 58.56,30.56 58.56,31.56 58.77,31.77 58.77,32.32 58.39,32.7 58.17,32.7 56.92,33.96 55.42,33.96 54.06,35.32 52.11,35.32 51.46,34.67 50.17,34.67 49.15,35.69 47.92,35.69 47.78,35.83 46.21,35.83 46.13,35.91 45.18,35.91 v2(45.13,35.86)
  BOTTOM w0.109: CT16.2 39,37.44 39.15,37.44 39.57,37.02 40.36,37.02 41.62,35.76 42.05,35.76 42.29,35.52 44.21,35.52 44.56,35.86 v2(45.13,35.86)
SW3_DP1_P3_C: length 3.3
  BOTTOM w0.076: 37.51,37.44 37.49,37.44 37.31,37.62 37.3,37.62 37.17,37.62 36.67,38.12 36.36,38.12 36.25,37.94 35.87,37.94 UT1.AB13
  BOTTOM w0.109: CT16.1 38.36,37.44 37.51,37.44
SW4_4PH: length 43.4
  TOP w0.203: v2(254.47,142.01) PR1149.1
  TOP w0.254: PL1205.2 225.9,127.72 v2(226.27,127.35)
  IN1 w0.254: v2(254.47,142.01) 254.13,141.66 233.84,141.66 231.98,139.8 230.19,139.8 228.25,137.86 228.25,136.22 228.93,135.54 228.93,132.58 226.27,129.91 v2(226.27,127.35)
  BOTTOM w0.109: v2(254.47,142.01) v1(254.47,142.6)
  BOTTOM w0.203: v2(254.47,142.01) 254.48,141.99 PR1164.1
SW4_DP2_AUXN: length 143.8
  TOP w0.109: UV67.57 151.77,40.95 151.84,41.02 152.08,41.02 152.31,40.78 152.31,40.29 152.89,39.72 153.14,39.72 v2(153.36,39.5) 153.53,39.67 153.74,39.67 RV869.1
  IN4 w0.102: v2(153.36,39.5) 153.15,39.71 152.91,39.71 152.05,40.57 146.51,40.57 146.22,40.87 146.22,41.3 145.79,41.73 142,41.73 141.21,42.52 139.85,42.52 138.84,43.54 137.89,43.54 137.34,44.08 127.1,44.08 124.03,41.01 117.46,41.01 116.38,42.09 116.38,42.46 114.7,44.14 107.2,44.14 106.39,44.95 99.41,44.95 98.89,44.43 94.46,44.43 90.93,40.9 89.73,40.9 89.61,41.02 82.01,41.02 80.67,42.36 77.24,42.36 76.29,43.31 73.98,43.31 73.75,43.08 68.18,43.08 67.01,41.91 65.28,41.91 64.4,41.03 57.28,41.03 56.33,41.98 47.83,41.98 46.13,43.68 43.93,43.68 41.15,46.46 41.15,48.99 38.2,51.94 34.36,51.94 32.44,50.02 31.36,50.02 31.07,50.3 31.07,50.52 v2(30.88,50.72)
  BOTTOM w0.109: v2(30.88,50.72) 31.1,50.49 31.1,49.87 CT184.2
SW4_DP2_AUXN_C: length 6.3
  BOTTOM w0.076: UT1.P2 31.68,43.44 31.68,44 31.65,44.03 31.65,44.05
  BOTTOM w0.109: 31.65,44.05 31.65,44.33 31.17,44.81 31.17,48.33 31,48.51 31,48.97 CT184.1
SW4_DP2_AUXP: length 143.8
  TOP w0.109: UV67.58 151.81,41.35 151.93,41.23 152.17,41.23 152.53,40.87 152.53,40.38 152.98,39.94 153.08,39.94 v2(153.36,40.21) 153.69,39.88 153.89,39.88 RV889.1
  IN4 w0.102: v2(31.54,50.72) 31.4,50.72 31.26,50.57 31.26,50.38 31.43,50.2 32.36,50.2 34.28,52.13 38.28,52.13 41.34,49.06 41.34,46.53 44,43.87 46.21,43.87 47.91,42.17 56.4,42.17 57.36,41.22 64.32,41.22 65.2,42.1 66.94,42.1 68.1,43.27 73.67,43.27 73.9,43.49 76.36,43.49 77.31,42.55 80.75,42.55 82.08,41.21 89.69,41.21 89.8,41.09 90.85,41.09 94.38,44.62 98.81,44.62 99.33,45.14 106.47,45.14 107.28,44.33 114.77,44.33 116.56,42.54 116.56,42.17 117.54,41.2 123.95,41.2 127.02,44.27 137.42,44.27 137.97,43.73 138.92,43.73 139.93,42.71 141.29,42.71 142.08,41.92 145.86,41.92 146.4,41.38 146.4,40.95 146.59,40.76 152.13,40.76 152.99,39.9 153.27,39.9 153.36,39.99 v2(153.36,40.21)
  BOTTOM w0.109: CT178.2 31.32,49.87 31.32,50.49 v2(31.54,50.72)
SW4_DP2_AUXP_C: length 6.3
  BOTTOM w0.076: UT1.P1 31.83,43.74 31.83,44 31.87,44.03 31.87,44.05
  BOTTOM w0.109: CT178.1 31.53,49.16 31.43,49.25 31.28,49.25 31.21,49.18 31.21,48.59 31.39,48.42 31.39,44.9 31.87,44.42 31.87,44.05
SW4_DP2_HPD: length 143.5
  TOP w0.109: v2(148.18,38.69) 148.04,38.82 148.04,39.66 147.9,39.8 UV67.49
  IN1 w0.102: v2(72.73,45.3) 72.9,45.3 73.33,44.86 73.33,44.1 73.14,43.91 72.61,43.91 70.78,42.08 67.33,42.08 66.08,40.82 54.29,40.82 53.7,40.23 51.31,40.23 51.01,39.92 51.01,38.03 49.19,36.21 46.46,36.21 45.52,37.15 44.9,37.15 43.8,36.06 41.94,36.06 40.55,37.45 40.55,38.03 40.09,38.48 39.55,38.48 37.17,40.86 35.89,40.86 v2(34.56,42.19)
  IN2 w0.081: v2(148.18,38.69) 148.18,39.46 147.83,39.8 142.07,39.8 140.96,38.69 140.17,38.69 139.6,39.26 138.71,39.26 137.62,38.17 134.7,38.17 133.67,39.2 133.67,40.09 132.84,40.91 130.76,40.91 129.07,39.22 129.07,36.18 128.61,35.72 124.42,35.72 123.64,34.93 123.64,33.37 122.69,32.41 121.5,32.41 120.86,33.06 110.31,33.06 106.65,36.73 106.65,38.34 106.24,38.75 102.71,38.75 102.27,39.19 99.76,39.19 98.95,39.99 98.95,40.65 97.19,42.41 91.61,42.41 90.87,41.68 83.95,41.68 83.27,42.36 82.27,42.36 81.84,42.79 81.28,42.79 80.69,43.38 78.42,43.38 78.19,43.61 77.26,43.61 75.18,45.69 73.12,45.69 v2(72.73,45.3)
  BOTTOM w0.109: UT1.Y4 v2(34.56,42.19)
SW4_DP2_N0: length 154
  TOP w0.109: UV67.53 149.5,39.5 150,39 150,38.86 149.94,38.81 v2(149.82,38.81)
  IN4 w0.102: v2(149.82,38.81) 149.84,38.81 149.98,38.67 149.98,37.73 148.67,36.42 148.04,36.42 147.24,35.63 146.74,35.63 145.91,34.8 143.75,34.8 142.95,35.6 139.3,35.6 135.62,39.28 130.06,39.28 128.46,37.68 127.97,37.68 127.19,36.9 121.69,36.9 119.1,34.31 107.44,34.31 104.82,36.93 98.21,36.93 97.87,36.59 95.76,36.59 94.95,35.78 84.03,35.78 83.53,35.27 80.32,35.27 80.06,35.02 79.44,35.02 79.08,35.37 76.74,35.37 75.26,36.85 73.02,36.85 72.62,36.44 62.57,36.44 61.09,34.95 58.56,34.95 57.84,34.24 57.43,34.24 57.27,34.4 55.8,34.4 54.39,35.81 51.79,35.81 51.16,35.17 50.36,35.17 49.42,36.11 47.97,36.11 47.72,36.36 46.84,36.36 46.31,35.83 46.31,34.92 46.08,34.69 38.92,34.69 37.98,35.63 37.98,36.57 38.11,36.7 38.11,38.18 35.86,40.43 35.86,42.26 34.31,43.8 27.54,43.8 26.73,44.61 24.77,44.61 24.45,44.92 24.45,45.67 22.87,47.25 22.87,47.92 22.27,48.52 21.86,48.52 v2(21.81,48.57)
  BOTTOM w0.109: v2(21.81,48.57) 21.91,48.48 22.25,48.48 22.74,47.99 22.74,47.21 CT187.2
SW4_DP2_N0_C: length 6.7
  BOTTOM w0.076: UT1.B5 26.16,42.06 25.64,42.06 25.44,42.26 25.44,42.65 24.99,43.1 24.6,43.1 24.13,43.57 24.13,43.83
  BOTTOM w0.109: CT187.1 22.76,46.28 v4(22.76,45.5) 22.76,45.19 24.13,43.83
SW4_DP2_N1: length 150.4
  TOP w0.109: v2(148.36,38.05) 148.57,38.26 148.57,38.98 148.26,39.3 148.26,39.76 148.3,39.8 UV67.50
  IN4 w0.102: v2(148.36,38.05) 148.37,38.05 148.44,37.97 148.44,37.86 148.18,37.61 147.54,37.61 146.99,37.05 146.28,37.05 145.2,35.97 144.26,35.97 144.04,36.19 144.04,36.76 143.54,37.25 139.62,37.25 138.25,38.63 138.25,38.79 136.45,40.59 134.71,40.59 134.38,40.91 130.39,40.91 129.96,40.48 129.32,40.48 129.08,40.72 127.99,40.72 125.33,38.06 121.05,38.06 119.5,36.52 118.88,36.52 117.99,37.41 115.69,37.41 114.63,36.35 108.04,36.35 107.27,37.12 107.27,38.31 106.56,39.02 102.92,39.02 102.38,39.55 97.07,39.55 94.47,36.95 86.73,36.95 86.08,37.59 82.47,37.59 81.43,36.55 77.22,36.55 75.75,38.03 73.88,38.03 73.21,38.69 67.47,38.69 67.29,38.51 66.62,38.51 66.15,38.04 61.57,38.04 60.52,37 59.6,37 59.52,36.92 56.15,36.92 55.25,37.82 49.75,37.82 49.56,38.02 47.17,38.02 46.94,37.79 45.09,37.79 44.17,36.87 44.17,36.52 43.72,36.07 41.93,36.07 40.58,37.42 39.85,37.42 39.59,37.68 39.59,38.14 39.85,38.39 39.85,39.19 37.95,41.09 37.95,41.95 37.34,42.56 37.34,43.11 37.09,43.36 36.4,43.36 34.8,44.97 30.22,44.97 29.15,46.04 26.96,46.04 26.35,46.65 25.19,46.65 24.47,47.37 24.47,48.01 24.04,48.44 23.64,48.44 v2(23.54,48.54)
  BOTTOM w0.109: CT180.2 24.75,47.75 24.06,48.44 23.63,48.44 v2(23.54,48.54)
SW4_DP2_N1_C: length 5.6
  BOTTOM w0.076: UT1.A3 26.02,42.76 26.18,42.92 26.18,42.97 26.15,42.99 25.7,42.99 25.4,43.29 25.4,43.72 25.09,44.03 25.09,44.25 24.68,44.67 24.68,44.91
  BOTTOM w0.109: 24.68,44.91 24.34,45.25 v4(24.34,45.48) 24.34,46.56 24.43,46.64 24.67,46.64 24.75,46.55 CT180.1
SW4_DP2_N2: length 139.2
  TOP w0.109: v2(146.95,39.11) 147.04,39.2 147.04,39.67 147.1,39.73 UV67.47
  IN4 w0.102: v2(146.95,39.11) 147.03,39.19 147.03,39.32 146.95,39.39 145.72,39.39 145.05,40.06 141.57,40.06 140.95,40.68 139.82,40.68 138.38,42.13 137.58,42.13 136.9,42.81 127.54,42.81 124.57,39.84 116.57,39.84 113.54,42.88 95.35,42.88 93.27,40.8 92.47,40.8 91.41,39.73 89.17,39.73 89.06,39.83 83.87,39.83 83.42,39.37 82,39.37 80.2,41.18 76.56,41.18 76.36,41.38 73.52,41.38 73.02,41.88 71.67,41.88 71.3,41.51 68.39,41.51 67.6,40.73 65.84,40.73 64.97,39.85 56.65,39.85 56.49,40.01 51.01,40.01 50.65,40.38 45.5,40.38 45.23,40.11 43.75,40.11 42.04,41.82 42.04,43.02 38.97,46.09 38.97,47.62 38.1,48.48 29.91,48.48 29.11,49.28 28.44,49.28 27.18,48.02 26.32,48.02 26.22,47.93 26.22,47.74 v2(26.45,47.52)
  BOTTOM w0.109: v2(26.45,47.52) 26.78,47.85 26.78,47.97 26.68,48.07 26.06,48.07 25.93,47.93 25.93,47.36 26.17,47.12 26.17,46.71 CT179.2
SW4_DP2_N2_C: length 3.5
  BOTTOM w0.076: 26.68,44.75 26.68,44.49 26.86,44.32 26.86,43.99 26.88,43.96 27,43.96 27.08,43.88 27.08,43.49 27.05,43.46 26.91,43.46 26.84,43.53 UT1.C1
  BOTTOM w0.109: CT179.1 26.16,46.02 26.16,45.27 v1(26.23,45.2) 26.68,44.75
SW4_DP2_N3: length 139.4
  TOP w0.109: UV67.44 145.9,39.78 145.7,39.58 145.7,38.51 v2(145.59,38.4)
  IN4 w0.102: v2(27.2,46.69) 27.26,46.74 27.26,47.06 27.76,47.57 29.89,47.57 31.23,46.23 32.56,46.23 33.93,47.6 35.56,47.6 36.13,47.03 36.13,46.3 38.51,43.93 38.51,43.11 39.14,42.48 39.14,41.67 41.67,39.15 41.67,38.11 42.12,37.66 42.56,37.66 44.14,39.23 50.09,39.23 50.31,39.02 56.07,39.02 56.64,38.66 57.07,38.66 57.65,39.24 65.24,39.24 66.04,40.03 67.99,40.03 68.2,40.24 72.99,40.24 73.47,40.72 75.58,40.72 76.56,39.74 76.56,38.87 77.61,37.81 81.03,37.81 81.98,38.76 84.34,38.76 84.8,39.22 88.27,39.22 88.86,38.63 92.4,38.63 92.54,38.76 94.63,38.76 97.43,41.56 100.04,41.56 100.21,41.74 103.87,41.74 105.09,40.51 106.46,40.51 106.91,40.96 114.58,40.96 115.88,39.66 115.88,39.43 116.73,38.58 118.44,38.58 119.1,39.23 124.85,39.23 127.72,42.11 136.71,42.11 137.76,41.06 138.58,41.06 141.21,38.42 144.13,38.42 144.62,37.94 145.12,37.94 145.58,38.4 v2(145.59,38.4)
  BOTTOM w0.109: v2(27.2,46.69) 27.29,46.59 CT181.2
SW4_DP2_N3_C: length 2.7
  BOTTOM w0.076: 27.65,44.37 27.65,44.36 27.83,44.18 27.83,44.03 27.77,43.97 27.65,43.97 27.54,43.86 27.54,43.59 27.6,43.54 27.72,43.54 27.76,43.58 UT1.E1
  BOTTOM w0.109: CT181.1 27.33,45.5 27.33,44.69 27.65,44.37
SW4_DP2_P0: length 153.9
  TOP w0.109: UV67.54 149.9,39.83 150.53,39.19 v2(150.53,38.81)
  IN4 w0.102: v2(21.81,47.91) 21.87,47.96 22.03,47.96 22.31,47.69 22.31,47.02 23.9,45.43 23.9,44.69 24.54,44.05 26.49,44.05 27.3,43.24 34.08,43.24 35.3,42.03 35.3,40.2 37.55,37.95 37.55,36.93 37.42,36.8 37.42,35.4 38.69,34.13 46.31,34.13 46.87,34.69 46.87,35.6 47.07,35.81 47.48,35.81 47.74,35.55 49.19,35.55 50.13,34.61 51.39,34.61 52.02,35.25 54.15,35.25 55.56,33.84 57.04,33.84 57.2,33.68 58.08,33.68 58.79,34.4 61.32,34.4 62.8,35.88 72.85,35.88 73.25,36.29 75.03,36.29 76.5,34.82 78.85,34.82 79.21,34.46 80.29,34.46 80.55,34.71 83.76,34.71 84.27,35.22 95.18,35.22 95.99,36.03 98.1,36.03 98.44,36.37 104.59,36.37 107.21,33.75 119.33,33.75 121.92,36.34 127.42,36.34 128.2,37.12 128.69,37.12 130.29,38.72 135.38,38.72 139.07,35.04 142.72,35.04 143.52,34.24 146.14,34.24 146.97,35.07 147.48,35.07 148.27,35.87 148.9,35.87 150.53,37.5 v2(150.53,38.81)
  BOTTOM w0.109: CT186.2 22.22,47.21 22.22,47.77 22.03,47.96 21.87,47.96 v2(21.81,47.91)
SW4_DP2_P0_C: length 6.8
  BOTTOM w0.076: 23.76,43.47 24.01,43.47 24.54,42.95 24.93,42.95 25.29,42.59 25.29,42.2 25.58,41.91 25.68,41.91 25.75,41.84 UT1.A5
  BOTTOM w0.109: 23.76,43.47 v4(23.43,43.8) 22.25,44.98 22.25,46.22 CT186.1
SW4_DP2_P1: length 150.3
  TOP w0.109: UV67.51 148.7,39.8 148.77,39.73 148.77,39.51 149.09,39.19 149.09,38.05 v2(149.08,38.05)
  IN4 w0.102: v2(149.08,38.05) 149,37.97 149,37.63 148.42,37.05 147.78,37.05 147.22,36.49 146.51,36.49 145.43,35.41 144.03,35.41 143.48,35.96 143.48,36.53 143.31,36.69 139.39,36.69 137.69,38.4 137.69,38.56 136.22,40.03 134.48,40.03 134.15,40.35 130.63,40.35 130.19,39.92 129.08,39.92 128.84,40.16 128.22,40.16 125.56,37.51 121.28,37.51 119.73,35.96 118.65,35.96 117.76,36.85 115.92,36.85 114.86,35.79 107.8,35.79 106.71,36.89 106.71,38.08 106.33,38.46 102.69,38.46 102.15,38.99 97.3,38.99 94.7,36.39 86.5,36.39 85.85,37.03 82.7,37.03 81.66,36 76.99,36 75.52,37.47 73.65,37.47 72.98,38.13 67.71,38.13 67.53,37.95 66.85,37.95 66.38,37.48 61.8,37.48 60.76,36.44 59.83,36.44 59.76,36.36 55.92,36.36 55.02,37.27 49.52,37.27 49.33,37.46 47.4,37.46 47.17,37.23 45.32,37.23 44.73,36.63 44.73,36.28 43.96,35.51 41.7,35.51 40.35,36.86 39.62,36.86 39.03,37.45 39.03,38.37 39.29,38.62 39.29,38.96 37.39,40.85 37.39,41.72 36.31,42.8 36.17,42.8 34.57,44.41 29.99,44.41 28.92,45.48 26.72,45.48 26.12,46.09 24.95,46.09 23.91,47.14 23.91,47.78 23.81,47.88 v2(23.54,47.88)
  BOTTOM w0.109: CT183.2 24.1,47.03 24.24,47.17 24.24,47.54 23.86,47.92 23.57,47.92 v2(23.54,47.88)
SW4_DP2_P1_C: length 5.6
  BOTTOM w0.076: UT1.B3 26.09,42.53 26.04,42.53 25.74,42.53 25.63,42.65 25.63,42.85 25.25,43.23 25.25,43.65 24.94,43.97 24.94,44.19 24.85,44.28 24.58,44.28 24.57,44.29 ; 24.31,44.55 24.33,44.53
  BOTTOM w0.109: 24.31,44.55 23.83,45.03 CT183.1 ; 24.33,44.53 24.57,44.29
SW4_DP2_P2: length 139.3
  TOP w0.109: v2(147.66,39.11) 147.55,39.22 147.55,39.76 147.5,39.81 UV67.48
  IN4 w0.102: v2(26.36,48.58) 26.95,48.58 28.2,49.84 29.34,49.84 30.14,49.04 38.33,49.04 39.52,47.85 39.52,46.32 42.6,43.25 42.6,42.05 43.98,40.67 45,40.67 45.26,40.94 50.88,40.94 51.25,40.57 56.72,40.57 56.88,40.41 64.73,40.41 65.61,41.28 67.37,41.28 68.16,42.07 71.06,42.07 71.44,42.44 73.25,42.44 73.75,41.94 76.6,41.94 76.8,41.74 80.43,41.74 82.23,39.93 83.18,39.93 83.64,40.39 89.3,40.39 89.4,40.29 91.18,40.29 92.24,41.36 93.04,41.36 95.12,43.44 113.77,43.44 116.81,40.4 124.34,40.4 127.31,43.37 137.13,43.37 137.81,42.69 138.61,42.69 140.05,41.24 141.18,41.24 141.81,40.62 145.28,40.62 145.95,39.95 147.19,39.95 147.59,39.55 147.59,39.19 v2(147.66,39.11)
  BOTTOM w0.109: v2(26.36,48.58) 25.84,48.58 25.41,48.15 25.41,47.14 25.65,46.9 25.65,46.66 CT185.2
SW4_DP2_P2_C: length 3.6
  BOTTOM w0.076: UT1.C2 26.62,43.52 26.62,43.84 26.7,43.92 26.7,44.25 26.66,44.3 26.4,44.3 26.39,44.31
  BOTTOM w0.109: 26.39,44.31 25.65,45.06 CT185.1
SW4_DP2_P3: length 139.5
  TOP w0.109: UV67.45 146.3,40 146.41,39.88 146.41,39.56 146.22,39.37 146.22,38.4 v2(146.25,38.37)
  IN4 w0.102: v2(27.86,46.69) 27.82,46.73 27.82,46.83 28,47.01 29.66,47.01 31,45.67 32.79,45.67 34.17,47.05 35.33,47.05 35.57,46.8 35.57,46.07 37.95,43.7 37.95,42.88 38.58,42.25 38.58,41.44 41.11,38.92 41.11,37.87 41.88,37.1 42.8,37.1 44.37,38.68 49.86,38.68 50.08,38.46 55.91,38.46 56.48,38.1 57.3,38.1 57.88,38.68 65.47,38.68 66.27,39.47 68.22,39.47 68.43,39.68 73.22,39.68 73.7,40.16 75.35,40.16 76,39.51 76,38.64 77.38,37.25 81.26,37.25 82.22,38.21 84.57,38.21 85.03,38.66 88.04,38.66 88.63,38.07 92.64,38.07 92.78,38.21 94.86,38.21 97.66,41 100.27,41 100.45,41.18 103.64,41.18 104.86,39.96 106.69,39.96 107.14,40.4 114.35,40.4 115.32,39.43 115.32,39.2 116.5,38.02 118.67,38.02 119.33,38.67 125.08,38.67 127.95,41.55 136.48,41.55 137.53,40.5 138.35,40.5 140.98,37.86 143.9,37.86 144.39,37.38 145.35,37.38 146.25,38.28 v2(146.25,38.37)
  BOTTOM w0.109: v2(27.86,46.69) 27.81,46.63 27.81,46.46 27.87,46.4 CT182.2
SW4_DP2_P3_C: length 2.6
  BOTTOM w0.076: 28.17,44.38 28.17,44.36 27.98,44.18 27.98,43.44 UT1.E2
  BOTTOM w0.109: CT182.1 27.85,45.52 27.85,44.9 28.17,44.59 28.17,44.38
SW_1PH: length 2.6
  TOP w0.203: PL1800.2 217.68,123.92 v2(217.63,123.97)
  BOTTOM w0.109: v2(217.63,123.97) v1(217.63,124.97)
  BOTTOM w0.203: PR1102.2 217.63,123.71 v2(217.63,123.97)
SW_TBT_A_USB20_N1: length 79.8
  IN2 w0.094: v2(16.95,44.21) 17.64,44.21 17.92,43.93 17.92,42.74 16.85,41.67 16.85,40.49 14.19,37.84 13.55,37.84 8.59,32.87 8.59,30.92 9.01,30.5 9.34,30.5 11.45,28.39 11.45,28.03 12.89,26.6 18.68,26.6 19.64,27.55 19.64,28.46 20.97,29.8 28.31,29.8 29.87,31.36 36.66,31.36 38.21,29.81 40.14,29.81 40.85,30.52 47.27,30.52 47.7,30.09 48.27,30.09 48.98,29.38 52.11,29.38 52.91,28.58 57.3,28.58 57.72,28.16 57.89,28.16 v2(58.16,28.43)
  BOTTOM w0.102: RT121.1 15.63,46.48 15.79,46.48 16.05,46.21 16.05,44.37 16.44,43.98 16.72,43.98 v2(16.95,44.21) ; UT5.A2 57.56,28.34 57.56,28.27 57.77,28.06 57.91,28.06 58.16,28.31 v2(58.16,28.43)
SW_TBT_A_USB20_N1_R: length 9
  TOP w0.102: v2(6.69,47.57) 6.64,47.52 JUSBC1.B7
  BOTTOM w0.102: v2(6.69,47.57) 6.71,47.57 6.9,47.37 7.49,47.37 7.55,47.31 v4(8.84,47.31) 9.92,47.31 10.69,46.55 10.99,46.55 11.42,46.99 DT7.4 DT7.7 14.21,46.99 RT121.2
SW_TBT_A_USB20_N2: length 101.9
  TOP w0.102: RT122.2 15.21,46.26 15.31,46.36 15.67,46.36 15.79,46.24 15.79,45.54 16.12,45.21 16.38,45.21 16.48,45.11 16.48,45.07 v2(16.64,44.91)
  IN2 w0.094: v2(16.64,44.91) 16.41,45.14 16.2,45.14 16.05,45 16.05,40.82 13.86,38.63 13.21,38.63 7.76,33.17 7.76,30.28 9.92,28.11 10.13,28.11 10.3,28.28 v2(10.3,28.39) ; v2(5.13,25.63) 5.13,25.49 5.27,25.35 6.74,25.35 7.31,24.77 7.31,22.73 7.73,22.32 11.49,22.32 12.36,21.44 14.58,21.44 16.74,19.28 16.84,19.28 18.2,17.93 24.18,17.93 26.65,20.4 30.52,20.4 32.06,21.94 35.22,21.94 36.57,20.59 36.57,19.92 38.39,18.09 40.24,18.09 41.03,17.3 44.56,17.3 45.25,17.98 45.25,19.09 46.48,20.31 53.05,20.31 54.04,21.3 54.95,21.3 57.41,23.77 57.41,25.6 56.62,26.39 56.62,26.86 56.75,26.98 56.75,27.01 56.75,27.01 v2(56.56,27.22)
  IN4 w0.102: v2(10.3,28.39) 10.3,28.27 10.15,28.12 9.35,28.12 8.67,27.43 8.67,26.95 7.07,25.36 5.25,25.36 5.13,25.48 v2(5.13,25.63)
  BOTTOM w0.102: v2(56.56,27.22) 56.73,27.39 56.73,27.49 56.62,27.6 56.62,27.92 56.51,28.03 UT5.C1
SW_TBT_A_USB20_N2_R: length 7.4
  TOP w0.102: RT122.1 14.18,45.99 DT8.2 DT8.8 11.89,45.99 11.75,46.13 11.33,46.13 10.88,46.58 10.21,46.58 9.86,46.93 8.2,46.93 8.04,46.78 JUSBC1.A7
SW_TBT_A_USB20_P1: length 79.9
  IN2 w0.094: v2(58.28,27.89) 58.21,27.96 57.64,27.96 57.22,28.38 52.83,28.38 52.03,29.18 48.9,29.18 48.19,29.89 47.62,29.89 47.19,30.33 40.93,30.33 40.22,29.62 38.13,29.62 36.58,31.16 29.95,31.16 28.39,29.61 21.06,29.61 19.83,28.38 19.83,27.47 18.76,26.4 12.81,26.4 11.26,27.95 11.26,28.31 9.26,30.3 8.93,30.3 8.39,30.84 8.39,32.95 13.47,38.03 14.11,38.03 16.66,40.58 16.66,41.75 17.73,42.82 17.73,43.85 17.56,44.02 17.33,44.02 16.95,43.64 v2(16.95,43.55)
  BOTTOM w0.102: UT5.A1 57.53,27.87 58.26,27.87 v2(58.28,27.89) ; RT120.1 15.63,46.29 15.71,46.29 15.86,46.13 15.86,44.29 16.36,43.79 16.72,43.79 v2(16.95,43.55)
SW_TBT_A_USB20_P1_R: length 9
  TOP w0.102: JUSBC1.B6 5.95,47.02 6.64,47.02 v2(6.69,46.98)
  BOTTOM w0.102: v2(6.69,46.98) 6.71,46.98 6.9,47.18 7.42,47.18 7.47,47.12 8.51,47.12 8.54,47.09 9.08,47.09 9.11,47.12 9.84,47.12 10.61,46.36 11.09,46.36 11.47,45.99 DT7.2 DT7.8 14.18,45.99 RT120.2
SW_TBT_A_USB20_P2: length 101.9
  TOP w0.102: RT123.2 15.56,46.55 15.75,46.55 15.98,46.32 15.98,45.62 16.2,45.41 16.48,45.41 v2(16.64,45.57)
  IN2 w0.094: v2(5.13,24.96) 5.31,25.15 6.66,25.15 7.12,24.69 7.12,22.65 7.65,22.12 11.41,22.12 12.28,21.25 14.5,21.25 16.66,19.09 16.76,19.09 18.11,17.74 24.26,17.74 26.73,20.21 30.6,20.21 32.14,21.74 35.14,21.74 36.37,20.51 36.37,19.83 38.31,17.89 40.15,17.89 40.94,17.1 44.65,17.1 45.44,17.9 45.44,19 46.56,20.12 53.13,20.12 54.12,21.11 55.03,21.11 57.61,23.69 57.61,25.68 56.81,26.48 56.81,26.78 56.96,26.92 56.96,27 v2(57.15,27.19) ; v2(10.3,27.73) 10.11,27.93 9.83,27.93 7.56,30.2 7.56,33.26 13.13,38.83 13.78,38.83 15.86,40.91 15.86,45.08 16.12,45.34 16.42,45.34 v2(16.64,45.57)
  IN4 w0.102: v2(10.3,27.73) 10.11,27.93 9.43,27.93 8.85,27.35 8.85,26.88 7.15,25.17 5.33,25.17 v2(5.13,24.96)
  BOTTOM w0.102: v2(57.15,27.19) 56.92,27.42 56.92,27.57 56.81,27.68 56.81,27.98 UT5.B1
SW_TBT_A_USB20_P2_R: length 7.2
  TOP w0.102: JUSBC1.A6 8.04,47.28 8.2,47.12 9.94,47.12 10.29,46.77 11.23,46.77 11.45,46.99 DT8.7 DT8.4 14.21,46.99 RT123.1
SW_TBT_B_USB20_N1: length 90.5
  IN2 w0.094: v2(13.53,54.41) 13.45,54.33 13.37,54.33 13.21,54.5 13.21,54.73 13.34,54.86 13.85,54.86 16.44,52.28 16.44,48.59 13.95,46.11 13.95,44.69 14.88,43.76 14.88,41.06 13.45,39.63 12.8,39.63 9.77,36.6 8.95,36.6 6.76,34.41 6.76,29.83 11.14,25.44 13.74,25.44 14.78,24.41 16.13,24.41 17.16,25.44 18.46,25.44 19.63,24.27 28.43,24.27 31.71,27.55 32.78,27.55 33.99,28.75 40.15,28.75 40.5,28.4 41.29,28.4 41.54,28.65 44.23,28.65 44.8,29.22 45.79,29.22 46.03,28.99 47.88,28.99 48.52,28.35 50.66,28.35 51.55,27.47 52.28,27.47 52.51,27.7 53.54,27.7 53.64,27.6 53.64,27.46 53.57,27.4 53.24,27.4 53.16,27.32 53.16,27.2 v2(53.22,27.14)
  BOTTOM w0.102: UT5.H1 53.87,27.8 53.22,27.16 v2(53.22,27.14) ; v2(13.53,54.41) 13.27,54.67 13.27,54.88 13.05,55.11 12.74,55.11 12.64,55.21 12.64,55.41 RT540.1
SW_TBT_B_USB20_N1_R: length 12.3
  TOP w0.102: JUSBC1.1B7 6.64,63.73 v2(6.69,63.77)
  BOTTOM w0.102: RT540.2 13.05,57.58 13.15,57.68 DT11.7 DT11.4 13.15,59.25 12.83,59.57 12.83,60.62 12.05,61.4 12.05,61.45 11.56,61.94 11.51,61.94 10.1,63.35 7.31,63.35 7.06,63.59 6.86,63.59 v2(6.69,63.77)
SW_TBT_B_USB20_N2: length 96.7
  TOP w0.102: RT539.2 12.44,55.43 12.44,55.3 12.25,55.12 11.83,55.12 11.57,54.87 11.57,54.48 v2(11.29,54.2)
  IN2 w0.094: v2(51.57,27.02) 51.48,27.11 51.32,27.11 51.21,26.99 51.21,26.7 51.1,26.59 50.48,26.59 49.33,27.75 44.99,27.75 44.93,27.81 42.65,27.81 41.85,27 40.66,27 40.2,27.46 39.65,27.46 39.57,27.54 33.94,27.54 33.31,26.91 32.15,26.91 31.02,25.79 31.02,24.57 30.36,23.9 29.02,23.9 28.7,23.59 28.29,23.59 27.79,23.09 25.57,23.09 24.66,22.18 23.54,22.18 23.04,22.68 21.23,22.68 20.16,21.61 18.6,21.61 18.19,22.01 16.47,22.01 15.01,23.47 13.07,23.47 11.8,24.75 10.97,24.75 6.13,29.59 6.13,34.64 8.7,37.2 9.52,37.2 12.55,40.23 13.2,40.23 14.28,41.31 14.28,42.36 13.61,43.02 10.04,43.02 7.67,45.4 7.67,49.1 8.57,50 8.57,53.41 9.94,54.79 11.72,54.79 11.8,54.7 11.8,54.58 11.71,54.49 11.29,54.49 11.19,54.39 11.19,54.29 v2(11.29,54.2)
  BOTTOM w0.102: v2(51.57,27.02) 51.57,26.88 51.65,26.81 51.91,26.81 52.07,26.97 52.07,27.24 52.6,27.77 52.6,27.98 52.51,28.07 52.4,28.07 UT5.L1
SW_TBT_B_USB20_N2_R: length 10.4
  TOP w0.102: RT539.1 12.14,56.82 12.14,57.05 12.04,57.15 11.9,57.15 11.83,57.23 11.83,57.43 11.91,57.52 12.08,57.52 12.15,57.59 DT12.2 DT12.8 12.15,59.24 12.49,59.59 12.49,60.24 v4(11.15,61.58) 9.88,62.86 8.33,62.86 8.09,63.1 7.93,63.1 7.81,62.97 JUSBC1.1A7
SW_TBT_B_USB20_P1: length 90.4
  IN2 w0.094: v2(53.83,27.13) 53.83,27.68 53.62,27.89 52.43,27.89 52.2,27.66 51.63,27.66 50.74,28.55 48.6,28.55 47.96,29.18 46.11,29.18 45.87,29.42 44.72,29.42 44.15,28.85 41.46,28.85 41.21,28.6 40.58,28.6 40.23,28.95 33.9,28.95 32.7,27.75 31.63,27.75 28.35,24.46 19.72,24.46 18.54,25.63 17.08,25.63 16.05,24.6 14.86,24.6 13.82,25.64 11.23,25.64 6.96,29.91 6.96,34.33 9.03,36.4 9.85,36.4 12.88,39.43 13.53,39.43 15.08,40.98 15.08,43.84 14.15,44.77 14.15,46.03 16.63,48.51 16.63,52.36 13.93,55.06 13.26,55.06 13.01,54.81 13.01,54.61 v2(12.81,54.41)
  BOTTOM w0.102: RT538.1 12.45,55.42 12.45,55.14 12.66,54.92 12.97,54.92 13.08,54.8 13.08,54.68 13.04,54.64 v2(12.81,54.41) ; UT5.G1 53.83,27.5 v2(53.83,27.13)
SW_TBT_B_USB20_P1_R: length 12.3
  TOP w0.102: v2(6.69,63.18) 6.64,63.22 5.95,63.22 JUSBC1.1B6
  BOTTOM w0.102: v2(6.69,63.18) 6.69,63.32 6.77,63.4 6.98,63.4 7.23,63.16 10.02,63.16 v4(11.67,61.51) 12.64,60.54 12.64,59.52 12.56,59.44 12.23,59.44 12.15,59.36 DT11.2 DT11.8 12.15,57.16 12.05,57.06 RT538.2
SW_TBT_B_USB20_P2: length 96.8
  TOP w0.102: v2(12,54.2) 11.76,54.43 11.76,54.79 11.9,54.93 12.33,54.93 12.63,55.22 12.63,55.39 RT541.2
  IN2 w0.094: v2(12,54.2) 12,54.78 11.8,54.98 9.86,54.98 8.37,53.49 8.37,50.08 7.47,49.18 7.47,45.32 9.96,42.83 13.53,42.83 14.08,42.28 14.08,41.39 13.12,40.42 12.47,40.42 9.44,37.4 8.62,37.4 5.94,34.72 5.94,29.51 10.89,24.55 11.72,24.55 12.99,23.28 14.93,23.28 16.39,21.82 18.11,21.82 18.52,21.41 20.24,21.41 21.31,22.48 22.96,22.48 23.46,21.99 24.74,21.99 25.65,22.9 27.87,22.9 28.37,23.39 28.78,23.39 29.1,23.71 30.44,23.71 31.22,24.49 31.22,25.71 32.23,26.72 33.39,26.72 34.02,27.34 39.49,27.34 39.57,27.27 40.12,27.27 40.58,26.81 41.93,26.81 42.73,27.62 44.84,27.62 44.9,27.56 49.24,27.56 50.4,26.4 v2(51.6,26.4)
  BOTTOM w0.102: UT5.K1 52.8,27.96 52.8,27.69 52.26,27.16 52.26,26.89 51.99,26.62 51.82,26.62 v2(51.6,26.4)
