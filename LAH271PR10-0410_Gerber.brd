# Allegro board LAH271PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG_CRX_GTX_N1: length 40
  TOP w0.102: UC1.E11 221.14,94.18 v2(220.79,93.84)
  BOTTOM w0.076: 217.53,94.61 217.55,94.59 220.17,94.59 220.6,94.16 220.6,94.01 220.77,93.84 v2(220.79,93.84)
  BOTTOM w0.102: CV430.2 184.48,98.16 185.75,98.16 185.96,97.95 187.69,97.95 188.99,96.65 191.54,96.65 191.8,96.4 v4(192.79,96.4) 193.94,96.4 194.55,95.79 196.79,95.79 197.36,95.22 199.47,95.22 200.41,96.16 207.48,96.16 208.43,95.22 215.5,95.22 216.11,94.61 217.53,94.61
PEG_CRX_GTX_N2: length 38.5
  TOP w0.102: v2(220.81,94.71) 220.81,94.73 UC1.E12
  BOTTOM w0.076: 217.16,95.26 217.18,95.26 217.2,95.28 217.58,95.28 217.73,95.43 218.11,95.43 218.73,94.82 220.19,94.82 220.71,94.3 220.89,94.3 221.02,94.43 221.02,94.5 v2(220.81,94.71)
  BOTTOM w0.102: 217.16,95.26 216.28,95.26 215.87,95.67 208.79,95.67 207.81,96.65 200.12,96.65 199.14,95.67 197.5,95.67 196.96,96.21 195.75,96.21 194.86,97.11 192.06,97.11 191.38,97.79 v4(189.93,97.79) 188.92,97.79 187.56,99.16 186.88,99.16 CV432.2
PEG_CRX_GTX_N3: length 39.7
  TOP w0.102: UC1.E13 221.14,95.81 v2(220.82,95.49)
  BOTTOM w0.076: v2(220.82,95.49) 220.63,95.68 220.63,95.87 220.47,96.03 218.36,96.03 218.21,96.18 217.6,96.18 217.58,96.2 217.56,96.2
  BOTTOM w0.102: CV434.2 184.26,100.69 185.07,100.69 185.25,100.51 187.46,100.51 189.06,98.91 192.88,98.91 193.78,98.01 196.78,98.01 196.91,97.88 v4(203.08,97.88) 208,97.88 209.4,96.49 216.74,96.49 217.04,96.2 217.56,96.2
PEG_CRX_GTX_N4: length 39
  TOP w0.102: v2(221.45,97.05) 221.45,96.88 221.2,96.63 UC1.E14
  BOTTOM w0.076: 217.31,97.2 217.33,97.2 217.34,97.18 218.26,97.18 219.04,96.4 221.49,96.4 221.73,96.64 221.73,96.94 221.62,97.05 v2(221.45,97.05)
  BOTTOM w0.102: CV436.2 186.91,101.71 188.48,101.71 190.11,100.08 v4(192.61,100.08) 195.57,100.08 197.09,98.56 204.99,98.56 205.03,98.6 205.67,98.6 205.71,98.56 208.41,98.56 209.77,97.2 217.31,97.2
PEG_CRX_GTX_N5: length 40.1
  TOP w0.102: v2(220.81,97.02) 221.14,97.35 UC1.E15
  BOTTOM w0.076: 216.6,97.8 216.62,97.8 216.64,97.78 218.42,97.78 218.65,97.56 220.35,97.56 220.61,97.3 220.61,97.22 v2(220.81,97.02)
  BOTTOM w0.102: CV438.2 184.26,103.14 184.93,103.14 185.08,102.99 188.24,102.99 190.39,100.84 195.72,100.84 196.37,100.19 197.04,100.19 197.08,100.23 197.68,100.23 197.72,100.19 202,100.19 202.76,99.44 208.7,99.44 210.34,97.8 216.6,97.8
PEG_CRX_GTX_N6: length 38.8
  TOP w0.102: UC1.E16 221.14,98.09 v2(221.44,97.79)
  BOTTOM w0.076: v2(221.44,97.79) 221.44,97.84 221.19,98.09 221.06,98.09 220.74,97.76 218.87,97.76 218.04,98.6 217.78,98.6 217.47,98.28 216.58,98.28 216.56,98.26 216.54,98.26
  BOTTOM w0.102: CV440.2 186.85,104.02 188.02,104.02 190.76,101.28 v4(195.42,101.28) 201.67,101.28 203.06,99.9 208.96,99.9 210.6,98.26 216.54,98.26
PEG_CRX_GTX_N7: length 40.9
  TOP w0.102: v2(220.81,98.57) 221.14,98.9 UC1.E17
  BOTTOM w0.076: 216.52,98.88 216.54,98.88 216.56,98.9 217.33,98.9 217.41,98.98 218.34,98.98 219.24,98.09 220.43,98.09 220.6,98.25 220.6,98.36 v2(220.81,98.57)
  BOTTOM w0.102: 216.52,98.88 210.92,98.88 209.29,100.51 v4(207.1,100.51) 205.57,100.51 203.52,102.56 199.04,102.56 199,102.52 198.41,102.52 198.38,102.56 198.08,102.56 197.5,103.14 194.34,103.14 192.52,104.96 187.95,104.96 187.56,105.35 184.31,105.35 CV442.2
PEG_CRX_GTX_N8: length 39.4
  TOP w0.102: UC1.F18 221.79,99.71 v2(221.46,99.39)
  BOTTOM w0.076: 216.84,99.52 216.86,99.52 216.88,99.54 217.28,99.54 217.7,99.96 218.09,99.96 218.73,99.32 220.2,99.32 220.59,98.92 221.09,98.92 221.26,99.09 221.26,99.18 v2(221.46,99.39)
  BOTTOM w0.102: 216.84,99.52 211.3,99.52 209.49,101.32 v4(208.38,101.32) 205.71,101.32 203.87,103.16 201.43,103.16 200.81,103.78 200.1,103.78 200.06,103.74 199.48,103.74 199.44,103.78 194.79,103.78 192.97,105.6 188.68,105.6 187.72,106.56 186.83,106.56 CV444.2
PEG_CRX_GTX_N9: length 41.1
  TOP w0.102: UC1.D19 220.49,100.54 v2(220.12,100.17)
  BOTTOM w0.076: 216.77,100.26 216.79,100.26 216.81,100.28 217.12,100.28 217.26,100.42 219.12,100.42 219.3,100.6 220.28,100.6 220.47,100.41 220.47,100.26 220.38,100.17 v2(220.12,100.17)
  BOTTOM w0.102: 216.77,100.26 211.61,100.26 209.8,102.06 206.08,102.06 203.75,104.39 195.32,104.39 193.3,106.4 190.36,106.4 190.32,106.37 189.73,106.37 189.7,106.39 189.7,106.4 188.91,106.4 187.49,107.83 184.35,107.83 CV446.2
PEG_CRX_GTX_N10: length 40.3
  TOP w0.102: v2(222.12,100.97) 221.79,101.3 UC1.F20
  BOTTOM w0.076: 216.82,101.12 216.84,101.12 216.86,101.1 217.65,101.1 217.75,101 218.74,101 219.09,101.35 221.01,101.35 221.17,101.51 221.7,101.51 221.92,101.3 221.92,101.17 v2(222.12,100.97)
  BOTTOM w0.102: 216.82,101.12 211.99,101.12 210.09,103.01 207.05,103.01 204.85,105.22 195.92,105.22 193.94,107.19 191.73,107.19 190.26,108.67 189.32,108.67 189.28,108.7 188.61,108.7 188.57,108.67 188.18,108.67 187.48,109.37 186.8,109.37 CV448.2
PEG_CRX_GTX_N11: length 41.6
  TOP w0.102: UC1.D21 220.49,102.07 v2(220.16,101.75)
  BOTTOM w0.076: 217.31,101.54 217.32,101.56 217.57,101.56 217.77,101.75 218.78,101.75 219.14,102.12 220.33,102.12 220.46,101.98 220.46,101.82 220.39,101.75 v2(220.16,101.75)
  BOTTOM w0.102: 217.31,101.54 212.22,101.54 210.32,103.43 207.21,103.43 205.02,105.63 196.26,105.63 193.28,108.6 v4(191.96,108.6) 190.92,108.6 189.7,109.82 188.45,109.82 187.96,110.32 184.37,110.32 CV450.2
PEG_CRX_GTX_N12: length 40.1
  TOP w0.102: UC1.F22 221.79,103 v2(221.46,103.32)
  BOTTOM w0.076: 217.56,102.42 217.58,102.42 217.6,102.4 218.29,102.4 218.49,102.61 220.67,102.61 221.07,103 221.37,103 221.46,103.09 v2(221.46,103.32)
  BOTTOM w0.102: CV452.2 186.85,111.98 187.57,111.98 188.94,110.61 191.01,110.61 192.01,109.61 193.49,109.61 196.65,106.44 198.49,106.44 198.53,106.48 199.11,106.48 199.15,106.44 205.39,106.44 207.55,104.28 210.73,104.28 212.59,102.42 217.56,102.42
PEG_CRX_GTX_N13: length 42.8
  TOP w0.102: UC1.D23 220.49,103.54 220.27,103.32 v2(220.16,103.32)
  BOTTOM w0.076: 217.7,103.46 217.72,103.44 218.38,103.44 218.85,102.97 220.36,102.97 220.47,103.08 220.47,103.23 220.38,103.32 v2(220.16,103.32)
  BOTTOM w0.102: CV454.2 184.32,113.07 184.99,113.07 185.09,113.16 186.91,113.16 187.19,113.44 188.06,113.44 188.53,112.97 188.53,112.13 189.43,111.23 191.42,111.23 191.8,110.86 195.24,110.86 195.28,110.9 195.86,110.9 195.9,110.86 v4(197.55,110.86) 198.81,110.86 200.05,109.62 202.33,109.62 203.76,108.19 204.7,108.19 207.89,105 211.13,105 212.67,103.46 217.7,103.46
PEG_CRX_GTX_N14: length 44
  TOP w0.102: v2(222.11,104.88) 222.11,104.82 UC1.F24
  BOTTOM w0.076: 219.58,103.86 219.6,103.88 221.31,103.88 221.92,104.49 221.92,104.7 v2(222.11,104.88)
  BOTTOM w0.102: CV456.2 186.57,114.15 187.34,114.15 187.75,114.56 188.14,114.56 188.49,114.21 188.49,113.6 189.68,112.42 v4(190.79,112.42) 194.76,112.42 195.2,111.98 198.51,111.98 200.47,110.02 203.62,110.02 204.36,110.76 205.08,110.76 205.6,110.24 205.6,107.86 208.02,105.44 211.33,105.44 212.91,103.86 219.58,103.86
PEG_CRX_GTX_N15: length 45.3
  TOP w0.102: UC1.D25 220.49,105.22 v2(220.16,104.9)
  BOTTOM w0.076: v2(220.16,104.9) 220.37,104.9 220.45,104.82 220.45,104.61 220.33,104.49 219.24,104.49 218.93,104.8 218.93,104.83 218.91,104.85
  BOTTOM w0.102: CV458.2 184.33,115.52 184.93,115.52 185.03,115.62 187.29,115.62 187.48,115.42 188.42,115.42 189.42,114.42 189.42,113.84 189.91,113.35 195.01,113.35 195.52,112.85 196.37,112.85 196.41,112.88 196.99,112.88 197.03,112.85 198.93,112.85 200.85,110.93 203.16,110.93 203.82,111.59 205.57,111.59 206.53,110.62 206.53,108.05 208.28,106.29 211.86,106.29 213.48,104.67 216.78,104.67 217.39,105.28 218.48,105.28 218.91,104.85
PEG_CRX_GTX_P0: length 38.3
  TOP w0.102: UC1.F10 221.79,93.41 v2(221.46,93.09)
  BOTTOM w0.076: v2(221.46,93.09) 221.08,93.47 218.8,93.47 218.27,93.99 217.6,93.99 217.58,94.01 217.56,94.01
  BOTTOM w0.102: 217.56,94.01 215.44,94.01 214.83,94.62 207.78,94.62 206.9,95.49 200.8,95.49 199.93,94.62 197.11,94.62 196.6,95.13 v4(195.94,95.13) 194.63,95.13 194.11,94.61 193.49,94.61 193.45,94.64 192.71,94.64 192.67,94.61 192.41,94.61 190.96,96.05 188.47,96.05 187.75,96.77 186.84,96.77 CV427.2
PEG_CRX_GTX_P1: length 40
  TOP w0.102: UC1.D11 220.49,94.2 v2(220.13,93.85)
  BOTTOM w0.076: v2(220.13,93.85) 220.35,93.85 220.45,93.95 220.45,94.1 220.11,94.44 217.56,94.44 217.54,94.42 217.53,94.42
  BOTTOM w0.102: 217.53,94.42 216.03,94.42 215.42,95.03 208.35,95.03 207.4,95.97 200.49,95.97 199.55,95.03 197.28,95.03 196.71,95.6 194.47,95.6 193.86,96.21 193.12,96.21 193.08,96.17 192.41,96.17 192.37,96.21 191.72,96.21 191.46,96.46 188.92,96.46 187.62,97.76 185.89,97.76 185.67,97.97 184.37,97.97 184.13,97.73 CV429.2
PEG_CRX_GTX_P2: length 38.6
  TOP w0.102: UC1.F12 221.79,94.98 v2(221.48,94.67)
  BOTTOM w0.076: v2(221.48,94.67) 221.08,95.07 220.61,95.07 220.51,94.97 218.79,94.97 218.18,95.59 217.67,95.59 217.52,95.44 217.2,95.44 217.18,95.46 217.16,95.46
  BOTTOM w0.102: CV431.2 186.83,99.35 187.64,99.35 189,97.98 189.59,97.98 189.63,98.02 190.22,98.02 190.26,97.98 191.45,97.98 192.14,97.3 194.94,97.3 195.83,96.4 197.03,96.4 197.58,95.86 199.06,95.86 200.04,96.84 207.89,96.84 208.75,95.99 208.87,95.86 215.95,95.86 216.36,95.46 217.16,95.46
PEG_CRX_GTX_P3: length 39.7
  TOP w0.102: UC1.D13 220.49,95.8 v2(220.17,95.48)
  BOTTOM w0.076: 217.56,96.01 217.58,96.01 217.6,96.03 218.15,96.03 218.29,95.88 220.4,95.88 220.48,95.8 220.48,95.61 220.36,95.48 v2(220.17,95.48)
  BOTTOM w0.102: CV433.2 184.37,100.5 184.99,100.5 185.17,100.32 187.38,100.32 188.98,98.72 192.8,98.72 193.7,97.82 196.71,97.82 196.83,97.69 202.74,97.69 202.78,97.65 203.41,97.65 203.44,97.69 207.92,97.69 209.32,96.3 216.66,96.3 216.96,96.01 217.56,96.01
PEG_CRX_GTX_P4: length 39
  TOP w0.102: UC1.F14 222.07,96.92 v2(222.07,97.04)
  BOTTOM w0.076: 217.31,97.01 217.33,97.01 217.34,97.03 218.19,97.03 218.98,96.24 221.55,96.24 221.88,96.58 221.88,96.85 v2(222.07,97.04)
  BOTTOM w0.102: 217.31,97.01 209.69,97.01 208.32,98.37 v4(205.35,98.37) 197.01,98.37 195.49,99.89 192.94,99.89 192.9,99.85 192.31,99.85 192.27,99.89 190.03,99.89 188.4,101.52 186.8,101.52 CV435.2
PEG_CRX_GTX_P5: length 40
  TOP w0.102: v2(220.16,97.02) 220.49,97.35 UC1.D15
  BOTTOM w0.076: v2(220.16,97.02) 220.4,97.02 220.46,97.08 220.46,97.24 220.29,97.41 218.58,97.41 218.36,97.63 216.64,97.63 216.62,97.61 216.6,97.61
  BOTTOM w0.102: CV437.2 184.37,102.95 184.85,102.95 185,102.8 188.16,102.8 190.31,100.65 195.64,100.65 196.29,100 v4(197.37,100) 201.92,100 202.68,99.24 208.63,99.24 210.26,97.61 216.6,97.61
PEG_CRX_GTX_P6: length 38.8
  TOP w0.102: UC1.F16 221.47,98.52 v2(221.47,98.58)
  BOTTOM w0.076: 216.54,98.45 216.56,98.45 216.58,98.43 217.4,98.43 217.72,98.75 218.11,98.75 218.94,97.92 220.68,97.92 221,98.24 221.12,98.24 v2(221.47,98.58)
  BOTTOM w0.102: 216.54,98.45 210.68,98.45 209.04,100.09 203.14,100.09 201.75,101.47 195.75,101.47 195.71,101.51 195.11,101.51 195.07,101.47 190.84,101.47 188.1,104.21 186.86,104.21 CV439.2
PEG_CRX_GTX_P7: length 40.9
  TOP w0.102: v2(220.19,98.6) 220.24,98.6 220.49,98.84 UC1.D17
  BOTTOM w0.076: 216.52,99.07 216.54,99.07 216.56,99.05 217.26,99.05 217.34,99.13 218.41,99.13 219.3,98.24 220.37,98.24 220.45,98.32 220.45,98.56 220.4,98.6 v2(220.19,98.6)
  BOTTOM w0.102: 216.52,99.07 211,99.07 209.37,100.7 207.43,100.7 207.39,100.74 206.81,100.74 206.77,100.7 205.65,100.7 203.6,102.75 v4(198.71,102.75) 198.16,102.75 197.58,103.33 194.42,103.33 192.6,105.15 188.03,105.15 187.63,105.54 184.18,105.54 183.97,105.76 CV441.2
PEG_CRX_GTX_P8: length 39.4
  TOP w0.102: v2(220.81,99.44) 221.14,99.76 UC1.E18
  BOTTOM w0.076: v2(220.81,99.44) 221.02,99.44 221.1,99.35 221.1,99.16 221.03,99.08 220.65,99.08 220.26,99.47 218.79,99.47 218.15,100.11 217.64,100.11 217.22,99.69 216.88,99.69 216.86,99.71 216.84,99.71
  BOTTOM w0.102: CV443.2 186.91,106.75 187.8,106.75 188.76,105.79 193.05,105.79 194.87,103.97 v4(199.77,103.97) 200.89,103.97 201.51,103.35 203.95,103.35 205.79,101.52 208.05,101.52 208.09,101.55 208.68,101.55 208.71,101.52 209.57,101.52 211.38,99.71 216.84,99.71
PEG_CRX_GTX_P9: length 41.1
  TOP w0.102: UC1.E19 221.14,100.5 v2(220.81,100.17)
  BOTTOM w0.076: 216.73,100.45 216.75,100.43 217.06,100.43 217.19,100.57 219.05,100.57 219.24,100.75 220.35,100.75 220.62,100.48 220.62,100.37 v2(220.81,100.17)
  BOTTOM w0.102: 216.73,100.45 211.68,100.45 209.88,102.25 206.16,102.25 203.83,104.58 195.39,104.58 193.38,106.6 v4(190.03,106.6) 188.99,106.6 187.57,108.02 184.28,108.02 CV445.2
PEG_CRX_GTX_P10: length 40.2
  TOP w0.102: v2(221.47,100.97) 221.47,101.02 UC1.E20
  BOTTOM w0.076: v2(221.47,100.97) 221.72,100.97 221.76,101.02 221.76,101.23 221.64,101.36 221.23,101.36 221.07,101.2 219.16,101.2 218.8,100.85 217.69,100.85 217.58,100.95 216.86,100.95 216.84,100.93 216.82,100.93
  BOTTOM w0.102: CV447.2 186.93,109.18 187.4,109.18 188.1,108.48 v4(188.98,108.48) 190.18,108.48 191.65,107 193.86,107 195.84,105.03 204.77,105.03 206.97,102.82 210.01,102.82 211.91,100.93 216.82,100.93
PEG_CRX_GTX_P11: length 41.7
  TOP w0.102: v2(220.81,101.75) 221.14,102.07 UC1.E21
  BOTTOM w0.076: v2(220.81,101.75) 220.61,101.95 220.61,102.05 220.39,102.27 219.07,102.27 218.71,101.91 217.71,101.91 217.51,101.71 217.32,101.71 217.31,101.73 217.3,101.73
  BOTTOM w0.102: 217.3,101.73 212.3,101.73 210.4,103.62 207.29,103.62 205.09,105.82 196.34,105.82 193.36,108.79 192.29,108.79 192.25,108.83 191.66,108.83 191.62,108.79 191,108.79 189.78,110.01 188.53,110.01 188.04,110.51 184.26,110.51 CV449.2
PEG_CRX_GTX_P12: length 40.1
  TOP w0.102: UC1.E22 221.14,102.86 v2(221.46,102.54)
  BOTTOM w0.076: v2(221.46,102.54) 221.46,102.78 221.4,102.85 221.13,102.85 220.74,102.45 218.55,102.45 218.35,102.25 217.6,102.25 217.58,102.23 217.56,102.23
  BOTTOM w0.102: 217.56,102.23 212.51,102.23 210.65,104.09 207.47,104.09 205.31,106.25 199.07,106.25 199.03,106.29 198.86,106.29 v4(198.82,106.25) 196.58,106.25 193.41,109.41 191.93,109.41 190.93,110.42 188.86,110.42 187.5,111.79 186.85,111.79 CV451.2
PEG_CRX_GTX_P13: length 42.8
  TOP w0.102: v2(220.81,103.32) 221.14,103.65 UC1.E23
  BOTTOM w0.076: 217.7,103.26 217.71,103.26 217.73,103.28 218.32,103.28 218.79,102.82 220.42,102.82 220.62,103.02 220.62,103.13 v2(220.81,103.32)
  BOTTOM w0.102: 217.7,103.26 212.6,103.26 211.06,104.8 207.81,104.8 204.62,108 203.68,108 202.25,109.43 199.97,109.43 198.73,110.67 197.88,110.67 197.84,110.63 197.26,110.63 197.22,110.67 v4(195.57,110.67) 191.72,110.67 191.35,111.04 189.35,111.04 188.34,112.05 188.34,112.89 187.98,113.25 187.27,113.25 186.98,112.97 185.16,112.97 185.07,112.88 184.29,112.88 CV453.2
PEG_CRX_GTX_P14: length 44
  TOP w0.102: v2(221.46,104.84) 221.14,104.52 UC1.E24
  BOTTOM w0.076: 219.63,104.05 219.64,104.05 219.66,104.03 221.25,104.03 221.77,104.55 221.77,104.77 221.63,104.91 221.52,104.91 v2(221.46,104.84)
  BOTTOM w0.102: CV455.2 186.68,114.34 187.26,114.34 187.67,114.75 188.22,114.75 188.68,114.29 188.68,113.68 189.76,112.61 190.46,112.61 190.5,112.64 191.09,112.64 191.12,112.61 194.84,112.61 195.28,112.17 198.59,112.17 200.55,110.21 203.54,110.21 204.28,110.95 205.16,110.95 205.79,110.32 205.79,107.94 208.1,105.63 211.41,105.63 212.99,104.05 219.63,104.05
PEG_CRX_GTX_P15: length 45.4
  TOP w0.102: v2(220.81,104.84) 221.14,105.17 UC1.E25
  BOTTOM w0.076: 218.78,104.71 218.79,104.7 218.82,104.7 219.18,104.34 220.4,104.34 220.61,104.55 220.61,104.64 v2(220.81,104.84)
  BOTTOM w0.102: 218.78,104.71 218.4,105.09 217.47,105.09 216.85,104.47 213.4,104.47 211.78,106.1 208.21,106.1 206.34,107.97 206.34,110.55 205.49,111.4 203.9,111.4 203.24,110.74 200.77,110.74 198.85,112.66 v4(196.7,112.66) 195.44,112.66 194.93,113.16 189.83,113.16 189.23,113.76 189.23,114.34 188.34,115.23 187.4,115.23 187.21,115.42 185.11,115.42 185.01,115.33 184.3,115.33 CV457.2
PEG_CTX_C_GRX_N0: length 44.7
  TOP w0.102: v2(172.77,93.47) 173.05,93.76 173.05,94.01 172.87,94.19 JDGFF2.H8 ; CC65.2 208.35,92.44 207.44,92.44 204.48,95.39 199,95.39 198.96,95.43 198.38,95.43 198.34,95.39 198,95.39 197.05,96.33 196.64,96.33 196.43,96.54 196.43,96.79 196.58,96.94 196.71,96.94 v2(196.78,96.86)
  IN1 w0.102: v2(172.77,93.47) 172.95,93.29 172.95,92.63 174.33,91.25 176.91,91.25 177.36,91.7 178.64,91.7 179.09,92.15 179.72,92.15 180.5,92.93 180.5,93.38 181.51,94.38 184.39,94.38 186.38,96.37 194.16,96.37 194.77,95.76 195.95,95.76 196.61,96.41 196.61,96.69 v2(196.78,96.86)
PEG_CTX_C_GRX_N1: length 41.1
  TOP w0.102: JDGFF2.H5 174.67,94.25 174.87,94.04 174.87,93.68 v2(174.67,93.48) ; v2(198.4,96.55) 198.4,96.72 198.46,96.77 198.66,96.77 199.44,95.99 v4(203.06,95.99) 204.47,95.99 206.19,94.27 208.48,94.27 CC63.2
  IN1 w0.102: v2(174.67,93.48) 174.83,93.32 174.83,92.81 175.31,92.32 178.38,92.32 178.79,92.74 179.47,92.74 179.89,93.16 179.89,93.61 181.27,94.99 184.15,94.99 186.14,96.97 187.91,96.97 188.83,97.88 191.48,97.88 192.16,97.21 193.79,97.21 194.38,97.8 196.76,97.8 197.84,96.72 198.23,96.72 v2(198.4,96.55)
PEG_CTX_C_GRX_N2: length 41.9
  TOP w0.102: CC61.2 205.86,96.1 205.71,96.1 204.71,97.1 201.56,97.1 201.53,97.14 200.94,97.14 200.9,97.1 200.04,97.1 198.03,99.11 198.03,100.67 198.15,100.78 v2(198.45,100.78) ; v2(174.27,96.7) 174.54,96.42 174.54,96.33 174.27,96.05 174.27,95.87 174.07,95.67 JDGFF2.G6
  IN1 w0.102: v2(198.45,100.78) 198.28,100.62 198.28,100.36 197.96,100.05 196.33,100.05 195.64,100.73 187.54,100.73 186.31,99.5 181.78,99.5 180.47,98.19 180.47,96.7 179.35,95.58 174.81,95.58 174.44,95.95 174.44,96.52 v2(174.27,96.7)
PEG_CTX_C_GRX_N3: length 40.2
  TOP w0.102: v2(199.22,99.11) 199.34,98.98 199.34,98.59 200.12,97.81 200.6,97.81 201.05,98.27 201.72,98.27 202.17,97.81 204.9,97.81 205.58,97.13 207.8,97.13 208.13,96.8 208.49,96.8 CC59.2 ; JDGFF2.H2 176.47,94.35 176.69,94.13 176.69,94 176.26,93.57 176.26,93.29 v2(176.08,93.1)
  IN1 w0.102: v2(176.08,93.1) 176.29,93.32 176.29,93.9 176.97,94.58 179.76,94.58 180.95,95.77 183.81,95.77 185.84,97.8 187.59,97.8 188.74,98.96 193.73,98.96 193.89,99.12 195.51,99.12 195.82,98.81 197.88,98.81 198.25,98.44 199.33,98.44 199.49,98.61 199.49,98.83 v2(199.22,99.11)
PEG_CTX_C_GRX_N4: length 45
  TOP w0.102: v2(171.03,96.76) 171.28,96.76 171.39,96.64 171.39,96.36 171.61,96.14 172.36,96.14 172.43,96.07 172.43,95.93 172.27,95.78 JDGFF2.G9 ; v2(200.36,100.78) 200.31,100.84 200.18,100.84 200.05,100.71 200.05,100.17 200.44,99.77 201.6,99.77 202.55,98.83 203.55,98.83 203.58,98.87 204.17,98.87 204.2,98.83 205.26,98.83 205.64,98.44 205.83,98.44 CC57.2
  IN1 w0.102: v2(200.36,100.78) 200.2,100.61 200.2,100.07 199.76,99.63 198.62,99.63 198.42,99.43 195.95,99.43 195.33,100.06 187.73,100.06 186.58,98.9 182.05,98.9 181.09,97.94 181.09,96.48 179.59,94.99 173.62,94.99 173.1,95.5 171.72,95.5 171.22,96 171.22,96.57 v2(171.03,96.76)
PEG_CTX_C_GRX_N5: length 40.8
  TOP w0.102: CC55.2 208.44,99.29 208.12,99.29 207.91,99.5 205.13,99.5 204.77,99.87 204.77,100.27 204.52,100.52 204.16,100.52 203.9,100.27 203.9,99.87 203.54,99.5 202.52,99.5 201.88,100.15 201.88,100.64 201.34,101.17 200.93,101.17 200.65,101.45 200.65,101.87 v2(200.5,102.03) ; JDGFF2.G3 175.87,95.65 176.07,95.86 176.07,96.01 176.3,96.24 176.94,96.24 177.04,96.34 177.04,96.51 v2(176.86,96.69)
  IN1 w0.102: v2(200.5,102.03) 200.54,102.03 200.75,101.82 200.75,101.67 200.65,101.56 187.27,101.56 185.99,100.28 181.16,100.28 180.32,99.45 179.66,99.45 178.84,98.63 177.49,98.63 177.07,98.21 177.07,96.9 v2(176.86,96.69)
PEG_CTX_C_GRX_N6: length 37.3
  TOP w0.102: v2(203.05,101.6) 203.28,101.36 205.2,101.36 205.69,100.88 205.9,100.88 CC53.2 ; v2(175.59,96.64) 175.84,96.89 175.84,96.98 175.71,97.11 175.06,97.11 174.87,97.3 174.87,97.43 174.67,97.63 JDGFF2.F5
  IN1 w0.102: v2(175.59,96.64) 175.75,96.81 175.75,97.77 177.29,99.31 178.59,99.31 180.19,100.91 183.06,100.91 183.97,101.82 186.63,101.82 187.07,102.26 198.11,102.26 198.49,102.65 202.03,102.65 202.42,102.26 202.42,101.61 202.6,101.43 202.88,101.43 v2(203.05,101.6)
PEG_CTX_C_GRX_N7: length 43.9
  TOP w0.102: v2(172.57,96.76) 172.8,96.98 172.8,97.07 173.07,97.34 173.07,97.44 172.87,97.65 JDGFF2.F8 ; CC51.2 208.47,101.62 208.05,101.62 207.78,101.88 v4(204.83,101.88) 204.2,101.88 202.57,103.51 202.57,103.69 v2(202.41,103.85)
  IN1 w0.102: v2(202.41,103.85) 202.63,103.63 202.63,103.46 202.53,103.36 200.97,103.36 199.23,105.1 186.21,105.1 182.67,101.56 179.3,101.56 178.3,100.55 177.67,100.55 174.95,97.84 173.23,97.84 172.73,97.34 172.73,96.92 v2(172.57,96.76)
PEG_CTX_C_GRX_N8: length 44
  TOP w0.102: JDGFF3.C8 172.87,117.95 173.07,118.15 173.07,118.25 173.02,118.31 172.31,118.31 172.13,118.48 172.13,118.72 v2(171.96,118.9) ; CC49.2 205.86,103.1 205.11,103.1 203.92,104.29 200.72,104.29 v4(198.88,106.12) 197.43,107.58 196.92,107.58 v2(196.69,107.35)
  IN1 w0.102: v2(196.69,107.35) 196.55,107.49 194.37,107.49 193.32,108.54 186.55,108.54 182.19,112.9 182.19,113.76 180.06,115.89 177.25,115.89 175.07,118.07 172.39,118.07 172.09,118.37 172.09,118.76 v2(171.96,118.9)
PEG_CTX_C_GRX_N9: length 44.3
  TOP w0.102: v2(198.6,109.9) 198.35,109.9 198.18,109.73 198.18,108.63 200.75,106.07 200.8,106.07 201.21,105.65 201.21,105.6 201.71,105.1 204.22,105.1 204.72,104.6 207.64,104.6 207.96,104.28 208.38,104.28 CC47.2 ; v2(177.28,118.97) 177.4,118.85 177.4,118.67 177.25,118.52 175.1,118.52 174.88,118.3 174.88,118.18 174.67,117.97 JDGFF3.C5
  IN1 w0.102: v2(198.6,109.9) 198.41,109.71 198.41,109.47 198.16,109.21 196.49,109.21 194.94,110.76 194.58,110.76 193.15,112.19 190.5,112.19 187.5,115.19 186.09,115.19 186.03,115.25 182.44,118.84 179.39,118.84 178.82,118.27 177.7,118.27 177.42,118.55 177.42,118.83 v2(177.28,118.97)
PEG_CTX_C_GRX_N10: length 38.3
  TOP w0.102: CC45.2 205.87,105.53 203.01,105.53 v4(202.48,106.05) 200.57,107.97 200.1,107.97 v2(199.87,107.74) ; JDGFF3.B3 175.87,119.92 176.02,119.77 176.02,119.66 175.68,119.32 175.68,119.12 v2(175.51,118.95)
  IN1 w0.102: v2(175.51,118.95) 175.67,118.79 175.67,118.43 177.58,116.52 180.39,116.52 182.81,114.1 185.46,114.1 189.05,110.51 193.46,110.51 195.38,108.6 198.16,108.6 198.87,107.88 199.72,107.88 v2(199.87,107.74)
PEG_CTX_C_GRX_N11: length 43.6
  TOP w0.102: JDGFF3.B6 174.07,119.95 174.25,119.77 174.25,119.73 173.93,119.4 173.93,119.29 v2(173.7,119.07) ; CC43.2 208.47,106.56 207.8,106.56 207.66,106.7 205.73,106.7 205.44,106.41 204.18,106.41 203.31,107.28 203.31,107.33 202.9,107.75 202.85,107.75 202.46,108.13 202.13,108.13 v2(201.88,108.38)
  IN1 w0.102: v2(201.88,108.38) 201.72,108.22 201.47,108.22 197.66,112.02 196.52,112.02 195.89,112.65 195.44,112.65 193.43,114.66 189.84,114.66 189.05,115.45 189.05,116.27 188.07,117.25 186.29,117.25 185.57,117.97 185.57,118.25 185,118.82 183.63,118.82 182.63,119.82 174.19,119.82 173.85,119.48 173.85,119.21 v2(173.7,119.07)
PEG_CTX_C_GRX_N12: length 46.8
  TOP w0.102: CC41.2 205.97,107.78 205.59,107.78 204.97,107.17 204.74,107.17 v2(204.5,106.93) ; JDGFF3.B9 172.27,119.95 172.47,119.75 172.47,119.58 172.38,119.49 170.82,119.49 170.59,119.25 170.59,118.98 v2(170.4,118.8)
  IN1 w0.102: v2(204.5,106.93) 204.34,107.1 203.44,107.1 202.54,106.19 185.55,106.19 179.48,112.26 178.15,112.26 177.23,113.18 173.25,113.18 171.89,114.54 171.89,116.69 170.56,118.01 170.56,118.63 v2(170.4,118.8)
PEG_CTX_C_GRX_N13: length 44.5
  TOP w0.102: JDGFF3.A2 176.47,121.34 176.64,121.51 176.64,121.57 176.24,121.97 176.24,122.22 v2(176.06,122.4) ; v2(202.16,111.45) 201.9,111.45 201.75,111.3 201.75,110.61 v4(202.74,109.62) 203.83,108.53 205.05,108.53 205.77,109.25 207.89,109.25 208.03,109.11 208.4,109.11 CC39.2
  IN1 w0.102: v2(202.16,111.45) 201.97,111.64 201.97,111.95 201.41,112.51 199.86,112.51 198.92,113.46 198.92,114.98 197.44,116.45 197.28,116.45 193.87,119.87 188.97,119.87 188.79,119.69 186.2,119.69 185.28,120.6 183.93,120.6 183.08,121.45 180.71,121.45 178.57,123.6 176.59,123.6 176.2,123.21 176.2,122.54 v2(176.06,122.4)
PEG_CTX_C_GRX_N14: length 41.1
  TOP w0.102: JDGFF3.A8 172.87,121.26 173.07,121.47 173.07,121.76 v2(172.88,121.95) ; CC37.2 205.9,110.24 205.66,110.24 205.56,110.13 205.56,109.83 205.23,109.51 204.63,109.51 v2(204.4,109.28)
  IN1 w0.102: v2(172.88,121.95) 173.03,121.81 173.03,121.02 173.55,120.49 182.79,120.49 183.8,119.48 185.17,119.48 185.89,118.76 188.09,118.76 189.8,117.05 192.98,117.05 196.09,113.94 196.09,113.41 196.96,112.54 198.19,112.54 199.98,110.75 202.4,110.75 203.72,109.43 204.25,109.43 v2(204.4,109.28)
PEG_CTX_C_GRX_N15: length 47.8
  TOP w0.102: JDGFF3.A5 174.67,121.27 174.93,121.53 174.93,121.9 v2(174.67,122.17) ; v2(205.05,112.01) 204.78,112.01 204.66,111.89 204.66,111.72 204.77,111.61 208.42,111.61 CC35.2
  IN1 w0.102: v2(174.67,122.17) 174.82,122.32 174.82,125.29 175.82,126.29 177.94,126.29 180.32,123.92 180.32,123.16 181.36,122.11 183.42,122.11 183.87,121.66 187.51,121.66 188.1,121.08 193.62,121.08 197.29,117.41 197.84,117.41 199.76,115.49 199.76,113.76 200.37,113.15 204.43,113.15 204.87,112.71 204.87,112.19 v2(205.05,112.01)
PEG_CTX_C_GRX_P0: length 44.7
  TOP w0.102: JDGFF2.H7 173.47,94.22 173.24,93.99 173.24,93.77 v2(173.53,93.49) ; CC64.2 208.45,92.25 207.36,92.25 204.4,95.2 v4(198.67,95.2) 197.92,95.2 196.98,96.14 196.56,96.14 196.24,96.46 196.24,96.71 v2(196.07,96.88)
  IN1 w0.102: v2(196.07,96.88) 196.14,96.94 196.26,96.94 196.42,96.78 196.42,96.49 195.87,95.94 194.85,95.94 194.24,96.56 186.3,96.56 184.31,94.57 181.43,94.57 180.32,93.45 180.32,93.01 179.64,92.34 179.01,92.34 178.56,91.89 177.28,91.89 176.83,91.44 174.41,91.44 173.14,92.71 173.14,93.41 173.28,93.56 173.46,93.56 v2(173.53,93.49)
PEG_CTX_C_GRX_P1: length 41.1
  TOP w0.102: v2(198.37,97.22) 198.63,96.96 198.74,96.96 199.52,96.18 202.73,96.18 202.77,96.22 203.35,96.22 203.39,96.18 204.55,96.18 206.27,94.46 208.38,94.46 CC62.2 ; JDGFF2.H4 175.27,94.22 175.06,94.02 175.06,93.67 v2(175.25,93.48)
  IN1 w0.102: v2(175.25,93.48) 175.15,93.48 175.01,93.34 175.01,92.89 175.39,92.51 178.3,92.51 178.72,92.93 179.4,92.93 179.71,93.24 179.71,93.69 181.19,95.17 184.07,95.17 186.06,97.16 187.83,97.16 188.75,98.07 191.56,98.07 192.24,97.4 193.71,97.4 194.3,97.99 196.84,97.99 197.92,96.91 198.32,96.91 198.44,97.03 198.44,97.15 v2(198.37,97.22)
PEG_CTX_C_GRX_P2: length 41.9
  TOP w0.102: JDGFF2.G5 174.67,95.65 174.46,95.87 174.46,95.97 174.73,96.25 174.73,96.44 v2(174.98,96.68) ; v2(197.68,100.78) 197.84,100.62 197.84,99.03 199.96,96.91 v4(201.23,96.91) 204.63,96.91 205.63,95.91 205.91,95.91 CC60.2
  IN1 w0.102: v2(174.98,96.68) 174.92,96.74 174.75,96.74 174.63,96.61 174.63,96.03 174.88,95.77 179.27,95.77 180.28,96.78 180.28,98.26 181.7,99.69 186.23,99.69 187.47,100.92 195.72,100.92 196.41,100.23 197.88,100.23 198.09,100.44 198.09,100.68 197.91,100.86 197.76,100.86 v2(197.68,100.78)
PEG_CTX_C_GRX_P3: length 40.2
  TOP w0.102: CC58.2 208.38,96.99 208.21,96.99 207.88,97.32 205.66,97.32 204.98,98 202.25,98 201.8,98.46 200.97,98.46 200.52,98 200.2,98 199.53,98.67 199.53,98.91 199.74,99.12 v2(199.96,99.12) ; JDGFF2.H1 177.07,94.32 176.88,94.13 176.88,93.93 176.45,93.49 176.45,93.31 v2(176.66,93.1)
  IN1 w0.102: v2(176.66,93.1) 176.48,93.29 176.48,93.82 177.05,94.39 179.84,94.39 181.03,95.58 183.88,95.58 185.92,97.62 187.67,97.62 188.82,98.77 193.81,98.77 193.97,98.93 195.43,98.93 195.74,98.63 197.8,98.63 198.17,98.26 199.41,98.26 199.68,98.53 199.68,98.84 v2(199.96,99.12)
PEG_CTX_C_GRX_P4: length 45
  TOP w0.102: v2(199.69,100.78) 199.86,100.61 199.86,100.09 200.36,99.58 201.52,99.58 202.47,98.64 v4(203.88,98.64) 205.18,98.64 205.57,98.25 205.94,98.25 CC56.2 ; v2(171.91,96.77) 171.72,96.77 171.58,96.63 171.58,96.44 171.69,96.33 172.44,96.33 172.62,96.15 172.62,95.97 172.87,95.72 JDGFF2.G8
  IN1 w0.102: v2(171.91,96.77) 171.58,96.77 171.41,96.6 171.41,96.08 171.8,95.69 173.18,95.69 173.7,95.18 179.52,95.18 180.9,96.56 180.9,98.02 181.97,99.09 186.5,99.09 187.66,100.24 195.41,100.24 196.03,99.62 198.34,99.62 198.54,99.82 199.68,99.82 200.01,100.15 200.01,100.68 199.85,100.83 199.74,100.83 v2(199.69,100.78)
PEG_CTX_C_GRX_P5: length 40.8
  TOP w0.102: JDGFF2.G2 176.47,95.65 176.27,95.85 176.27,95.94 176.38,96.05 177.02,96.05 177.23,96.26 177.23,96.48 v2(177.44,96.69) ; CC54.2 208.43,99.48 208.2,99.48 207.99,99.69 205.21,99.69 204.96,99.95 204.96,100.35 204.59,100.71 204.08,100.71 203.71,100.35 203.71,99.95 203.46,99.69 202.6,99.69 202.07,100.23 202.07,100.72 201.42,101.36 201,101.36 200.84,101.53 200.84,101.89 201.03,102.08 201.17,102.08 v2(201.23,102.03)
  IN1 w0.102: v2(177.44,96.69) 177.44,96.69 177.26,96.87 177.26,98.13 177.57,98.44 178.92,98.44 179.73,99.26 180.39,99.26 181.23,100.1 186.07,100.1 187.35,101.38 200.73,101.38 200.94,101.59 200.94,101.73 v2(201.23,102.03)
PEG_CTX_C_GRX_P6: length 37.3
  TOP w0.102: JDGFF2.F4 175.27,97.64 175.06,97.44 175.06,97.38 175.14,97.3 175.79,97.3 176.03,97.06 176.03,96.86 v2(176.25,96.64) ; v2(203.05,100.94) 203.28,101.17 205.12,101.17 205.61,100.69 205.91,100.69 CC52.2
  IN1 w0.102: v2(176.25,96.64) 176.05,96.64 175.94,96.75 175.94,97.69 177.37,99.12 178.67,99.12 180.27,100.72 183.14,100.72 184.05,101.63 186.7,101.63 187.15,102.08 198.19,102.08 198.57,102.46 201.95,102.46 202.23,102.18 202.23,101.53 202.52,101.24 202.93,101.24 203.05,101.13 v2(203.05,100.94)
PEG_CTX_C_GRX_P7: length 43.9
  TOP w0.102: v2(173.16,96.76) 172.99,96.93 172.99,96.99 173.27,97.26 173.27,97.43 173.47,97.64 JDGFF2.F7 ; v2(203.1,103.85) 202.88,103.85 202.76,103.73 202.76,103.59 203.55,102.8 204.28,102.07 204.5,102.07 204.54,102.11 205.11,102.11 205.14,102.08 207.85,102.08 208.13,101.81 208.35,101.81 CC50.2
  IN1 w0.102: v2(173.16,96.76) 172.92,97 172.92,97.26 173.31,97.65 175.03,97.65 177.75,100.36 178.38,100.36 179.38,101.37 182.75,101.37 186.29,104.91 199.15,104.91 200.89,103.18 202.61,103.18 202.82,103.39 202.82,103.56 v2(203.1,103.85)
PEG_CTX_C_GRX_P8: length 44
  TOP w0.102: v2(196.68,108.04) 196.95,107.77 197.5,107.77 198.78,106.49 198.84,106.49 199.25,106.08 199.25,106.03 200.8,104.48 204,104.48 205.19,103.29 205.91,103.29 CC48.2 ; JDGFF3.C7 173.47,117.99 173.27,118.19 173.27,118.33 173.1,118.5 172.39,118.5 172.33,118.56 172.33,118.68 v2(172.54,118.9)
  IN1 w0.102: v2(172.54,118.9) 172.46,118.9 172.28,118.71 172.28,118.44 172.47,118.26 175.15,118.26 177.33,116.08 180.14,116.08 182.38,113.84 182.38,112.98 186.63,108.73 193.39,108.73 194.44,107.68 196.51,107.68 196.68,107.85 v2(196.68,108.04)
PEG_CTX_C_GRX_P9: length 44.2
  TOP w0.102: JDGFF3.C4 175.27,117.94 175.07,118.14 175.07,118.22 175.18,118.32 177.33,118.32 177.59,118.59 177.59,118.7 v2(177.86,118.97) ; CC46.2 208.48,104.09 207.88,104.09 207.56,104.41 204.64,104.41 204.14,104.91 201.63,104.91 v4(200.84,105.7) 197.99,108.55 197.99,109.74 v2(197.85,109.88)
  IN1 w0.102: v2(177.86,118.97) 177.77,118.97 177.61,118.82 177.61,118.62 177.78,118.46 178.74,118.46 179.31,119.03 182.52,119.03 186.17,115.38 187.58,115.38 190.58,112.38 193.23,112.38 194.65,110.95 195.01,110.95 196.57,109.4 198.08,109.4 198.23,109.54 198.23,109.95 198.14,110.04 198,110.04 v2(197.85,109.88)
PEG_CTX_C_GRX_P10: length 38.4
  TOP w0.102: v2(199.87,108.42) 200.13,108.16 200.65,108.16 202.38,106.42 202.46,106.42 202.92,105.96 202.92,105.88 203.09,105.72 205.94,105.72 CC44.2 ; JDGFF3.B2 176.47,119.93 176.21,119.67 176.21,119.58 175.87,119.24 175.87,119.17 v2(176.09,118.95)
  IN1 w0.102: v2(176.09,118.95) 175.99,118.95 175.86,118.81 175.86,118.51 177.65,116.71 180.47,116.71 182.89,114.29 185.54,114.29 189.13,110.7 193.54,110.7 195.45,108.79 198.23,108.79 198.95,108.07 199.71,108.07 199.87,108.23 v2(199.87,108.42)
PEG_CTX_C_GRX_P11: length 43.6
  TOP w0.102: CC42.2 208.44,106.37 207.72,106.37 207.58,106.51 205.81,106.51 205.52,106.22 204.1,106.22 v4(202.94,107.38) 202.39,107.94 202.11,107.94 v2(201.88,107.7) ; v2(174.33,119.07) 174.12,119.28 174.12,119.33 174.44,119.65 174.44,119.72 174.67,119.95 JDGFF3.B5
  IN1 w0.102: v2(174.33,119.07) 174.21,119.07 174.04,119.24 174.04,119.4 174.26,119.63 182.55,119.63 183.5,118.68 183.55,118.63 184.92,118.63 185.38,118.17 185.38,117.89 186.21,117.06 187.99,117.06 188.86,116.19 188.86,115.38 189.77,114.47 193.36,114.47 195.36,112.47 195.82,112.47 196.45,111.84 197.59,111.84 199.46,109.96 201.39,108.03 201.74,108.03 201.88,107.9 v2(201.88,107.7)
PEG_CTX_C_GRX_P12: length 46.8
  TOP w0.102: v2(170.99,118.8) 170.78,119.01 170.78,119.17 170.9,119.3 172.46,119.3 172.66,119.5 172.66,119.74 172.87,119.94 JDGFF3.B8 ; CC40.2 205.81,107.97 205.51,107.97 204.9,107.36 204.74,107.36 v2(204.5,107.59)
  IN1 w0.102: v2(204.5,107.59) 204.5,107.5 204.29,107.28 203.37,107.28 202.46,106.38 185.63,106.38 179.56,112.45 178.23,112.45 177.3,113.37 173.32,113.37 172.07,114.62 172.07,116.77 170.75,118.09 170.75,118.68 170.87,118.8 v2(170.99,118.8)
PEG_CTX_C_GRX_P13: length 44.5
  TOP w0.102: CC38.2 208.5,108.92 207.95,108.92 207.81,109.06 205.85,109.06 205.13,108.34 203.75,108.34 202.84,109.26 202.78,109.26 202.37,109.67 202.37,109.72 201.56,110.54 201.56,111.3 v2(201.41,111.45) ; v2(176.64,122.4) 176.43,122.19 176.43,122.05 176.83,121.65 176.83,121.53 177.07,121.28 JDGFF3.A1
  IN1 w0.102: v2(201.41,111.45) 201.57,111.29 201.69,111.29 201.78,111.38 201.78,111.87 201.33,112.32 199.78,112.32 198.73,113.38 198.73,114.9 197.36,116.27 197.2,116.27 193.79,119.68 189.04,119.68 188.87,119.5 186.12,119.5 185.21,120.41 183.86,120.41 183,121.27 180.63,121.27 178.49,123.41 176.67,123.41 176.39,123.13 176.39,122.57 176.56,122.4 v2(176.64,122.4)
PEG_CTX_C_GRX_P14: length 41.2
  TOP w0.102: JDGFF3.A7 173.47,121.29 173.27,121.49 173.27,121.75 v2(173.47,121.95) ; CC36.2 205.89,110.43 205.58,110.43 205.37,110.21 205.37,109.91 205.16,109.7 204.67,109.7 204.4,109.97 v2(204.39,109.97)
  IN1 w0.102: v2(204.39,109.97) 204.39,109.75 204.26,109.62 203.79,109.62 202.48,110.94 200.06,110.94 198.32,112.67 198.27,112.73 197.04,112.73 196.28,113.49 196.28,114.02 193.06,117.24 189.88,117.24 188.17,118.95 185.97,118.95 185.25,119.67 183.88,119.67 182.87,120.68 173.63,120.68 173.21,121.1 173.21,121.78 173.39,121.95 v2(173.47,121.95)
PEG_CTX_C_GRX_P15: length 47.8
  TOP w0.102: v2(204.31,112.01) 204.47,111.85 204.47,111.64 204.69,111.42 208.48,111.42 CC34.2 ; JDGFF3.A4 175.27,121.3 175.12,121.44 175.12,121.9 v2(175.42,122.2)
  IN1 w0.102: v2(204.31,112.01) 204.44,111.88 204.58,111.88 204.68,111.99 204.68,112.63 204.35,112.96 200.29,112.96 199.57,113.69 199.57,115.41 197.76,117.22 197.21,117.22 193.55,120.89 188.02,120.89 187.43,121.48 183.79,121.48 183.34,121.93 181.28,121.93 180.13,123.08 180.13,123.84 177.86,126.1 175.9,126.1 175.01,125.21 175.01,122.4 175.21,122.2 v2(175.42,122.2)
PEG_CTX_GRX_N0: length 11.6
  TOP w0.102: CC65.1 210.01,92.49 v4(210.92,92.49) 211.54,92.49 212.84,93.79 212.99,93.79 213.02,93.82 213.76,93.82 213.79,93.79 217.05,93.79 217.8,93.03 218.16,93.03 218.31,93.18 219.47,93.18 219.54,93.25 219.54,93.41 219.45,93.51 219.22,93.51 UC1.B10
PEG_CTX_GRX_N1: length 10.2
  TOP w0.102: CC63.1 210.05,94.32 211.43,94.32 211.47,94.29 212.05,94.29 212.09,94.32 v4(214.63,94.32) 217.05,94.32 217.49,93.88 218.22,93.88 218.32,93.77 218.83,93.77 219.08,94.02 219.08,94.16 UC1.B11
PEG_CTX_GRX_N2: length 13.9
  TOP w0.102: CC61.1 207.49,96.13 207.82,96.13 208.12,95.83 210.44,95.83 210.92,95.36 212.74,95.36 212.78,95.39 213.37,95.39 213.41,95.36 v4(215.95,95.36) 217.04,95.36 217.82,94.58 218.13,94.58 218.31,94.76 219.46,94.76 219.54,94.85 219.54,94.97 219.43,95.09 219.22,95.09 UC1.B12
PEG_CTX_GRX_N3: length 10.6
  TOP w0.102: UC1.B13 219.07,95.73 219.07,95.6 218.82,95.35 218.26,95.35 218.11,95.49 217.45,95.49 217.14,95.8 v4(214.33,95.8) 211.58,95.8 211.29,96.09 211.24,96.09 210.82,96.51 210.82,96.56 210.53,96.85 210.05,96.85 CC59.1
PEG_CTX_GRX_N4: length 14.2
  TOP w0.102: CC57.1 207.49,98.5 207.69,98.5 207.92,98.27 210.8,98.27 211.33,97.74 211.33,97.67 212.36,96.63 v4(213.04,96.63) 217.46,96.63 217.89,96.19 218.19,96.19 218.33,96.33 219.51,96.33 219.55,96.37 219.55,96.57 219.47,96.66 219.21,96.66 UC1.B14
PEG_CTX_GRX_N5: length 10.9
  TOP w0.102: CC55.1 210,99.26 210.95,99.26 211.67,98.54 211.67,98.48 212.08,98.07 212.14,98.07 213.07,97.14 v4(215.84,97.14) 218.08,97.14 218.28,96.93 218.79,96.93 219.02,97.16 219.02,97.25 UC1.B15
PEG_CTX_GRX_N6: length 14.5
  TOP w0.102: CC53.1 207.53,100.87 207.71,100.87 207.89,100.68 211,100.68 211.39,100.29 211.45,100.29 211.86,99.88 211.86,99.83 213.6,98.08 v4(214.16,98.08) 217.34,98.08 217.62,97.8 218.17,97.8 218.27,97.9 219.48,97.9 219.56,97.98 219.56,98.08 219.4,98.24 219.22,98.24 UC1.B16
PEG_CTX_GRX_N7: length 11.2
  TOP w0.102: CC51.1 210.01,101.66 211,101.66 212.9,99.75 212.9,99.7 213.31,99.29 213.37,99.29 214.02,98.63 v4(215.72,98.63) 218.04,98.63 218.17,98.51 218.8,98.51 219.04,98.75 219.04,98.85 UC1.B17
PEG_CTX_GRX_N8: length 15
  TOP w0.102: UC1.C18 219.74,99.69 219.74,99.45 219.58,99.29 218.4,99.29 218.15,99.03 217.52,99.03 217.18,99.37 214.49,99.37 v4(212.49,101.38) 211.52,102.34 211.46,102.34 211.02,102.78 211.02,102.84 210.94,102.92 207.83,102.92 207.68,103.07 207.5,103.07 CC49.1
PEG_CTX_GRX_N9: length 11.6
  TOP w0.102: UC1.A19 218.61,100.64 218.75,100.64 218.85,100.54 218.85,100.39 218.73,100.27 v4(215.53,100.27) 214.96,100.27 214.57,100.65 214.57,100.71 214.11,101.17 214.06,101.17 210.89,104.33 210.05,104.33 CC47.1
PEG_CTX_GRX_N10: length 15.1
  TOP w0.102: UC1.C20 219.74,101.25 219.74,101.06 219.54,100.87 218.39,100.87 218.31,100.79 215.41,100.79 213.17,103.03 213.11,103.03 212.7,103.44 212.7,103.49 v4(211.74,104.45) 210.91,105.29 208.08,105.29 207.87,105.5 207.52,105.5 CC45.1
PEG_CTX_GRX_N11: length 11.9
  TOP w0.102: UC1.A21 218.6,102.21 218.78,102.21 218.88,102.11 218.88,101.99 218.74,101.84 218.32,101.84 218.25,101.91 v4(216.24,101.91) 215.67,101.91 214.79,102.8 214.79,102.85 214.38,103.26 214.32,103.26 211.04,106.54 210.07,106.54 CC43.1
PEG_CTX_GRX_N12: length 15.6
  TOP w0.102: CC41.1 207.5,107.85 208.32,107.85 208.43,107.95 210.38,107.95 212.11,106.23 212.11,106.17 212.52,105.76 212.58,105.76 213.72,104.62 v4(214.02,104.32) 215.97,102.37 218.33,102.37 218.4,102.44 219.53,102.44 219.72,102.62 219.72,102.81 UC1.C22
PEG_CTX_GRX_N13: length 12.7
  TOP w0.102: CC39.1 210.07,109.16 210.61,109.16 211.43,108.34 211.52,108.34 211.92,107.94 211.92,107.85 212.77,107 213.75,107 215.38,105.37 215.38,104.63 215.69,104.32 215.77,104.24 v4(215.95,104.06) 216.51,103.5 218.28,103.5 218.36,103.42 218.74,103.42 218.85,103.53 218.85,103.72 218.78,103.79 218.61,103.79 UC1.A23
PEG_CTX_GRX_N14: length 16.2
  TOP w0.102: CC37.1 207.48,110.21 211.27,110.21 211.63,109.85 211.63,109.8 212.04,109.39 212.1,109.39 v4(213.24,108.24) 215.81,105.67 215.81,104.92 216.13,104.6 216.45,104.28 216.71,104.02 217.44,104.02 217.44,104.01 217.45,104.01 217.45,104.02 219.54,104.02 219.74,104.21 219.74,104.41 UC1.C24
PEG_CTX_GRX_N15: length 13.3
  TOP w0.102: CC35.1 210.06,111.64 v4(210.77,111.64) 211.1,111.64 211.28,111.45 212.97,109.77 213.22,109.52 213.45,109.28 214.64,108.09 214.71,108.09 215.14,107.66 215.14,107.6 216.59,106.14 216.59,105.41 216.9,105.1 217.29,105.1 217.45,105.26 218.13,105.26 218.4,104.99 218.78,104.99 218.84,105.05 218.84,105.31 218.78,105.37 218.61,105.37 UC1.A25
PEG_CTX_GRX_P0: length 11.6
  TOP w0.102: CC64.1 209.99,92.27 210.58,92.27 210.59,92.26 211.22,92.26 211.25,92.3 211.62,92.3 212.92,93.59 v4(213.39,93.59) 216.97,93.59 217.72,92.84 218.23,92.84 218.39,92.99 219.55,92.99 219.73,93.17 219.73,93.38 UC1.C10
PEG_CTX_GRX_P1: length 10.1
  TOP w0.102: CC62.1 210.05,94.51 v4(211.76,94.51) 217.13,94.51 217.57,94.07 218.3,94.07 218.4,93.96 218.75,93.96 218.89,94.1 218.89,94.19 218.76,94.32 218.59,94.32 UC1.A11
PEG_CTX_GRX_P2: length 13.9
  TOP w0.102: CC60.1 207.49,95.94 207.74,95.94 208.04,95.64 210.36,95.64 210.84,95.17 v4(213.07,95.17) 216.97,95.17 217.75,94.39 218.2,94.39 218.39,94.57 219.54,94.57 219.73,94.77 219.73,94.95 UC1.C12
PEG_CTX_GRX_P3: length 10.6
  TOP w0.102: CC58.1 210.05,97.04 210.61,97.04 v4(211.19,96.46) 211.66,95.99 213.98,95.99 214.02,96.03 214.62,96.03 214.66,95.99 217.22,95.99 217.53,95.68 218.19,95.68 218.34,95.54 218.75,95.54 218.88,95.68 218.88,95.8 218.77,95.9 218.6,95.9 UC1.A13
PEG_CTX_GRX_P4: length 14.2
  TOP w0.102: CC56.1 207.49,98.31 207.61,98.31 207.84,98.08 210.65,98.08 v4(210.89,97.83) 212.29,96.44 212.69,96.44 212.73,96.4 213.39,96.4 213.43,96.44 217.38,96.44 217.81,96 218.27,96 218.41,96.14 219.59,96.14 219.74,96.29 219.74,96.53 UC1.C14
PEG_CTX_GRX_P5: length 10.9
  TOP w0.102: CC54.1 210.09,99.45 211.03,99.45 v4(212.04,98.44) 213.15,97.33 215.5,97.33 215.54,97.36 216.14,97.36 216.18,97.33 218.16,97.33 218.36,97.12 218.71,97.12 218.83,97.24 218.83,97.4 218.74,97.5 218.61,97.5 UC1.A15
PEG_CTX_GRX_P6: length 14.5
  TOP w0.102: UC1.C16 219.75,98.12 219.75,97.91 219.56,97.71 218.35,97.71 218.25,97.61 217.54,97.61 217.26,97.89 214.49,97.89 214.45,97.85 213.87,97.85 213.83,97.89 213.52,97.89 v4(211.49,99.92) 210.92,100.49 207.81,100.49 207.63,100.68 207.5,100.68 CC52.1
PEG_CTX_GRX_P7: length 11.2
  TOP w0.102: CC50.1 210.04,101.85 211.08,101.85 v4(213.27,99.66) 214.1,98.82 215.38,98.82 215.42,98.86 216.02,98.86 216.05,98.82 218.12,98.82 218.25,98.7 218.72,98.7 218.85,98.83 218.85,98.96 218.76,99.06 218.6,99.06 UC1.A17
PEG_CTX_GRX_P8: length 15
  TOP w0.102: CC48.1 207.5,103.26 207.76,103.26 207.91,103.11 211.02,103.11 v4(211.42,102.71) 212.33,101.8 212.41,101.8 212.94,101.26 212.94,101.19 214.57,99.56 217.26,99.56 217.6,99.22 218.07,99.22 218.32,99.48 219.5,99.48 219.55,99.53 219.55,99.69 219.43,99.81 219.22,99.81 UC1.B18
PEG_CTX_GRX_P9: length 11.6
  TOP w0.102: CC46.1 210.05,104.14 210.81,104.14 213.86,101.1 v4(214.16,100.8) 214.88,100.08 215.2,100.08 215.24,100.04 215.83,100.04 215.86,100.08 218.81,100.08 219.04,100.31 219.04,100.42 UC1.B19
PEG_CTX_GRX_P10: length 15.1
  TOP w0.102: UC1.B20 219.23,101.39 219.41,101.39 219.55,101.26 219.55,101.14 219.46,101.06 218.31,101.06 218.23,100.98 215.49,100.98 v4(213.07,103.4) 212.11,104.36 212.11,104.41 211.7,104.82 211.64,104.82 210.99,105.48 208.16,105.48 207.95,105.69 207.52,105.69 CC44.1
PEG_CTX_GRX_P11: length 11.9
  TOP w0.102: UC1.B21 219.07,102.03 219.07,101.91 218.81,101.65 218.24,101.65 218.17,101.72 216.4,101.72 216.37,101.68 215.95,101.68 215.92,101.72 215.59,101.72 v4(214.42,102.89) 210.96,106.35 210.07,106.35 CC42.1
PEG_CTX_GRX_P12: length 15.5
  TOP w0.102: UC1.B22 219.23,102.97 219.41,102.97 219.53,102.85 219.53,102.7 219.45,102.63 218.32,102.63 218.26,102.56 216.05,102.56 214.39,104.22 214.39,104.27 213.97,104.69 213.92,104.69 v4(212.48,106.13) 212.24,106.36 210.46,108.14 208.35,108.14 208.24,108.04 207.51,108.04 CC40.1
PEG_CTX_GRX_P13: length 12.7
  TOP w0.102: CC38.1 210.07,108.97 210.53,108.97 v4(211.55,107.95) 212.69,106.81 213.67,106.81 215.18,105.29 215.18,104.56 215.56,104.18 215.56,104.12 215.99,103.69 216.05,103.69 216.43,103.31 218.21,103.31 218.28,103.23 218.82,103.23 219.04,103.45 219.04,103.57 UC1.B23
PEG_CTX_GRX_P14: length 16.2
  TOP w0.102: CC36.1 207.53,110.4 211.35,110.4 v4(212,109.75) 213.14,108.61 213.2,108.61 213.73,108.07 213.73,108.02 216,105.75 216,105 216.79,104.21 219.47,104.21 219.55,104.29 219.55,104.39 219.39,104.54 219.22,104.54 UC1.B24
PEG_CTX_GRX_P15: length 13.2
  TOP w0.102: UC1.B25 219.03,105.14 219.03,104.98 218.86,104.8 218.32,104.8 218.05,105.07 217.53,105.07 217.37,104.91 216.82,104.91 216.4,105.33 216.4,106.07 v4(214.74,107.72) 211.06,111.41 210.48,111.41 210.44,111.45 210.06,111.45 CC34.1
PG_1.0V: length 3.2
  TOP w0.254: PU800.1 154.95,11.55 155.08,11.42 155.08,11.22 154.89,11.03 154.89,9.82 PR812.2 153.88,9.64 PR800.1
PG_1.8V: length 5.6
  TOP w0.254: PU900.2 126.66,5.91 126.34,5.59 PR900.2 124.86,6.16 124.07,6.16 123.97,6.25 v1(123.44,6.25) 122.93,6.25 122.54,5.86 PR906.2
PG_2.5V: length 2.3
  TOP w0.254: PU400.2 284.35,44.59 283.91,44.15 v1(283.91,44) 283.91,43.38 PR400.2
PG_IO: length 3.8
  TOP w0.254: v2(275.31,97.58) v1(274.31,97.58) 273.83,97.58 273.47,97.93 PR300.2
  BOTTOM w0.254: PU300.13 274.82,97.99 275.22,97.58 v2(275.31,97.58)
PGOOD_3V: length 3.3
  TOP w0.254: PR102.1 115.38,10.33 PR107.2 115.38,8.73 v1(115.14,8.49) 114.46,7.8 PU100.9
PGOOD_3VR: length 3.7
  TOP w0.109: PR508.1 315.66,30.26 v1(315.79,30.38)
  TOP w0.254: PU501.9 313.02,29.44 PR515.2
  TOP w0.508: PR515.2 314.71,30.26 PR508.1
PGOOD_5V: length 63.5
  TOP w0.109: v2(115.11,11.9) 115.11,11.49 115.38,11.22 PR103.1
  IN4 w0.102: v2(67.94,11.09) 68.23,10.79 68.59,10.79 70.98,8.4 74.33,8.4 76.71,6.02 76.71,2.89 v2(76.3,2.48)
  BOTTOM w0.109: PU101.9 68.23,11.58 67.94,11.28 v2(67.94,11.09) 67.94,10.79 67.4,10.26 PR110.2 ; v2(76.3,2.48) 76.66,2.84 81.56,2.84 83.12,4.39 89.73,4.39 90.53,3.59 91.83,3.59 92.21,3.97 100.49,3.97 101.42,3.04 109.38,3.04 113.42,7.08 113.42,9.03 v1(114.86,10.46) 115.11,10.72 v2(115.11,11.9)
PGOOD_5VR: length 2.5
  TOP w0.254: PU500.9 311.71,39.33 PR500.2 313.4,40.15 PR509.1
PLTRST_CPU#: length 166.8
  TOP w0.076: v2(262.32,111.85) 262.3,111.87 259.93,111.87 259.66,111.59 258.76,111.59 258.6,111.75 258.26,111.75 UC1.BP35
  TOP w0.089: UH1.AG5 183.35,41.56 183.38,41.58 183.38,41.78 183.51,41.91 183.51,42.8 183.7,42.99 183.7,46.9 v2(183.52,47.08)
  IN1 w0.102: v2(200.89,118.44) 201.43,118.44 201.81,118.06 201.81,116.89 204.26,114.44 208.04,114.44 210.72,117.12 221.81,117.12 222.53,116.4 225.17,116.4 226.64,114.92 228.25,114.92 228.79,115.46 242.17,115.46 242.71,114.92 243.71,114.92 244.27,114.37 246.85,114.37 247.36,114.89 252.05,114.89 253.53,113.42 260.76,113.42 v2(262.32,111.85)
  IN2 w0.081: v2(183.52,47.08) 184.07,47.08 185.05,48.06 185.05,49.81 185.86,50.61 185.86,53.54 188.03,55.72 192.11,55.72 192.93,56.53 194.91,56.53 195.32,56.94 195.32,59.09 196.64,60.41 196.64,61.15 197.02,61.53 197.02,62.09 196.68,62.44 196.68,65.83 197.02,66.17 197.02,79.29 193.55,82.76 193.55,85.8 191.84,87.51 191.84,89.02 191.66,89.19 191.66,96.23 191.28,96.61 191.28,102.32 191.66,102.7 191.66,104 194.25,106.58 194.25,112.07 196,113.82 196,114.41 200.02,118.44 v2(200.89,118.44)
PLTRST_GPU#: length 63.8
  TOP w0.109: RH625.1 160.1,35.5 160.1,47.26 163.47,50.63 v3(163.66,50.63) 164.27,51.25 164.27,55.72 181.46,72.9 181.46,74.81 181.14,75.12 181.14,77.35 180.11,78.38 180.11,81.56 180.62,82.07 182.43,82.07 182.67,82.3 183.47,82.3 183.68,82.08 184.27,82.08 184.49,82.31 UV63.2
PLTRST_LAN#: length 111
  TOP w0.109: v2(180.63,76.29) 180.63,75.26 181.22,74.67 181.22,73 163.92,55.71 163.92,51.65 v3(160.34,48.07) 159.73,47.46 159.73,35.88 158.46,34.61 RH624.1
  IN3 w0.081: v2(192.98,124.79) 192.36,124.16 192.36,122.48 191.43,121.56 189.63,121.56 189.02,120.95 189.02,115.92 187.34,114.24 187.34,111.6 190.72,108.22 190.72,107.03 191.68,106.07 191.68,102.74 188.7,99.76 188.7,95.31 188.13,94.73 188.13,89.31 187.28,88.46 187.28,85.69 185.84,84.25 185.84,82.87 183.71,80.74 182.95,80.74 180.63,78.42 v2(180.63,76.29)
  BOTTOM w0.109: UL1.36 192.7,125.08 v2(192.98,124.79)
PLTRST_MMI#: length 173.6
  TOP w0.109: RH626.2 158.73,31.33 v2(159.39,31.33)
  IN3 w0.081: v2(46.98,36.77) 46.98,37.04 47.64,37.7 49.41,37.7 50.03,38.32 53.26,38.32 53.56,38.03 55.06,38.03 55.58,37.5 55.58,37.47 55.94,37.11 56.47,37.11 56.79,36.8 57.92,36.8 58.36,37.24 58.36,37.95 58.79,38.38 66.06,38.38 66.2,38.24 66.88,38.24 67.35,38.72 67.35,38.89 67.35,39.02 69.91,41.59 70.5,41.59 71.69,42.78 73.02,42.78 74.5,41.29 79.78,41.29 81.57,39.5 84.6,39.5 84.98,39.88 88.14,39.88 88.55,40.29 91.19,40.29 91.8,40.91 93.23,40.91 97.23,44.9 106.06,44.9 106.88,44.09 114.67,44.09 116.84,41.93 117.39,41.37 124.21,41.37 125.83,42.99 136.55,42.99 137.08,43.53 138.45,43.53 138.54,43.44 139.91,43.44 141.52,41.83 149.85,41.83 150.11,41.57 150.54,41.57 150.92,41.19 153.22,41.19 156.33,38.08 156.33,33.79 158.79,31.33 v2(159.39,31.33) ; v2(41.08,29.05) 40.8,28.77 40.8,27.12 38.96,25.28 37.76,25.28 33.97,21.48 31.73,21.48 30.74,20.5 28.89,20.5 25.67,17.28 v2(25.67,11.9)
  BOTTOM w0.109: v2(25.67,11.9) 25.32,11.9 24.96,11.54 24.5,11.54 24.29,11.75 UR1.1 ; v2(41.08,29.05) v1(41.08,29.84) 41.08,30.21 40.7,30.59 40.7,32.33 40.93,32.55 40.93,32.64 41.15,32.86 41.15,33.62 41.44,33.91 43.32,33.91 43.58,34.17 44.99,34.17 45.05,34.23 46.21,34.23 46.79,34.81 46.79,36.59 v2(46.98,36.77)
PLTRST_TPM#: length 187.3
  TOP w0.109: v2(123.37,20.69) 123,21.06 123,21.76 122.85,21.91 UZ12.17 ; RH623.1 158.83,33.29 159.37,33.29 v2(159.84,33.75) v1(159.84,34.46)
  IN1 w0.102: v2(99.79,30.62) 99.79,31.33 99,32.12 97.83,32.12 95.09,34.87 95.09,41.24 95.66,41.81 99.37,41.81 99.65,42.09 99.65,44.57 98.19,46.03 v2(98.01,46.03)
  IN2 w0.081: v2(123.37,20.69) 122.84,21.23 120.89,21.23 120.38,21.73 119.68,21.73 119.44,21.97 119.44,22.26 118.85,22.85 118.09,22.85 117.4,23.54 117.4,23.83 116.79,24.44 115.97,24.44 114.59,25.82 109.35,25.82 108.75,26.42 104.58,26.42 101.98,29.02 100.75,29.02 99.79,29.98 v2(99.79,30.62)
  IN3 w0.081: v2(46.75,39.73) 46.8,39.73 47.38,39.16 48.81,39.16 50.03,40.38 54.29,40.38 54.51,40.16 56.63,40.16 56.68,40.11 56.95,39.84 65.51,39.84 65.71,40.04 65.76,40.04 66.26,40.54 66.8,40.54 69.82,43.56 70.39,43.56 71.04,44.21 75.6,44.21 77.23,42.57 80.29,42.57 81.64,41.22 87.99,41.22 88.16,41.4 90.81,41.4 91.38,41.97 91.82,41.97 95.59,45.73 97.72,45.73 v2(98.01,46.03) 98.17,45.87 108.89,45.87 109.78,44.98 114.96,44.98 117.7,42.24 123.71,42.24 125.36,43.9 135.24,43.9 136.86,45.52 138.39,45.52 139.65,44.27 140.27,44.27 141.18,43.35 150.67,43.35 150.97,43.06 153.55,43.06 154.52,42.1 156.82,42.1 159.49,39.43 159.49,34.1 v2(159.84,33.75)
  BOTTOM w0.109: v2(46.75,39.73) 46.75,39.45 46.38,39.08 RH622.2
PM_LANPHY_ENABLE: length 134.8
  TOP w0.102: v2(169.51,22.72) 169.51,22.83 170.12,23.44 173.01,23.44 173.31,23.75 173.94,23.75 174.07,23.62 UH1.BF41
  TOP w0.109: v2(193.44,103.41) 193.57,103.53 v1(194.15,103.53)
  IN2 w0.081: v2(169.51,22.72) 169.9,23.12 175.44,23.12 176.27,22.29 176.6,22.29 177.07,21.82 177.6,21.82 178.1,22.32 178.1,23.14 179.5,24.54 180.3,24.54 180.62,24.86 180.62,26.77 181.41,27.56 181.41,32.07 181.64,32.29 181.64,36.29 181.83,36.48 181.83,37.59 182.87,38.63 182.87,39.69 182.15,40.41 182.15,41.17 182.39,41.41 182.39,43.24 185.5,46.36 185.5,46.77 186.54,47.81 186.54,53.26 188.32,55.03 195.24,55.03 196.83,56.61 196.83,58.48 196.43,58.87 196.43,59.33 197.29,60.18 197.29,61 197.77,61.48 197.77,66.27 198.06,66.56 198.06,79.63 194.27,83.41 194.27,87.82 193.25,88.84 192.66,88.84 192.18,89.32 192.18,96.35 191.75,96.79 191.75,101.71 v2(193.44,103.41)
  IN4 w0.102: v2(184.78,118.17) 185.71,117.24 185.71,111.78 186.36,111.13 186.36,108.54 188.09,106.81 190.04,106.81 v2(193.44,103.41)
  BOTTOM w0.109: v2(184.78,118.17) 184.53,118.42 RL7.1
