# Allegro board LAH271PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB20_N9: length 145.8
  TOP w0.102: v2(81.87,32.79) 81.87,31.63 82.01,31.5 82.01,31.44 82.42,31.03 82.47,31.03 82.73,30.77 82.73,30.2 83.08,29.85 v4(83.3,29.85) 83.55,29.85 83.97,30.27 LV3.4 ; UH1.M6 190.96,40.34 v2(190.96,39.91)
  IN4 w0.102: v2(190.96,39.91) 190.81,40.07 190.81,40.36 191.14,40.7 191.14,42 190.4,42.74 190.4,45.78 189.78,46.39 189.78,47.22 190.01,47.44 190.01,49.22 188.67,50.56 187.83,50.56 184.42,53.97 181.94,53.97 181.48,54.43 174.43,54.43 171.21,51.22 168.86,51.22 162.71,45.07 162.71,43.97 162.38,43.64 161.75,43.64 153.76,35.66 153.2,35.66 151.81,34.27 150.9,34.27 149.05,32.42 146.38,32.42 145.77,33.03 142.17,33.03 141.43,33.77 136.9,33.77 135.15,35.51 135.14,35.51 134.91,35.75 134.91,36.77 134.73,36.94 130.81,36.94 130.32,36.46 130.32,36.17 128.62,34.48 127.95,34.48 127.37,35.06 125.24,35.06 123.8,33.62 123.8,33.19 123.23,32.62 120.06,32.62 119.19,31.75 114.7,31.75 114.27,32.18 112.14,32.18 111.99,32.04 103.07,32.04 102.31,32.8 102.31,33.96 100.87,35.41 98.64,35.41 98.42,35.18 96.01,35.18 95.4,34.57 85.91,34.57 85.06,33.71 82.14,33.71 81.87,33.45 v2(81.87,32.79)
USB20_N9_R: length 12.2
  TOP w0.102: LV3.3 83.97,32.71 83.81,32.87 83.81,33.1 83.95,33.24 v4(83.95,33.47) 83.95,34.15 83.05,35.04 82.29,35.04 81.84,34.6 81.84,33.83 81.41,33.39 80.62,33.39 80.26,33.76 80.26,33.91 80.38,34.03 80.79,34.03 DV30.2 80.97,34.46 80.33,34.46 80.23,34.56 80.23,34.95 80.73,35.45 80.73,35.83 81.14,36.23 JTS1.2
USB20_N10: length 111.3
  TOP w0.102: UH1.H3 192.49,42.46 192.49,42.78 192.43,42.84 192.43,43.66 192.9,44.14 192.9,45.47 193.31,45.88 193.79,45.88 195.05,47.15 195.05,48.51 195.52,48.98 195.52,49.25 195.46,49.31 v2(195.18,49.31) ; JUSH1.19 185.1,2.98 184.95,3.14 184.95,3.79 185.38,4.23 186.09,4.23 190.11,8.25 191.77,8.25 192.13,8.6 195.12,8.6 196.06,7.66 197.84,7.66 198.05,7.87 198.05,8.16 v2(198.43,8.54)
  IN2 w0.094: v2(198.43,8.54) 198.2,8.76 197.99,8.76 197.91,8.69 197.91,7.91 198.05,7.77 198.84,7.77 199.69,8.62 199.69,13.18 200.99,14.48 206.72,14.48 211.9,19.66 211.9,25.29 210.84,26.35 207.89,26.35 207.57,26.03 195.42,26.03 195.13,26.32 194.4,26.32 194.14,26.07 193.09,26.07 192.46,25.43 191.07,25.43 190.39,26.11 190.39,26.22 189.12,27.49 189.12,30.69 190.18,31.76 190.65,31.76 191.48,30.93 194.69,30.93 195.64,31.88 195.64,36.96 196.36,37.67 196.36,42.51 195.82,43.05 195.82,45.86 196.42,46.46 196.42,49.15 195.78,49.78 195.57,49.78 195.18,49.39 v2(195.18,49.31)
USB20_N11: length 128.3
  TOP w0.102: UH1.R10 189.72,38.58 v2(190.09,38.21)
  IN4 w0.102: v2(102.99,33.03) 102.99,33.11 103.38,33.5 104.03,33.5 105.02,32.52 111.36,32.52 111.77,32.93 114.78,32.93 115.54,32.17 118.97,32.17 120.31,33.51 122.03,33.51 122.75,34.23 123.81,34.23 125.12,35.54 129.08,35.54 129.55,36.01 129.55,36.85 130.59,37.89 135.08,37.89 138.74,34.23 142.36,34.23 143.15,33.44 145.95,33.44 146.55,32.85 148.76,32.85 151.73,35.82 151.73,36.29 152.9,37.46 154.35,37.46 156.9,40.01 157.47,40.01 161.01,43.55 161.01,43.94 168.69,51.63 171.05,51.63 174.35,54.93 181.66,54.93 182.01,55.28 183.72,55.28 184.27,54.73 192.14,54.73 193.32,53.54 193.32,50.76 191.58,49.02 191.58,43.05 191.91,42.72 191.91,40.37 191.52,39.97 191.52,39.83 191.06,39.37 190.76,39.37 190.62,39.52 189.85,39.52 189.46,39.13 189.46,38.69 189.7,38.45 189.93,38.45 190.09,38.29 v2(190.09,38.21)
  BOTTOM w0.102: v2(102.99,33.03) 103.06,33.1 103.6,33.1 103.99,33.49 LV2.1
USB20_N11_R: length 16.3
  TOP w0.102: 103.45,36.69 104.28,36.69 104.45,36.86 104.45,37.11 101.99,39.57 101.99,40.18 101.5,40.67 JEDP1.15 ; 103.45,36.69 104.29,35.84 104.29,35.59 104.48,35.41 104.83,35.41 104.89,35.35 104.89,35.23 v2(104.57,34.91) ; 103.45,36.69 DV41.2
  BOTTOM w0.102: v2(104.57,34.91) 104.74,34.91 105.22,35.39 105.22,36.44 104.91,36.75 v4(104.41,36.75) 103.83,36.75 103.68,36.6 103.68,36.37 103.76,36.3 103.92,36.3 103.99,36.23 LV2.2
USB20_N14: length 143.8
  TOP w0.089: UH1.E5 v2(193.66,41.03)
  IN4 w0.102: v2(193.66,41.03) 193.93,41.03 194.11,41.21 195.32,41.21 196.53,40.01 196.53,39.36 198.25,37.63 199.39,37.63 200.13,38.37 201.52,38.37 203.07,36.81 203.98,36.81 209.48,31.32 211.47,31.32 212.33,30.46 212.91,30.46 216.7,26.66 226.43,26.66 227.47,25.62 231.46,25.62 232.04,26.21 247.64,26.21 250.04,23.81 250.88,23.81 256.07,18.62 268.68,18.62 269.91,19.85 273.37,19.85 277.43,15.79 277.43,15.07 279.58,12.92 283.85,12.92 284.82,11.94 288.23,11.94 289,11.18 289.75,11.18 291.27,9.65 295.94,9.65 296.09,9.5 307.71,9.5 307.98,9.77 309.43,9.77 309.72,9.49 314.36,9.49 314.61,9.24 314.61,8.84 v2(314.74,8.7)
  BOTTOM w0.102: v2(314.74,8.7) 314.61,8.83 314.61,10.61 313.86,11.36 313.09,11.36 312.63,10.89 L1.1
USB20_N14_R: length 8.7
  BOTTOM w0.102: JNGFF1.5 317.9,7.97 317.62,7.69 v4(316.08,7.69) 314.07,7.69 314.03,7.65 313.43,7.65 313.39,7.69 312.84,7.69 312.63,7.9 L1.2 312.46,9.02 RI49.2
USB20_NA: length 10.6
  IN4 w0.102: v2(22.97,32.8) 22.57,32.4 22.57,32.06 22.75,31.88 25.93,31.88 27.87,33.82 27.87,34.58 v2(27.41,35.04)
  BOTTOM w0.102: v2(22.97,32.8) 22.81,32.96 22.81,33.26 22.59,33.48 22.1,33.48 RT562.2 ; UT1.D20 v2(27.41,35.04)
USB20_NB: length 11.9
  IN2 w0.094: v2(19.27,35.34) 19.71,35.78 20.31,35.78 22.15,37.62 23.63,37.62 24.06,37.19 25.83,37.19 26.09,36.93 27.38,36.93 27.79,36.53 27.79,36 27.47,35.68 v2(27.4,35.68)
  BOTTOM w0.102: RT558.1 v2(19.27,35.34) ; UT1.D19 v2(27.4,35.68)
USB20_P1: length 209.6
  TOP w0.102: UH1.J2 192.07,42.39 192.15,42.31 192.25,42.31 192.29,42.35 192.29,42.68 192.16,42.81 191.97,42.81 191.9,42.88 191.9,44.12 191.74,44.28 191.74,44.5 191.85,44.61 192.07,44.61 192.23,44.46 v2(192.23,44.29) ; v2(350.99,45.32) 350.73,45.58 350.73,46.87 350.45,47.15 350.45,47.63 350.61,47.79 UI1.3
  IN4 w0.102: v2(192.23,44.29) 192.98,44.29 193.32,44.63 193.32,45.85 193.87,46.4 195.96,46.4 199.89,42.47 202.92,42.47 204.9,40.49 204.9,39.67 207.37,37.2 208.64,37.2 210.17,35.67 210.17,34.62 211.8,33 212.05,33 212.48,32.57 213.72,32.57 214.27,32.02 214.27,31.65 217.6,28.31 227.34,28.31 228.36,27.3 230.8,27.3 231.37,27.86 232.71,27.86 233.6,28.75 236.15,28.75 237.04,27.86 248.5,27.86 250.8,25.56 251.83,25.56 255.88,21.5 274.59,21.5 277.92,18.18 280.1,18.18 281.22,17.06 283.74,17.06 284.56,16.23 284.56,14.63 285.66,13.53 288.91,13.53 289.67,12.77 290.44,12.77 291.24,11.97 294.25,11.97 295.03,12.75 295.43,12.75 295.62,12.57 295.62,12.17 295.76,12.03 295.76,11.25 296.36,10.64 306.99,10.64 307.95,11.6 311.26,11.6 312.02,10.84 315.96,10.84 317.36,12.24 319.01,12.24 319.7,12.93 320.75,12.93 321.03,12.65 321.75,12.65 322.88,13.78 325.63,13.78 325.78,13.93 327.98,13.93 334.33,20.28 334.98,20.28 335.81,21.11 335.81,26.16 336.2,26.55 337.92,26.55 340.04,28.66 340.04,31.84 344.52,36.32 345.7,36.32 346.59,37.21 346.59,40.94 349.37,43.72 350.4,43.72 350.74,44.07 350.74,45.07 v2(350.99,45.32)
USB20_P1_R: length 22.6
  TOP w0.102: JUSB1.3 360.67,54.5 360.77,54.4 361.37,54.4 361.98,55 361.98,58.78 361.25,59.5 357.89,59.5 356.33,57.94 356.33,57.88 355.91,57.47 355.86,57.47 355.45,57.06 v4(355.45,56.05) 355.45,54.03 354.97,53.55 354.23,53.55 354.12,53.43 DI2.3 353.24,53.28 353.11,53.28 352.89,53.05 352.11,53.05 LI3.1 351.82,52.77 RI61.2
USB20_P2: length 204
  TOP w0.094: UH1.N15 190.72,36.65 190.87,36.65 v2(191.08,36.44)
  TOP w0.102: v2(350.59,36.7) 350.22,37.06 350.22,37.28 350.38,37.43 UI2.3
  IN4 w0.102: v2(191.08,36.44) 191.33,36.69 193.95,36.69 197.83,32.81 199.23,32.81 200.43,31.61 202.95,31.61 203.6,32.26 205.49,32.26 206.57,31.18 206.57,30.14 209.02,27.69 211.38,27.69 214.4,24.67 225.4,24.67 226.48,23.59 232.52,23.59 233.15,24.22 246.5,24.22 254.16,16.56 267.44,16.56 269.86,14.14 274.08,14.14 278.06,10.15 280.13,10.15 280.75,9.52 281.03,9.52 281.49,9.07 282.84,9.07 283.31,8.6 289.19,8.6 290.21,7.57 295.05,7.57 295.6,7.02 300.64,7.02 300.73,7.11 305.71,7.11 307.18,5.65 307.37,5.65 307.37,5.65 308.91,5.65 312.14,5.65 312.28,5.51 313.02,5.51 313.94,4.59 315.36,4.59 315.58,4.37 322.64,4.37 323.39,5.11 323.39,6.73 325.69,9.03 331.74,9.03 333.3,7.47 335.49,7.47 337.07,9.06 337.97,9.06 343.55,14.64 343.55,15.89 342.79,16.65 342.79,17.22 343.61,18.04 343.61,18.65 342.42,19.84 342.42,29.36 343.87,30.82 344.2,30.82 345.61,32.23 346.96,32.23 350.35,35.62 350.35,36.46 v2(350.59,36.7)
USB20_P2_R: length 18.7
  TOP w0.102: RI70.2 353.25,40.18 LI4.1 353.25,39.79 353.39,39.64 353.39,39.41 353.62,39.18 354.67,39.18 354.78,39.07 354.78,38.95 DI3.3 354.68,38.08 354.78,37.98 354.78,37.34 355.21,36.91 358.13,36.91 358.42,37.2 360.8,37.2 361.6,36.4 361.6,32.42 361.44,32.26 361.19,32.26 360.67,32.78 JUSB2.3
USB20_P4: length 217
  TOP w0.102: UH1.L9 v2(191.88,39.31)
  IN1 w0.102: v2(17.17,32.58) 16.86,32.89 16.56,32.89 16.29,32.62 16.29,31.09 19.81,27.56 19.81,25.9 21.16,24.55 26.06,24.55 27.53,23.08 31.3,23.08 32.09,22.28 35.14,22.28 35.68,21.74 42.66,21.74 43.17,21.24 44.11,21.24 46.19,19.15 48.52,19.15 48.56,19.11 49.75,19.11 50.16,18.7 51.99,18.7 52.19,18.49 54,18.49 55.6,16.9 56.49,16.9 58.42,18.82 59.6,18.82 60.09,19.31 61.62,20.85 65.81,20.85 67.39,22.43 70.3,22.43 73.27,25.41 76.84,25.41 77.15,25.71 79.18,25.71 79.45,25.99 83.16,25.99 84.27,24.88 87.09,24.88 88.35,23.62 92.12,23.62 92.85,22.89 93.91,22.89 96.4,20.4 97.93,20.4 98.44,19.9 100.8,19.9 101.3,20.4 107.23,20.4 107.64,20.81 109.41,20.81 109.75,21.15 111.25,21.15 111.99,20.4 117.08,20.4 117.89,19.59 118.25,19.59 118.79,20.13 119.33,20.13 119.78,19.68 120.28,19.68 120.42,19.82 120.42,20.21 121.19,20.98 121.72,20.98 124.28,23.53 126.88,23.53 127.41,24.06 127.41,24.43 130.13,27.14 130.13,28.84 130.69,29.4 136.98,29.4 137.62,28.76 139.35,28.76 139.98,28.13 140.45,28.13 141,27.58 142.03,27.58 142.8,28.35 144.96,28.35 144.97,28.36 145.63,28.36 146.5,29.23 147.11,29.23 147.27,29.06 147.94,29.06 148.57,29.69 154.25,29.69 154.72,30.16 156.1,30.16 157.48,31.54 157.48,32.22 158.66,33.39 158.66,33.87 160.35,35.56 161.9,35.56 162.81,34.64 164.43,34.64 164.93,35.13 164.93,35.66 165.32,36.05 165.71,36.05 166.28,36.62 168.47,36.62 169.22,37.37 173.58,37.37 174.16,37.95 174.16,40.26 173.37,41.04 173.37,41.46 174.95,43.04 176.02,43.04 176.79,42.26 189.15,42.26 190.33,41.08 190.84,41.08 191.54,40.39 191.54,39.67 191.05,39.19 191.05,39.07 191.11,39.01 191.58,39.01 v2(191.88,39.31)
  BOTTOM w0.102: RT559.2 19.13,33.29 18.97,33.29 18.5,32.82 17.4,32.82 v2(17.17,32.58)
USB20_P5: length 218
  TOP w0.102: UH1.L2 191.51,43.01 191.51,43.98 191.09,44.39 v2(191.09,44.41)
  IN1 w0.102: v2(191.09,44.41) 191.65,43.85 191.65,43.33 191.06,42.74 179.2,42.74 178.06,43.89 176.67,43.89 176.23,43.45 174.76,43.45 172.88,41.56 172.88,40.75 173.71,39.92 173.71,38.33 173.16,37.78 169.64,37.78 169.36,38.06 168.65,38.06 167.62,37.03 166.11,37.03 165.6,36.51 164.82,36.51 164.28,37.05 161.02,37.05 158.24,34.27 158.24,33.55 157.05,32.36 157.05,31.71 156.59,31.25 155.54,31.25 154.85,30.56 154.54,30.56 154.08,30.11 146.81,30.11 145.49,28.8 142.52,28.8 142.2,29.11 142.2,29.6 141.8,30.01 140.8,30.01 139.89,29.1 138.09,29.1 136.83,30.36 135.3,30.36 134.41,31.24 133.46,31.24 133.45,31.24 132.2,31.24 131.2,30.24 130.9,30.24 129.7,29.04 129.7,27.58 127.51,25.39 125.49,25.39 121.53,21.43 121.02,21.43 120.32,20.73 117.64,20.73 117.02,21.35 114.71,21.35 114.17,20.81 112.17,20.81 111.21,21.77 108.02,21.77 107.06,20.81 101.1,20.81 100.61,20.32 98.59,20.32 95.5,23.41 92.93,23.41 92.24,24.1 91.66,24.1 89.64,26.12 87.12,26.12 86.31,26.93 83.05,26.93 82.8,27.18 81.75,27.18 81.14,26.57 79.45,26.57 79.01,26.13 76.97,26.13 76.66,25.82 73.1,25.82 70.64,23.35 68.62,23.35 68.55,23.28 67.33,23.28 67.32,23.29 66.96,23.29 66.93,23.26 66.27,23.26 64.26,21.25 61.29,21.25 61.28,21.24 61.13,21.24 60.13,20.24 58.95,20.24 57.02,18.32 54.76,18.32 54.17,18.9 52.36,18.9 52.15,19.11 50.33,19.11 49.92,19.52 48.91,19.52 48.8,19.63 46.31,19.63 44.28,21.66 43.32,21.66 42.83,22.15 35.85,22.15 35.31,22.69 32.27,22.69 31.27,23.69 28.47,23.69 27.36,24.81 27.36,29.02 25.84,30.54 20.12,30.54 18.55,32.11 18.55,33.77 18.41,33.91 18.09,33.91 v2(17.82,33.64)
  BOTTOM w0.102: RT555.1 16.3,35.84 16.07,35.84 15.85,35.61 15.85,34.84 16.06,34.63 16.85,34.63 17.24,34.24 17.34,34.24 17.82,33.76 v2(17.82,33.64)
USB20_P6: length 3.6
  TOP w0.102: v2(192.49,40.39) 192.18,40.7 UH1.K6
  BOTTOM w0.102: v2(192.49,40.39) 192.19,40.28 192.09,40.33 191.86,40.56 191.86,41.15 192.11,41.41 192.11,41.94 T314.1
USB20_P8: length 141.3
  TOP w0.102: v2(194.11,45.31) 194.05,45.25 193.47,45.25 193.29,45.07 193.29,43.93 192.83,43.47 192.83,42.99 193,42.82 193,41.97 192.91,41.88 192.91,41.56 193.14,41.33 UH1.G5
  IN4 w0.102: v2(291.44,4.22) 291.52,4.3 291.81,4.3 291.9,4.22 291.9,4.06 291.58,3.75 285.94,3.75 285.61,4.07 283.37,4.07 282.45,4.99 276.34,4.99 275.62,5.71 273.11,5.71 272.97,5.57 261.58,5.57 261.47,5.68 261.47,8.33 262.04,8.9 262.04,10.77 260.05,12.76 252.75,12.76 246.83,18.68 233.26,18.68 232.16,19.79 213.81,19.79 209.99,23.6 208.5,23.6 208.31,23.79 207.47,23.79 206.58,24.68 202.17,24.68 199.93,26.93 199.21,26.93 195.16,30.98 192.22,30.98 190.74,32.46 190.74,34.31 191.05,34.62 191.05,35.69 190.65,36.09 190.65,37.52 191.13,38 191.56,38 192.58,39.02 192.58,39.39 192.92,39.73 192.92,40 193.17,40.25 193.17,42.77 194.96,44.56 194.96,44.99 194.75,45.19 194.22,45.19 v2(194.11,45.31)
  BOTTOM w0.102: v2(291.44,4.22) 291.61,4.22 291.77,4.06 291.77,3.75 291.62,3.6 291.32,3.6 291.16,3.44 291.16,3.28 291,3.13 JNGFF2.7
USB20_P9: length 145.7
  TOP w0.102: v2(82.56,32.79) 82.56,32.58 82.49,32.5 82.15,32.5 82.06,32.42 82.06,31.71 v4(82.37,31.4) 82.92,30.85 82.92,30.28 83.13,30.08 83.51,30.08 83.77,30.34 83.77,30.45 83.71,30.51 83.53,30.51 83.47,30.57 LV3.1 ; UH1.N8 190.58,40.07 190.58,40.25 190.44,40.39 190.22,40.39 v2(190.14,40.32)
  IN4 w0.102: v2(190.14,40.32) 190.36,40.1 190.51,40.1 190.62,40.2 190.62,40.44 190.95,40.78 190.95,41.92 190.21,42.67 190.21,45.7 189.6,46.31 189.6,47.3 189.82,47.52 189.82,49.14 188.59,50.37 187.75,50.37 184.34,53.78 181.86,53.78 181.4,54.25 174.5,54.25 171.29,51.03 168.94,51.03 162.9,45 162.9,43.9 162.46,43.46 161.83,43.46 153.84,35.47 153.27,35.47 151.88,34.08 150.98,34.08 149.13,32.23 146.31,32.23 145.69,32.85 142.09,32.85 141.36,33.58 136.82,33.58 135.08,35.32 135.06,35.32 134.72,35.67 134.72,36.69 134.65,36.76 130.88,36.76 130.51,36.38 130.51,36.1 128.7,34.29 127.87,34.29 127.29,34.87 125.32,34.87 123.99,33.54 123.99,33.11 123.31,32.43 120.14,32.43 119.27,31.56 114.62,31.56 114.19,31.99 112.21,31.99 112.07,31.85 102.99,31.85 102.13,32.72 102.13,33.89 100.79,35.22 98.72,35.22 98.49,35 96.09,35 95.48,34.38 85.99,34.38 85.13,33.52 82.22,33.52 82.06,33.37 82.06,33.24 82.16,33.14 82.38,33.14 82.56,32.95 v2(82.56,32.79)
USB20_P9_R: length 12.2
  TOP w0.102: LV3.2 83.47,32.72 83.62,32.87 83.62,33.18 83.72,33.28 83.72,34.1 83.01,34.82 v4(82.69,34.82) 82.33,34.82 82.03,34.52 82.03,33.75 81.49,33.2 80.54,33.2 80.07,33.68 80.07,33.88 79.95,34 79.5,34 DV30.3 79.3,34.46 79.94,34.46 80.04,34.56 80.04,35.03 80.54,35.53 80.54,35.86 80.14,36.26 JTS1.3
USB20_P10: length 111.4
  TOP w0.102: JUSH1.18 184.6,2.99 184.75,3.15 184.75,3.87 185.3,4.42 186.01,4.42 190.03,8.44 191.69,8.44 192.05,8.79 195.2,8.79 196.14,7.85 197.76,7.85 197.86,7.95 197.86,8.2 v2(197.5,8.55) ; v2(195.18,49.97) 195.18,49.86 195.71,49.33 195.71,48.9 195.24,48.43 195.24,47.07 193.87,45.69 193.39,45.69 193.09,45.39 193.09,44.06 192.62,43.58 192.62,42.92 192.69,42.85 192.69,42.63 UH1.H2
  IN2 w0.094: v2(195.18,49.97) 195.87,49.97 196.61,49.23 196.61,46.38 196.01,45.78 196.01,43.13 196.55,42.59 196.55,37.59 195.84,36.88 195.84,31.8 194.77,30.73 191.4,30.73 190.57,31.56 190.26,31.56 189.31,30.61 189.31,27.58 190.59,26.3 190.59,26.19 191.16,25.63 192.38,25.63 193.01,26.26 194.06,26.26 194.32,26.52 195.21,26.52 195.5,26.23 207.49,26.23 207.81,26.54 210.92,26.54 212.1,25.37 212.1,19.58 206.8,14.28 201.07,14.28 199.89,13.1 199.89,8.54 198.92,7.58 197.97,7.58 197.72,7.83 197.72,8.34 v2(197.5,8.55)
USB20_P11: length 128.3
  TOP w0.102: UH1.P9 189.92,39.18 190.18,38.91 v2(190.31,38.91)
  IN4 w0.102: v2(102.99,33.69) 104.11,33.69 105.1,32.7 111.28,32.7 111.69,33.11 114.86,33.11 115.61,32.36 118.89,32.36 120.23,33.7 121.95,33.7 122.67,34.42 123.74,34.42 125.05,35.73 129,35.73 129.36,36.09 129.36,36.93 130.51,38.08 135.16,38.08 138.82,34.42 142.44,34.42 143.22,33.63 146.03,33.63 146.62,33.04 148.69,33.04 151.54,35.9 151.54,36.37 152.82,37.65 154.27,37.65 156.82,40.2 157.39,40.2 160.82,43.63 160.82,44.02 168.62,51.82 170.97,51.82 174.27,55.12 181.58,55.12 181.93,55.47 183.8,55.47 184.35,54.91 192.22,54.91 193.51,53.62 193.51,50.69 191.77,48.94 191.77,43.13 192.1,42.8 192.1,40.29 191.71,39.9 191.71,39.75 191.14,39.19 190.69,39.19 190.54,39.33 189.93,39.33 189.65,39.05 189.65,38.77 189.77,38.64 190.19,38.64 190.31,38.76 v2(190.31,38.91)
  BOTTOM w0.102: LV2.4 103.49,34.09 103.8,33.78 103.8,33.57 103.52,33.29 103.32,33.29 102.99,33.63 v2(102.99,33.69)
USB20_P11_R: length 16.3
  TOP w0.102: 105.33,36.69 104.73,36.69 104.64,36.78 104.64,37.19 102.18,39.65 102.18,40.26 101.69,40.75 101.69,42.54 101.77,42.62 101.96,42.62 102,42.66 JEDP1.16 ; 105.33,36.69 104.48,35.84 104.48,35.67 104.55,35.6 104.91,35.6 105.08,35.43 105.08,35.25 v2(105.41,34.92) ; 105.33,36.69 DV41.3
  BOTTOM w0.102: v2(105.41,34.92) 105.41,36.51 104.99,36.94 104.75,36.94 104.71,36.98 104.08,36.98 104.04,36.94 103.75,36.94 103.49,36.68 LV2.3
USB20_P14: length 143.8
  TOP w0.089: UH1.F6 194.17,40.49 v2(194.2,40.53)
  IN4 w0.102: v2(314.08,8.7) 314.17,8.7 314.42,8.95 314.42,9.16 314.28,9.3 309.64,9.3 309.36,9.59 308.06,9.59 307.79,9.31 296.01,9.31 295.86,9.46 291.2,9.46 289.67,10.99 288.92,10.99 288.15,11.75 284.75,11.75 283.77,12.73 279.5,12.73 277.24,15 277.24,15.71 273.29,19.66 269.99,19.66 268.76,18.44 255.99,18.44 250.81,23.62 249.97,23.62 247.56,26.02 232.12,26.02 231.54,25.44 227.39,25.44 226.35,26.47 216.62,26.47 212.83,30.27 212.25,30.27 211.39,31.13 209.4,31.13 203.91,36.63 203,36.63 201.44,38.18 200.21,38.18 199.47,37.45 198.18,37.45 196.34,39.28 196.34,39.93 195.24,41.03 194.19,41.03 193.94,40.78 193.94,40.64 194.06,40.53 v2(194.2,40.53)
  BOTTOM w0.102: L1.4 313.2,10.17 313.2,10.56 313.1,10.66 312.88,10.66 312.83,10.71 312.83,10.83 313.13,11.13 v4(313.54,11.13) 313.82,11.13 314.42,10.53 314.42,9.16 314.33,9.07 314.08,9.07 313.97,8.96 313.97,8.82 v2(314.08,8.7)
USB20_P14_R: length 8.7
  BOTTOM w0.102: JNGFF1.3 317.4,9.06 317.49,8.98 317.61,8.98 317.71,8.88 317.71,8.05 317.54,7.88 316.41,7.88 316.37,7.92 315.79,7.92 315.75,7.88 v4(313.74,7.88) 312.92,7.88 312.82,7.98 312.82,8.18 312.92,8.28 313.2,8.28 313.28,8.36 313.28,8.53 313.13,8.69 L1.3 313.3,9.02 RI50.2
USB20_PA: length 10.6
  IN4 w0.102: v2(22.39,32.8) 22.39,31.98 22.67,31.7 26.01,31.7 28.06,33.74 v2(28.06,35.04)
  BOTTOM w0.102: v2(22.39,32.8) 22.62,33.03 22.62,33.18 22.51,33.29 22.1,33.29 RT561.2 ; UT1.E20 v2(28.06,35.04)
USB20_PB: length 11.9
  IN2 w0.094: v2(19.27,35.97) 19.28,35.98 20.23,35.98 22.07,37.81 23.72,37.81 24.14,37.39 25.91,37.39 26.17,37.13 27.47,37.13 27.99,36.61 27.99,35.74 v2(28.05,35.68)
  BOTTOM w0.102: UT1.E19 v2(28.05,35.68) ; RT557.1 v2(19.27,35.97)
USB_ILIM1: length 46.7
  TOP w0.109: v2(70.54,25.99) 70.89,25.99 71.47,25.4 72.25,25.4 72.87,24.78 72.87,24.22 73.68,23.41 73.68,22.81 73.73,22.76 RT587.1 73.04,22.29 73.04,22.6 v1(72.51,23.13) RT588.1
  IN4 w0.102: v2(43.61,27.2) 43.61,27.14 43.95,26.8 45.38,26.8 46.61,25.57 47.78,25.57 48.04,25.83 49.52,25.83 50.89,24.46 52.06,24.46 53.94,22.58 54.45,22.58 55.03,23.16 58.82,23.16 60.37,24.7 61.97,24.7 62.49,24.18 63.6,24.18 64.16,24.74 69.54,24.74 70.54,25.74 v2(70.54,25.99)
  BOTTOM w0.109: v2(43.61,27.2) 43.61,27.54 43.44,27.72 43.44,28.67 43.26,28.84 42.17,28.84 41.97,29.04 41.97,30.5 42.42,30.95 UT9.11
USB_ILIM2: length 22.4
  IN4 w0.102: v2(59.01,19.42) 60.08,20.49 63.66,20.49 64.94,21.77 64.94,22.25 65.55,22.87 v2(67.25,22.87)
  BOTTOM w0.109: v2(67.25,22.87) 67.03,22.65 67.03,21.53 v1(67.75,20.82) 69.33,20.82 RT586.1 71.09,21.33 RT585.1 ; UT11.11 56.3,24.12 56.12,23.94 56.12,23.14 58.49,20.78 58.49,19.89 58.95,19.42 v2(59.01,19.42)
USB_OC0#: length 16.6
  TOP w0.089: v2(182.35,25.67) 182.78,25.67 UH1.AH36
  TOP w0.109: v2(189.67,19.13) 189.73,19.13 190.91,17.95 RH720.1
  IN2 w0.081: v2(182.35,25.67) 182.35,25.59 187.19,20.75 187.78,20.75 188.45,20.08 188.72,20.08 v2(189.67,19.13)
  BOTTOM w0.102: v2(189.67,19.13) 189.67,18.81 189.83,18.66
  BOTTOM w0.109: 189.83,18.66 190.12,18.66 190.91,17.87 RH720.1
USB_OC1#: length 257.8
  TOP w0.089: v2(181.2,23.99) 181.2,24.12 181.3,24.22 UH1.AL40
  TOP w0.109: UI1.13 347.98,50.51 347.26,49.79 v1(347.26,48.48) 347.26,45.32 348.91,43.67 354.03,43.67 356.17,41.52 v2(356.17,40.36) ; v2(190.26,19.13) 190.26,18.92 191.8,17.38 RH719.1
  IN1 w0.102: v2(190.26,19.13) 190.26,18.8 192.54,16.51 200.69,16.51 201.48,15.73 218.71,15.73 218.99,16.01 230.96,16.01 231.46,15.5 241,15.5 241.96,16.46 253.59,16.46 256.58,13.46 256.58,10.85 255.9,10.17 255.9,8.17 256.49,7.58 257.51,7.58 261.83,3.26 274.06,3.26 274.6,2.72 276.93,2.72 278.5,4.28 282.76,4.28 283.57,3.47 285.45,3.47 286.48,2.44 290.99,2.44 292.29,3.74 293.57,3.74 295.86,1.46 328.26,1.46 329.33,2.53 329.33,4.8 330.52,5.99 333.49,5.99 334.62,4.86 337.34,4.86 338.57,6.08 v2(339.17,6.08)
  IN2 w0.081: v2(190.26,19.13) 190.26,19.23 189.45,20.04 189,20.04 188.56,20.49 188.28,20.49 187.85,20.92 187.26,20.92 183.03,25.14 183.03,26.65 182.84,26.84 182.08,26.84 181.83,26.59 181.83,24.71 181.2,24.08 v2(181.2,23.99)
  IN3 w0.081: v2(339.17,6.08) 339.54,6.45 339.54,8.72 341.8,10.98 341.8,19.55 342.24,19.99 342.24,29.71 343.54,31.01 344.13,31.01 345.45,32.32 349.02,32.32 350.65,30.69 353.79,30.69 357.13,34.03 357.13,39.4 v2(356.17,40.36)
  BOTTOM w0.109: RH719.1 191.8,17.39 190.26,18.93 v2(190.26,19.13)
USB_OC2#: length 249.4
  TOP w0.089: v2(181.76,22.22) 181.98,22 UH1.AJ44
  TOP w0.109: v2(355.72,40.89) 355.72,41.65 353.95,43.41 348.29,43.41 v1(347.84,42.96) 347.64,42.77 347.64,40.52 348.08,40.09 UI2.13 ; v2(188.56,18.91) 188.68,18.91 189.46,18.14 189.46,17.64 189.13,17.31 RH721.1
  IN1 w0.102: v2(339.79,6.06) 339.39,5.66 338.52,5.66 337.49,4.63 334.53,4.63 333.4,5.76 330.61,5.76 329.56,4.71 329.56,2.43 328.35,1.22 295.76,1.22 293.48,3.51 292.42,3.51 291.13,2.21 286.38,2.21 285.35,3.24 283.39,3.24 282.58,4.05 281.17,4.05 279.61,2.49 274.5,2.49 273.96,3.03 261.73,3.03 257.42,7.35 256.37,7.35 255.67,8.05 255.67,10.26 256.35,10.95 256.35,13.37 254.5,15.22 244.52,15.22 243.51,16.23 242.05,16.23 241.1,15.28 231.37,15.28 230.86,15.78 219.09,15.78 217.9,14.59 211.51,14.59 210.82,15.28 201.6,15.28 200.75,16.13 192.6,16.13 190.09,18.65 188.83,18.65 v2(188.56,18.91)
  IN2 w0.081: v2(188.56,18.91) 187.29,20.18 186.3,20.18 183.84,22.65 182.59,22.65 182.16,22.22 v2(181.76,22.22)
  IN3 w0.081: v2(355.72,40.89) 356.32,40.89 357.37,39.84 357.37,33.81 354.02,30.46 350.11,30.46 348.58,31.99 345.45,31.99 344.24,30.78 343.63,30.78 342.47,29.62 342.47,19.9 342,19.43 342,10.86 339.79,8.65 v2(339.79,6.06)
  BOTTOM w0.109: v2(188.56,18.91) 189.47,18.01 189.47,17.59 189.13,17.25 RH721.1
USB_OC3#: length 17.2
  TOP w0.089: UH1.AL41 v2(180.91,23.49)
  TOP w0.109: v2(189.09,19.16) 189.09,19.01 189.51,18.58 189.78,18.58 190.45,17.91 v1(190.45,17.76) 190.45,17.25 RH718.1
  IN2 w0.081: v2(180.91,23.49) 181.32,23.49 181.58,23.75 182.98,23.75 186.15,20.58 187.67,20.58 v2(189.09,19.16)
  BOTTOM w0.109: v2(189.09,19.16) 189.09,18.93 189.66,18.36 190.08,18.36 190.36,18.08 190.36,17.47 190.02,17.12 RH718.1
USB_OC4#: length 181.9
  TOP w0.109: RH714.1 156.44,20.55 v2(156.59,20.71) ; v2(45.37,28.74) 45.37,29.4 v1(45.25,29.52) ; UH1.AV47 178.19,19.25 178.28,19.17 v2(178.28,18.53)
  IN1 w0.102: v2(99.3,34.76) 99.3,35.94 v2(101.12,37.76)
  IN2 w0.081: v2(156.59,20.71) 157.19,21.3 157.92,21.3 159.02,20.2 160.03,20.2 160.41,19.82 160.52,19.82 160.98,19.36 163.75,19.36 165.78,17.32 165.78,16.67 166.33,16.11 169.43,16.11 171.18,17.87 177.59,17.87 178.25,18.53 v2(178.28,18.53)
  IN3 w0.081: v2(45.37,28.74) 46.14,27.97 46.14,25.53 47.12,24.55 47.64,24.55 48.97,23.22 50.25,23.22 50.77,23.74 55.74,23.74 56.16,23.32 59.65,23.32 60.82,24.5 70.56,24.5 71.75,25.68 79.28,25.68 81.26,23.7 83.68,23.7 84.67,24.69 86.98,24.69 87.69,25.4 87.69,26.12 88.1,26.54 88.1,27.17 87.64,27.64 87.64,29.6 88.36,30.32 94.87,30.32 97.21,32.66 98.41,32.66 99.67,33.91 99.67,34.39 v2(99.3,34.76) ; v2(101.12,37.76) 101.32,37.96 101.32,38.9 101.41,38.99 104.11,38.99 105.06,39.95 106.57,39.95 107.12,40.5 117.17,40.5 117.35,40.68 124.65,40.68 126.16,42.19 139.37,42.19 141.02,40.54 148.67,40.54 149.07,40.14 149.07,38.61 149.85,37.84 153.68,37.84 155.51,36.01 155.51,33.69 158.45,30.75 158.45,25.22 157.29,24.06 157.29,21.4 v2(156.59,20.71)
  BOTTOM w0.109: v2(178.28,18.53) 178.28,18.29 177.95,17.96 CT383.2 ; UT9.8 44.63,29.08 44.98,28.74 v2(45.37,28.74)
USB_OC5#: length 170.2
  TOP w0.109: RH715.1 155.98,21.44 v1(156.17,21.25) 156.31,21.12 156.84,21.12 v2(157.24,20.72) ; v2(179.08,25.92) 179.51,26.35 UH1.AR35
  IN1 w0.102: v2(100.03,32.67) 99.27,32.67 98.02,33.92 98.02,37.11 97.53,37.61 v2(97.53,38.4)
  IN2 w0.081: v2(157.68,23.89) 158.02,24.23 159.13,24.23 159.35,24.45 160.48,24.45 160.62,24.59 161.3,24.59 161.92,25.21 163.32,25.21 164.33,24.19 165.1,24.19 166.64,22.64 167.15,22.64 167.92,23.41 168.65,23.41 169.02,23.78 174.09,23.78 175.91,25.6 175.99,25.6 177.49,27.1 178.92,27.1 179.28,26.75 179.28,26.12 v2(179.08,25.92)
  IN3 w0.081: v2(100.03,32.67) 99.4,32.67 98.73,32 97.52,32 95.15,29.63 88.64,29.63 88.32,29.31 88.32,27.92 88.79,27.46 88.79,26.25 88.38,25.84 88.38,25.12 87.27,24.01 84.95,24.01 82.76,21.81 82.05,21.81 78.65,25.21 72.26,25.21 70.88,23.84 62.54,23.84 60.73,22.02 v2(60.09,22.02) ; v2(97.53,38.4) 97.75,38.4 98.33,38.97 101.09,38.97 101.33,39.2 103.99,39.2 104.94,40.15 106.48,40.15 107.05,40.72 117.07,40.72 117.26,40.91 124.55,40.91 126.07,42.42 137.51,42.42 137.53,42.4 139.46,42.4 141.11,40.75 148.89,40.75 149.42,40.23 149.42,38.63 150,38.05 153.77,38.05 155.76,36.06 155.76,33.74 158.66,30.83 158.66,24.87 v2(157.68,23.89) 157.68,21.17 v2(157.24,20.72)
  BOTTOM w0.109: v2(179.08,25.92) 179.56,25.44 CT384.2 ; UT11.8 58.11,22.32 58.38,22.05 59.15,22.05 59.17,22.02 v2(60.09,22.02)
USB_OC6#: length 30
  TOP w0.109: v2(178.63,25.48) 178.97,25.48 179.03,25.42 179.21,25.42 UH1.AR37 ; RH716.1 155.67,22.78 155.67,23.4 155.88,23.61 v2(155.88,24.04) 155.15,24.77 v1(155.15,24.82)
  IN2 w0.081: v2(178.63,25.48) 178.57,25.42 177.95,25.42 177.94,25.41 176.93,25.41 175.58,24.07 174.7,24.07 174.18,23.55 169.11,23.55 168.75,23.18 168.02,23.18 167.25,22.41 166.55,22.41 165,23.96 164.24,23.96 163.22,24.98 162.01,24.98 161.39,24.36 160.72,24.36 160.58,24.22 159.44,24.22 159.22,24 158.53,24 158.02,23.5 157.38,23.5 156.84,24.04 v2(155.88,24.04)
USB_OC7#: length 29.5
  TOP w0.089: UH1.AV43 177.78,22.8 v2(177.68,22.7)
  TOP w0.109: RH717.1 155.22,23.93 v2(155.28,23.99) 154.9,24.36 153.9,24.36 v1(153.85,24.31)
  IN2 w0.081: v2(155.28,23.99) 155.28,23.73 155.59,23.41 156.31,23.41 156.88,22.84 158.2,22.84 158.78,23.41 159.31,23.41 159.9,22.82 160.89,22.82 160.97,22.91 161.43,22.91 162.11,23.59 163.17,23.59 164.48,22.28 165.18,22.28 165.55,21.92 167.11,21.92 167.73,21.31 168.28,21.31 168.95,21.98 168.95,22.31 169.1,22.46 169.1,22.89 169.56,23.34 175.48,23.34 176.37,22.46 176.86,22.46 177.1,22.7 v2(177.68,22.7)
USB_POWERSHARE_EN#: length 302.5
  TOP w0.102: UE1.J3 v2(131.13,22.45)
  TOP w0.109: v2(356.07,35.67) 355.91,35.67 355.11,34.87 354.32,34.87 353.04,36.16 353.04,36.85 352.43,37.46 352.43,38.71 352.05,39.09 UI2.6 ; UI1.6 352.17,49.51 352.82,48.86 352.82,46.16 v1(353.84,45.14) v2(355.51,43.46)
  IN1 w0.102: v2(320.41,39.08) 319.7,39.08 316.99,41.79 315.77,41.79 315.1,42.47 311.46,42.47 310.66,43.27 310.66,43.67 308.57,45.76 304.64,45.76 304.45,45.95 300.82,45.95 299.99,45.13 297.02,45.13 295.18,46.96 292.62,46.96 289.54,43.89 283.13,43.89 274.95,35.71 274.95,34.44 273.52,33 273.52,27.58 270.31,24.37 264.7,24.37 261.58,27.48 255.96,27.48 254.96,28.48 254.32,28.48 v2(254.26,28.54)
  IN3 w0.081: v2(356.07,35.67) 356.07,37.78 354.97,38.88 354.97,42.92 v2(355.51,43.46) ; v2(254.26,28.54) 254.26,24.35 247.96,18.04 232.49,18.04 227.98,13.54 212.28,13.54 206.28,7.54 v2(206.28,6.77)
  IN4 w0.102: v2(131.13,22.45) 131.13,22.34 130.73,21.93 130.73,21.43 130.49,21.2 130.49,20.41 131.65,19.26 131.93,19.26 132.53,18.66 132.53,18.42 134.05,16.9 138.01,16.9 138.89,17.78 140.34,17.78 141.02,17.1 143.55,17.1 145.97,19.52 145.97,20.02 148.85,22.91 151.08,22.91 151.96,22.03 153.09,22.03 153.27,21.85 153.78,21.85 156.39,19.24 157.99,19.24 158.29,19.54 158.29,19.78 158.49,19.98 159.02,19.98 160.17,18.83 160.67,18.83 161.64,17.86 162.87,17.86 163.37,17.35 164.86,17.35 166.65,15.57 169.69,15.57 169.92,15.8 171.37,15.8 171.38,15.81 171.79,15.81 172.26,15.34 172.61,15.34 174.43,13.52 176.51,13.52 178.78,11.24 179.31,11.24 179.99,10.56 180.21,10.56 181.43,9.34 183.57,9.34 184.03,9.8 196.06,9.8 196.38,9.48 200,9.48 201.81,7.67 203.71,7.67 204.61,6.77 v2(206.28,6.77)
  BOTTOM w0.109: v2(320.41,39.08) 320.74,39.41 327.59,39.41 331.1,42.91 341.01,42.91 341.56,43.46 344.01,43.46 344.87,42.6 347.49,42.6 348.35,43.46 v2(355.51,43.46) ; RE701.1 128.8,20.48 128.8,21.52 128.98,21.7 129.68,21.7 130.07,22.09 130.47,22.09 130.83,22.45 v2(131.13,22.45)
USB_POWERSHARE_VBUS_EN: length 376.9
  TOP w0.109: UE1.J2 130.27,22.38 129.64,22.38 v2(128.36,21.11) ; v2(355.47,42.83) v1(354.75,43.55) 352.54,45.76 352.54,48.63 352.16,49.01 UI1.5 ; v2(356.33,35.08) 355.66,35.08 355.21,34.63 354.23,34.63 352.8,36.06 352.8,36.75 352.16,37.39 352.16,38.46 352.03,38.59 UI2.5
  IN1 w0.102: v2(320.76,38.57) 319.89,38.57 316.9,41.56 313.46,41.56 312.78,42.24 311.36,42.24 310.43,43.17 310.43,43.58 308.49,45.52 304.56,45.52 304.35,45.72 300.91,45.72 300.09,44.9 296.68,44.9 294.94,46.64 292.77,46.64 289.59,43.46 283.06,43.46 276.72,37.12 276.72,35.69 273.81,32.78 273.81,27.42 270.16,23.76 264.26,23.76 261.02,27.01 255.12,27.01 v2(254.86,27.27)
  IN3 w0.081: v2(356.33,35.08) 356.53,35.28 356.53,37.7 355.23,38.99 355.23,42.6 v2(355.47,42.83) ; v2(83.99,27.73) 83.99,26.59 83.62,26.22 71.7,26.22 70.83,25.35 v2(69.57,25.35) ; v2(254.86,27.27) 254.86,24.62 247.71,17.48 232.24,17.48 228.08,13.31 212.4,13.31 206.85,7.76 206.85,6.75 206.29,6.19 v2(206.27,6.19)
  IN4 w0.102: v2(206.27,6.19) 204.87,6.19 203.62,7.45 201.71,7.45 199.9,9.25 196.28,9.25 195.97,9.57 184.12,9.57 183.66,9.11 181.34,9.11 180.11,10.33 179.89,10.33 179.21,11.02 178.68,11.02 176.41,13.29 174.34,13.29 172.63,15 170.97,15 170.71,15.25 166.64,15.25 164.77,17.12 163.28,17.12 162.77,17.63 161.55,17.63 160.64,18.53 158.36,18.53 157.89,19.01 156.3,19.01 153.68,21.62 153.17,21.62 152.99,21.8 151.86,21.8 150.99,22.68 148.95,22.68 146.2,19.93 146.2,19.43 143.65,16.88 140.92,16.88 140.25,17.55 138.98,17.55 138.1,16.67 133.95,16.67 132.3,18.33 132.3,18.62 131.85,19.07 131.57,19.07 130.5,20.14 129.53,20.14 128.56,21.11 v2(128.36,21.11)
  BOTTOM w0.109: v2(83.99,27.73) 84.44,27.28 85.65,27.28 86.16,26.78 86.16,25.42 87.82,23.76 87.92,23.76 89.23,22.44 89.23,21.29 90.09,20.43 90.09,15.11 91.19,14.01 104.36,14.01 105.62,15.27 108.46,15.27 110.22,17.03 110.22,17.93 112.03,19.74 118.13,19.74 119.33,20.95 122.09,20.95 122.71,21.57 124.58,21.57 124.95,21.95 126.91,21.95 RE700.1 127.75,21.11 v2(128.36,21.11) ; v2(320.76,38.57) 320.76,38.64 321.13,39.01 327.96,39.01 331.63,42.68 341.11,42.68 341.66,43.22 343.84,43.22 344.7,42.36 347.59,42.36 348.44,43.21 355.09,43.21 v2(355.47,42.83) ; v2(69.57,25.35) 69.57,25.01 RE702.1 69.03,24.49 68.44,23.9 68.37,23.9 67.99,23.52 67.92,23.52 QT5.2
USB_POWERSHARE_VBUS_EN#: length 35.3
  TOP w0.109: v1(63.13,22.57) 63.13,22.6 63.47,22.94 v2(63.7,22.94)
  IN4 w0.102: v2(43.93,24.25) 44.33,24.66 45.35,24.66 45.51,24.5 48.01,24.5 48.41,24.91 49.14,24.91 50.5,23.55 51.61,23.55 52.16,23 52.16,20.96 52.54,20.58 54.03,20.58 55.64,22.19 59.15,22.19 60.75,23.79 61.59,23.79 62.11,23.26 63.38,23.26 v2(63.7,22.94)
  BOTTOM w0.109: RT564.2 66.69,22.57 66.38,22.88 QT5.1 65.62,22.88 65.27,23.23 RT610.2 65.04,23.24 64.01,23.24 v2(63.7,22.94) 63.35,22.94 63.22,23.07 UT12.1 ; v2(43.93,24.25) 44.82,25.14 44.82,26.33 45.14,26.65 UT10.1
USH_DET#: length 67
  TOP w0.109: v2(180.32,12.1) 179.07,12.1 176.2,9.23 176.2,8.63 175.6,8.04 175.6,5.14 176.1,4.64 JUSH1.1 ; UE1.C13 140.09,27.65 v2(140.43,27.31)
  IN4 w0.102: v2(140.43,27.31) 140.48,27.35 141.78,27.35 142.49,26.64 143.17,26.64 143.38,26.43 143.87,26.43 144.16,26.71 144.16,27.06 144.79,27.69 150.29,27.69 151.73,29.13 157.94,29.13 159.4,27.67 159.4,26.87 159.63,26.64 160.14,26.64 160.3,26.8 161.47,26.8 161.94,26.32 162.19,26.32 164.08,24.44 164.08,22.58 164.46,22.19 164.82,22.19 166.37,20.64 166.37,19.93 167.22,19.08 167.22,19.08 167.46,18.84 168,18.84 169.52,17.33 170.38,17.33 170.65,17.6 171.62,17.6 172.74,16.48 173.33,16.48 173.71,16.11 173.96,16.11 174.1,15.97 176.3,15.97 177.61,14.66 177.61,14.03 179.24,12.4 180.02,12.4 v2(180.32,12.1)
  BOTTOM w0.102: v2(140.43,27.31) 140.43,26.64 v1(140.51,26.57) 140.65,26.43 RE526.2
USH_EXPANDER_SMBCLK: length 235.1
  TOP w0.102: UE1.B3 v2(131.93,28.05)
  TOP w0.109: JUSH1.16 183.6,3.42 185.2,5.02 186.03,5.02 187.24,6.23 187.24,7.01 186.94,7.32 177.77,7.32 177.77,7.32 v2(177.64,7.32)
  IN3 w0.081: v2(131.93,28.05) 130.73,28.05 129.16,26.48 127.97,26.48 126.82,25.34 125.27,25.34 124.78,24.85 124.78,24.26 123.92,23.4 122.27,23.4 121.9,23.03 116.22,23.03 113.65,20.46 112.03,20.46 111.35,19.78 101.88,19.78 101.18,19.08 93.76,19.08 93.36,19.47 90.97,19.47 89.4,21.05 84.77,21.05 83.92,20.2 80.57,20.2 80.39,20.38 79.34,20.38 78.76,20.96 78.76,22.26 78.01,23.01 77.46,23.01 76.23,24.24 73.3,24.24 70.82,21.76 64.38,21.76 64.11,21.49 63.3,21.49 62.22,20.41 57.94,20.41 56.16,18.63 54.42,18.63 54.08,18.29 54.08,11.07 51.7,8.69 51.7,5.96 51.13,5.39 44.64,5.39 43.44,6.59 42.14,6.59 39.98,8.75 36.77,8.75 35.45,7.43 30.08,7.43 28.83,6.19 25.7,6.19 22.35,2.85 18.16,2.85 15.58,5.43 9.88,5.43 8.24,7.06 8.24,9.83 v2(8.66,10.24)
  IN4 w0.102: v2(177.64,7.32) 177.53,7.32 175.65,9.2 174.55,9.2 174.09,9.65 167.24,9.65 166.05,10.84 162.3,10.84 160.36,12.78 160.36,12.85 158.15,15.07 156.54,15.07 155.78,15.83 154.41,15.83 152.55,17.69 147.58,17.69 144.64,14.75 142.03,14.75 v2(141.63,14.34)
  BOTTOM w0.102: 135.49,18.72 135.49,20.1 135.08,20.5 135.08,20.9 134.72,21.26 134.72,21.84 134.52,22.03 134.11,22.03 133.92,22.22 133.92,25.8 133.65,26.07 133.37,26.07 133.15,26.29 133.15,26.57 132.85,26.87 132.57,26.87 132.34,27.1 132.34,27.64 v2(131.93,28.05)
  BOTTOM w0.109: UE12.12 8.85,10.44 v2(8.66,10.24) ; v2(141.63,14.34) 140.46,14.34 v1(140.42,14.31) 139.79,14.31 RZ8.2 CZ62.1 137.39,13.87 136.6,14.66 136.6,16.76 135.71,17.66 135.71,17.71 135.71,17.71 135.71,18 135.71,18.5 135.49,18.72
USH_EXPANDER_SMBDAT: length 245
  TOP w0.102: UE1.E5 v2(132.73,26.45)
  TOP w0.109: JUSH1.15 183.1,3.25 185.1,5.25 185.93,5.25 187.01,6.33 187.01,6.92 186.84,7.08 179.38,7.08 179.15,6.86 v2(178.1,6.86)
  IN3 w0.081: v2(132.73,26.45) 133.12,26.84 133.12,28.32 132.99,28.45 131.54,28.45 131.44,28.36 130.71,28.36 129.13,26.77 127.85,26.77 126.65,25.57 125.14,25.57 124.53,24.96 124.53,24.4 123.77,23.63 122.17,23.63 121.8,23.26 120.92,23.26 119.88,24.3 115.3,24.3 114.59,23.59 113.72,23.59 113.17,23.03 112.21,23.03 111.68,22.5 108.45,22.5 105.96,20.01 101.79,20.01 101.09,19.3 93.85,19.3 93.46,19.7 91.07,19.7 89.49,21.27 84.67,21.27 83.83,20.43 82.1,20.43 81.85,20.68 81.85,21.12 79.73,23.24 77.56,23.24 76.3,24.5 73.16,24.5 70.89,22.22 67.06,22.22 66.59,22.69 65.32,22.69 65.02,22.39 63.5,22.39 63.18,22.08 63.18,21.83 62.01,20.65 57.86,20.65 57.32,20.12 55.09,20.12 53.85,18.88 53.85,11.16 51.47,8.79 51.47,6.06 51.03,5.62 44.73,5.62 43.53,6.82 42.24,6.82 40.07,8.98 36.68,8.98 35.36,7.67 29.99,7.67 28.74,6.42 25.6,6.42 22.31,3.13 19.15,3.13 17.44,4.83 16.47,4.83 15.65,5.66 9.97,5.66 8.49,7.14 8.49,9.44 v2(8.66,9.62)
  IN4 w0.102: v2(178.1,6.86) 177.3,6.86 175.81,8.35 175.07,8.35 174,9.43 167.07,9.43 165.98,10.52 162.3,10.52 159.93,12.89 159.93,12.92 158,14.84 156.44,14.84 155.68,15.6 154.32,15.6 152.45,17.46 147.68,17.46 144.11,13.9 142.66,13.9 142.23,14.32 v2(142.23,14.34)
  BOTTOM w0.102: CZ63.1 136.57,14.2 136.33,14.44 136.33,16.7 135.47,17.56 135.47,17.8 135.48,17.81 135.48,18 135.22,18.26 135.22,19.98 134.8,20.4 134.8,20.91 134.46,21.25 133.28,21.25 133.11,21.42 133.11,25.84 132.73,26.22 v2(132.73,26.45)
  BOTTOM w0.109: v2(8.66,9.62) 8.21,10.06 8.21,10.41 8.4,10.6 UE12.13 ; v2(142.23,14.34) 142.41,14.16 142.41,12.81 142.21,12.61 140.35,12.61 140.35,12.61 140.15,12.61 139.92,12.38 139.01,12.38 138.1,11.47 135.62,11.47 135.08,12.01 135.08,13.36 RZ9.2 136.56,13.86 CZ63.1
USH_PWR_STATE#: length 79
  TOP w0.109: JUSH1.5 178.1,3.07 178.03,3.14 178.03,4.57 176.96,5.64 176.75,5.85 176.75,8.09 178.43,9.77 v2(178.43,10.18) ; UE1.H2 130.33,23.25 129.46,23.25 v2(129.35,23.36) 128.95,22.95 127.6,22.95 RZ10.2
  IN4 w0.102: v2(129.35,23.36) 128.92,22.93 128.19,22.93 127.7,22.43 127.7,20.75 128.49,19.95 128.49,19.13 128.96,18.66 129.89,18.66 130.96,17.59 131.05,17.59 132.41,16.22 138.69,16.22 138.87,16.39 139.77,16.39 140.11,16.05 142.57,16.05 143.18,15.44 144.35,15.44 147.54,18.62 147.54,20.3 148.88,21.64 150.62,21.64 150.91,21.34 152.8,21.34 153.03,21.12 153.54,21.12 156.11,18.55 157.69,18.55 158.16,18.08 160.45,18.08 161.36,17.17 162.58,17.17 163.09,16.67 163.75,16.67 164.34,16.08 165.16,16.08 166.45,14.79 170.52,14.79 170.78,14.54 172.44,14.54 174.15,12.83 175.78,12.83 v2(178.43,10.18)
  BOTTOM w0.109: v1(129.62,23.93) 129.35,23.66 v2(129.35,23.36)
USH_RST#_R: length 18.2
  TOP w0.109: v2(181.74,12.09) 181.74,11.88 180.28,10.42 180.28,9.93 179.66,9.31 178.3,9.31 176.99,8.01 176.99,5.98 178.36,4.61 178.36,3.18 178.6,2.94 JUSH1.6
  BOTTOM w0.109: CZ61.1 183.22,16.29 RZ114.2 182.76,15.02 182.76,13.87 v1(182.25,13.35) 181.74,12.84 v2(181.74,12.09)
VCI_IN1#: length 5.2
  TOP w0.102: RE507.1 133.38,31.04 132.7,30.37 132.7,28.88 UE1.B5
  TOP w0.109: v1(134.48,32.48) 134.11,32.48 133.38,31.75 RE507.1
VCI_IN2#: length 3.4
  TOP w0.102: UE1.D4 v2(131.93,27.25)
  BOTTOM w0.102: v2(131.93,27.25) 131.55,26.87 130.95,26.87 130.54,27.28 v1(130.52,27.28) RE508.1
VCI_IN3#: length 6.4
  TOP w0.102: UE1.E4 v2(131.93,26.45)
  BOTTOM w0.102: 127.82,27.11 128.39,26.54 130.5,26.54 130.98,26.07 131.55,26.07 v2(131.93,26.45)
  BOTTOM w0.109: RE750.1 127.5,27.43 127.82,27.11
VCT_LAN_R1: length 18.9
  IN3 w0.081: v2(185.4,126.86) 185.4,125.79 184.51,124.9 180.88,124.9 180.41,124.43 v2(180.41,118.28)
  BOTTOM w0.109: v2(180.41,118.28) 180.41,119.28 v1(181.03,119.91) 181.48,120.36 RL50.2 RL3.1 ; UL1.6 185.88,127.34 v2(185.4,126.86)
VGA_IDENTIFY: length 159.9
  TOP w0.102: UE1.L9 v2(135.93,20.85)
  TOP w0.109: JDGFF4.F1 177.07,128.66 177.13,128.61 v2(177.13,128.15) ; JDGFF2.F1 177.07,97.51 177.2,97.38 178.01,97.38 v2(178.14,97.51) ; v2(186.23,77.98) 185.61,77.98 184.67,77.04 184.67,73.36 166.25,54.95 v1(166.25,53.53) 166.14,53.42 166.14,51.56 165.64,51.06 v2(165.64,50.14)
  IN3 w0.081: v2(177.13,128.15) 177.2,128.15 178.78,126.57 178.78,123.21 179.71,122.28 179.71,117.39 181.09,116.01 181.09,109.72 180.15,108.78 180.15,102.13 177.86,99.83 177.86,98.97 178.14,98.69 v2(178.14,97.51)
  IN4 w0.102: v2(186.23,77.98) 186.23,79.72 184.21,81.74 184.21,82.37 183.47,83.11 182.92,83.11 182.21,83.83 182.21,88.68 182.68,89.15 182.68,89.93 181.1,91.5 181.1,96.55 179.73,97.92 178.55,97.92 v2(178.14,97.51)
  BOTTOM w0.109: v2(165.64,50.14) 165.64,49.3 164.72,48.39 163.57,48.39 159,43.83 159,40.58 150.64,32.22 150.64,22.49 151.17,21.96 151.17,20.63 150.59,20.05 145.69,20.05 143.91,18.26 143.91,15.52 143.63,15.25 142.78,15.25 142.52,14.99 139.59,14.99 139.21,14.61 138.39,14.61 137.5,15.5 RE84.1 136.98,16.63 136.98,17.4 136.77,17.62 136.77,18.17 136.45,18.48 136.08,18.48 135.75,18.81 135.75,20.67 v2(135.93,20.85)
VID0_VCCIO_VR: length 3.4
  TOP w0.109: v1(270.18,97.95) 270.52,98.29 v2(270.58,98.29)
  TOP w0.254: v2(270.58,98.29) 271.13,98.29 PR313.2
  BOTTOM w0.254: PR314.1 270.26,98.29 v2(270.58,98.29) 270.77,98.49 PU300.4
VID1_VCCIO_VR: length 3.9
  TOP w0.254: PR311.1 PR312.2 272.1,97.92 271.78,97.6 v1(271.54,97.6) v2(270.61,97.6)
  BOTTOM w0.254: PU300.3 271,97.99 v2(270.61,97.6)
VOUT_IO: length 10.5
  IN1 w0.254: v2(269.55,101.2) 269.79,101.2 271.45,99.53 273.97,99.53 v2(275.29,98.21)
  BOTTOM w0.109: v2(269.55,101.2) 269.99,101.64 v1(269.99,101.66)
  BOTTOM w0.254: PR306.1 268.42,101.75 PR303.2 269.31,101.44 v2(269.55,101.2) ; PU300.12 275.01,98.49 v2(275.29,98.21)
VR_SVID_ALERT#: length 53.5
  TOP w0.109: v2(266.73,151.75) 266.73,151.45 PR1115.2
  IN4 w0.102: v2(266.73,151.75) 267.21,152.24 268.91,152.24 269.16,151.99 269.16,144.86 275.03,138.99 275.03,121.42 273.12,119.5 267.77,119.5 267.21,118.94 263.69,118.94 262.73,119.9 v2(262.52,119.9)
  BOTTOM w0.109: PR1199.2 v2(266.73,151.75) ; RC152.2 261.6,119.8 261.6,119.83 RC153.1 262.35,120.07 v2(262.52,119.9)
VR_SVID_CLK: length 71.9
  TOP w0.076: v2(254.6,110.64) 254.28,110.31 UC1.BH32
  TOP w0.109: PR1117.2 265.34,150.95 v2(266.13,151.75)
  IN4 w0.102: v2(266.13,151.75) 266.13,151.93 266.97,152.77 269.13,152.77 269.66,152.24 269.66,145.04 275.52,139.19 275.52,121.22 273.32,119.02 267.97,119.02 267.41,118.46 263.4,118.46 262.77,119.09 v2(259.27,119.09)
  BOTTOM w0.102: v2(254.6,110.64) 254.98,110.26 255.65,110.26 256.53,111.13 257,111.13 257.24,111.37 257.89,111.37 259.98,113.46 259.98,118.51 260.06,118.59 CC325.1
  BOTTOM w0.109: v1(266.13,152.35) v2(266.13,151.75) 265.84,151.46 PR1104.2 ; CC325.1 259.33,119.16 v2(259.27,119.09)
VR_SVID_DATA: length 71.4
  TOP w0.102: UC1.BH29 254.08,107.86 v2(254.18,107.76)
  TOP w0.109: v2(267.42,151.72) 267.42,151.23 PR1113.2
  IN4 w0.102: v2(267.42,151.72) 268.61,150.54 268.61,150.18 268.43,150 266.79,150 266.6,149.81 266.6,149.56 266.76,149.39 268.43,149.39 268.61,149.21 268.61,148.96 268.43,148.78 266.94,148.78 266.75,148.6 266.75,148.34 266.92,148.17 268.43,148.17 268.61,147.99 268.61,144.73 274.55,138.79 274.55,121.62 272.92,119.99 267.57,119.99 267.16,119.57 v2(265.06,119.57)
  BOTTOM w0.102: v2(254.18,107.76) 254.18,108.37 254.98,109.16 254.98,109.43 255.25,109.7 255.86,109.7 256.74,110.59 257,110.59 257.21,110.38 258.3,110.38 259.42,111.5 260.04,111.5 261.01,112.46 261.01,114.97 263.69,117.66 RC157.2
  BOTTOM w0.109: v2(265.06,119.57) 264.72,119.23 RC157.2 ; PR1105.1 267.62,151.53 v2(267.42,151.72)
VRALERT#: length 13.8
  TOP w0.102: RH203.1 163.16,26.33 v1(163.45,26.33) 164.92,26.33 165.17,26.57 165.17,26.98 165.41,27.22 166.17,27.22 166.27,27.32 167.04,27.32 167.4,27.69 168.41,27.69 168.96,28.24 171.43,28.24 171.45,28.26 171.46,28.26 171.55,28.36 173.98,28.36 174.09,28.24 174.54,28.24 UH1.BE32
VSET_5105: length 3.9
  TOP w0.254: UE1.C9 v2(136.73,28.05)
  BOTTOM w0.109: CE38.1 136.41,30.71 v1(135.87,30.71)
  BOTTOM w0.254: CE38.1 RE77.1 136.78,28.1 v2(136.73,28.05)
VSN_1PH: length 8.9
  TOP w0.109: v1(258.29,153.15) 257.98,153.15 PC1140.2
  TOP w0.203: PU1100.51 261.38,148.39 260.92,148.85 259.97,148.85 259.33,149.48 258.07,149.48 257.82,149.73 257.82,151.04 PR1107.2 PC1140.2
VSN_2PH: length 4.5
  TOP w0.203: PC1112.1 PR1127.1 267.87,148.69 267.45,148.27 v1(267.45,148.25) 267.45,147.06 266.92,146.53 PU1100.37
VSN_4PH: length 4.7
  TOP w0.203: v2(259.53,147.27) 259.87,146.93 PU1100.2
  BOTTOM w0.109: v2(259.53,147.27) v1(260.09,147.27)
  BOTTOM w0.203: v2(259.53,147.27) 259.64,147.38 259.64,148.81 259.48,148.97 PC1110.2 PR1123.2
VSP_1PH: length 5.6
  TOP w0.203: PR1109.2 PC1105.2 257.98,149.1 v1(258.74,149.1) 259.25,149.1 259.84,148.51 260.72,148.51 260.98,148.25 PU1100.52
VSP_2PH: length 6.5
  TOP w0.203: PU1100.38 266.74,146.93 267.02,147.21 267.02,148.42 267.85,149.24 269.32,149.24 269.65,149.57 PR1126.1 270.15,148.71 PC1111.1
VSP_4PH: length 6
  TOP w0.203: v2(260.3,147.88) 260.43,147.75 PU1100.1
  BOTTOM w0.203: v2(260.3,147.88) v1(260.3,148.86) 260.3,148.94 259.73,149.51 257.87,149.51 PC1109.2 256.43,148.97 PR1121.2
WIGIG_32KHZ: length 4.1
  BOTTOM w0.109: JNGFF1.42 329.15,20.07 RZ56.1 v1(327.7,20.25)
WLAN_COEX1: length 29.4
  TOP w0.109: v2(332.49,14.57) 332.49,12.11 332.97,11.62 332.97,9.65 329.94,6.62 329.94,3.09 328.63,1.77 v1(321.55,1.77) 320.8,1.77 RZ130.2
  BOTTOM w0.109: v2(332.49,14.57) 332.76,14.84 332.76,15.71 332.52,15.95 329.63,15.95 328.65,16.93 JNGFF1.40
WLAN_COEX2: length 26
  TOP w0.109: v2(331.3,14.56) 331.3,14.37 332.25,13.42 332.25,12 332.7,11.55 332.7,9.71 329.58,6.59 327.54,6.59 323.24,2.29 v1(322.81,2.29) 322.1,2.29 RZ129.2
  BOTTOM w0.109: v2(331.3,14.56) 330.41,14.56 328.15,16.82 JNGFF1.38
WLAN_COEX3: length 37.9
  TOP w0.109: RZ128.2 318.42,3.12 317.99,3.12 317.81,2.93 317.81,1.73 318.31,1.22 319.79,1.22 319.99,1.42 328.79,1.42 v1(328.9,1.53) 330.18,2.81 330.18,6.52 333.22,9.57 333.22,11.79 332.91,12.11 332.91,14.76 332.66,15 332.33,15 v2(331.89,14.56)
  BOTTOM w0.109: 331.87,14.55 331.87,14.16 331.83,14.12 331.44,14.12 ; 331.87,14.55 331.44,14.12 ; 331.87,14.55 v2(331.89,14.56) ; 331.44,14.12 330.22,14.12 327.65,16.68 JNGFF1.36
WLAN_PWR_EN: length 278.8
  TOP w0.109: UZ44.3 325.59,22.06 325.41,21.87 325.41,21.42 326.03,20.8 v2(326.95,20.8) R127.1 ; RZ71.2 136.11,38.62 v2(136.52,39.03) ; RZ70.2 136.15,39.41 v2(136.52,39.03) ; v2(192.04,62.89) 192.62,63.47 192.62,64.23 v1(193.55,65.16) 195.31,66.92 195.31,75.32 197.29,77.3 197.29,79.78 198.92,81.41 202.53,81.41 213.1,70.84 235.89,70.84 239.82,66.92 241.39,66.92 246.07,71.59 264.4,71.59 264.45,71.64 265.1,72.29 277.66,72.29 279.92,70.04 279.92,69.17 282.06,67.03 287.15,67.03 287.59,67.46 290.8,67.46 v2(290.98,67.28) ; DZ9.1 137.59,39.03 v2(136.52,39.03)
  IN2 w0.081: v2(318.92,40.63) 319.01,40.71 319.01,42.81 316.61,45.21 314.96,45.21 300.01,60.16 298.77,60.16 291.65,67.28 v2(290.98,67.28) ; v2(136.52,39.03) 137.5,39.03 139.91,41.44 141.36,41.44 141.51,41.58 153.85,41.58 154.89,42.62 155.59,42.62 156.51,43.54 158.16,43.54 160.62,46 161.59,46 164.04,48.44 164.04,49.37 167.54,52.87 167.54,54 174.32,60.78 176.23,60.78 181.05,65.59 191.94,65.59 192.85,64.68 192.85,63.7 v2(192.04,62.89)
  BOTTOM w0.109: v2(318.92,40.63) 318.46,40.17 318.46,38.05 322.4,34.11 323.37,34.11 324.21,34.95 332.48,34.95 332.83,34.6 332.83,32.49 329.72,29.38 329.72,25.65 328.37,24.3 328.37,21.11 328.06,20.8 v2(326.95,20.8)
WLAN_WIGIG60GHZ_DIS#: length 263
  TOP w0.102: v2(141.15,21.59) 140.81,21.25 UE1.L13
  TOP w0.109: v2(335.01,5.98) 335.01,6.28 335.83,7.1 335.83,9.42 334.56,10.7 334.56,12.03 333.66,12.93 333.66,15.01 333.09,15.57 333.09,15.79 332.48,16.4 331.48,16.4 331.09,16.79 331.09,18.99 331.97,19.87 331.97,21.3 v2(332.39,21.71) ; v2(141.15,21.59) 141.38,21.59 141.46,21.66 RE8.1 ; v2(141.33,8.77) 140.54,8.77 139.89,8.11 139.89,5.29 139.38,4.79 v1(139.38,3.53) 139.38,2.33 v2(139.13,2.07)
  IN2 w0.081: v2(335.01,5.98) 330.87,5.98 326.25,1.36 313.72,1.36 313.57,1.51 291.82,1.51 291.02,2.31 283.76,2.31 283.18,1.73 273.89,1.73 271.42,4.19 266.52,4.19 265.37,5.34 265.37,6.46 264.75,7.08 252.84,7.08 250.99,8.94 237.27,8.94 236.53,9.68 228.66,9.68 227.33,11.01 221.24,11.01 219.09,8.86 216.12,8.86 215.9,8.64 215.9,3.74 213.44,1.27 173.67,1.27 171.84,3.1 171.84,4 169.76,6.09 166.38,6.09 165.68,5.38 159.7,5.38 159.5,5.18 159.5,2.49 158.29,1.27 139.93,1.27 v2(139.13,2.07)
  IN3 w0.081: v2(141.15,21.59) 141.23,21.51 141.23,20.37 140.56,19.7 140.56,14.97 139.71,14.12 139.71,12.53 139.1,11.93 139.1,11.37 138.48,10.75 138.48,10.5 139.35,9.62 140.47,9.62 v2(141.33,8.77)
  BOTTOM w0.109: DZ1.1 332.17,22.25 332.39,22.04 v2(332.39,21.71)
WLAN_WIGIG60GHZ_DIS#_R: length 3.5
  BOTTOM w0.109: JNGFF1.48 330.65,18.27 331.69,19.31 v1(331.69,19.56) DZ1.2
WRST#: length 3.6
  BOTTOM w0.109: v1(5.03,12.58) 4.83,12.79 4.83,13.51 RE564.2 5.04,13.73 CE343.1 6.1,13.56 UE12.19
WWAN_COEX1: length 25.4
  TOP w0.109: v2(318.1,5.47) 318.38,5.19 319.39,5.19 319.84,4.74 RZ373.1 319.89,2.89 RZ130.1
  IN3 w0.081: v2(305.11,11.37) 306.2,10.28 307.28,10.28 307.5,10.06 308.44,10.06 309.72,8.78 312.62,8.78 313.65,7.76 314.03,7.76 315.5,6.29 319.48,6.29 319.74,6.04 319.74,5.44 319.51,5.21 318.36,5.21 v2(318.1,5.47)
  BOTTOM w0.109: v2(305.11,11.37) 305.25,11.24 JNGFF2.56
WWAN_COEX2: length 21.3
  TOP w0.109: RZ129.1 320.26,4.7 v2(319.32,5.64) 319.32,6.47 RZ372.1
  IN3 w0.081: v2(319.32,5.64) 318.9,6.06 315.43,6.06 313.95,7.55 313.53,7.55 312.53,8.55 309.56,8.55 308.29,9.83 307.41,9.83 307.18,10.05 305.85,10.05 v2(304.53,11.37)
  BOTTOM w0.109: JNGFF2.54 304.75,11.15 v2(304.53,11.37)
WWAN_COEX3: length 21.5
  TOP w0.109: RZ128.1 319.24,3.48 RZ374.1 319.04,4.31 v1(318.39,4.31) 317.83,4.31 316.9,5.24 v2(316.9,5.47)
  IN3 w0.081: v2(303.95,11.37) 305.08,10.23 305.08,9.82 308.3,6.61 312.23,6.61 312.8,7.18 314.02,7.18 315.35,5.85 316.52,5.85 v2(316.9,5.47)
  BOTTOM w0.109: JNGFF2.52 304.25,11.07 v2(303.95,11.37)
WWAN_FULL_PWR_EN: length 173.4
  TOP w0.109: v2(172.35,34.28) 172.36,34.28 172.36,34.38 172.69,34.72 173.26,34.72 173.34,34.65 173.76,34.65 174.28,34.13 UH1.BF19
  IN4 w0.102: v2(249.97,4.38) 249.8,4.21 247.27,4.21 245.88,5.6 243.82,5.6 239.02,10.4 238.34,11.09 238.34,12.44 237.38,13.4 230.04,13.4 229.61,13.83 220.21,13.83 218.69,12.31 209.46,12.31 207.61,14.15 204.65,14.15 203.95,13.45 200.92,13.45 200.32,14.05 199.17,14.05 198.32,14.9 195.62,14.9 194.9,15.62 192.27,15.62 191.42,14.77 189.72,14.77 189.16,14.21 188.61,14.21 187.96,13.56 187.34,13.56 186.68,14.23 186.05,14.23 186.02,14.2 184.45,14.2 182.26,16.39 180.96,16.39 180.54,16.81 179.14,16.81 177.5,18.44 176.66,18.44 176.3,18.81 174.48,18.81 172.38,20.91 172.38,21.38 172.11,21.65 172.11,23.82 173.17,24.89 173.17,25.56 171.8,26.93 171.8,28.52 171.14,29.18 171.14,31.47 172.26,32.59 172.26,33.28 172.35,33.37 v2(172.35,34.28)
  BOTTOM w0.109: v2(249.97,4.38) 250.12,4.38 250.8,3.71 256.61,3.71 257.93,5.02 265.75,5.02 265.88,5.15 268.45,5.15 269.5,4.09 273.8,4.09 273.85,4.14 274.99,4.14 275.71,4.87 276.13,4.87 276.46,5.2 276.46,6.15 275.18,7.43 275.18,9.36 275.71,9.88 276.1,9.88 276.43,10.22 276.43,10.99 277.12,11.69 278.24,11.69 278.65,11.28 278.65,6.54 278.1,6 278.1,5.25 278.56,4.79 279.77,4.79 280.15,5.18 280.15,6.94 CZ198.1 281.13,6.16 281.42,6.16 282.2,5.39 282.2,5.18 282.58,4.8 284.17,4.8 284.8,5.44 284.8,5.46 285.85,6.51 286.04,6.51 286.81,7.28 v1(286.81,7.28) 286.81,7.99 RZ43.1 286,8.26 285.83,8.43 285.83,9.75 286.08,10 288.23,10 289.16,10.93 290.58,10.93 290.75,10.76 JNGFF2.6
