# Allegro board LAH271PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_SPI_CS#2_R: length 2.8
  TOP w0.109: UZ12.20 123.27,23.41 123.94,24.08 123.94,24.42 RZ61.2
PCH_SPI_D0: length 87.5
  TOP w0.089: v2(178.08,23.85) 178.45,23.49 UH1.AU41
  IN1 w0.102: v2(158.04,26.78) 158.04,26.66 159.33,25.37 160.02,25.37 160.15,25.5 160.15,26.18 160.85,26.88 161.07,26.88 161.86,26.09 163.9,26.09 163.9,26.09 164.91,26.09 165.49,25.51 167.65,25.51 168.38,24.78 171.37,24.78 173.03,23.12 175.94,23.12 176.5,23.68 177.92,23.68 v2(178.08,23.85)
  BOTTOM w0.109: RH178.2 169.39,64.1 RC128.1 170.03,64.05 170.73,63.35 171.03,63.35 JSPI1.4 173.58,60.8 174.32,60.8 174.55,60.57 174.55,60.12 175.68,58.99 175.68,54.15 175.35,53.82 175.17,53.82 174.5,54.49 174.32,54.49 174.19,54.36 174.19,54.18 174.86,53.51 174.86,53.33 174.73,53.2 174.55,53.2 173.41,54.34 173.2,54.34 173.07,54.21 173.07,54.06 174.24,52.89 174.24,52.71 174.11,52.59 173.93,52.59 172.9,53.61 172.72,53.61 172.59,53.48 172.59,53.31 173.62,52.28 173.62,52.1 173.49,51.97 173.31,51.97 172.64,52.64 172.46,52.64 172.33,52.51 172.33,52.33 173,51.66 173,51.48 172.87,51.35 172.69,51.35 172.02,52.02 171.84,52.02 171.71,51.89 171.71,51.71 172.38,51.04 172.38,50.86 171.7,50.18 170.84,50.18 165.21,44.55 165.21,43.88 164.68,43.35 164.68,42.61 162.27,40.19 162.27,37.51 161.71,36.94 161.03,36.94 v1(158.98,34.89) 158.64,34.55 158.64,33.03 158.29,32.68 158.29,28.14 RH600.2 157.8,27.01 v2(158.04,26.78)
PCH_SPI_D0_0_R: length 17.9
  BOTTOM w0.109: UC5.5 136.43,45 v3(137.21,45.78) 137.63,46.21 138.86,46.21 139.26,45.8 139.26,41.2 138.48,40.42 137.61,40.42 137.34,40.14 137.34,39.58 137.42,39.5 137.42,38.66 136.73,37.96 136.52,37.96 135.65,37.09 134,37.09 RH723.2
PCH_SPI_D0_1_R: length 11.3
  TOP w0.109: UC6.5 120.13,32.81 v1(121.86,34.54) 122.25,34.93 127.19,34.93 127.27,35.01 RH727.2
PCH_SPI_D0_2_R: length 3.7
  TOP w0.109: UZ12.21 123.34,23.91 123.66,24.24 123.66,24.91 v1(123.48,25.09) 123.48,25.38 123.9,25.8 RZ59.2
PCH_SPI_D0_R1: length 105.5
  TOP w0.109: v2(132.64,39.83) 132.09,39.28 129.83,39.28 129.19,38.64 129.19,35.05 RH727.1 ; RZ59.1 125.82,25.8 v2(126.02,25.99)
  IN2 w0.081: v2(126.02,25.99) 125.58,26.43 123.68,26.43 122.14,27.98 121.81,27.98 v2(121.16,28.64) 120.75,29.04 120.75,30.45 121.9,31.59 122.57,31.59 124.06,33.08 124.06,34.35 125.01,35.3 128.95,35.3 129.49,35.84 129.49,38.96 130.82,40.3 132.21,40.3 132.64,39.87 v2(132.64,39.83) 132.64,39.83 132.64,39.64 132.88,39.4 132.88,39.34 134.86,37.36 137.29,37.36 137.5,37.57 145.06,37.57 145.34,37.3 149.79,37.3 150.42,37.92 151.91,37.92 152.08,37.75 153.4,37.75 155.56,39.91 156.01,39.91 156.95,40.85 156.95,41.92 157.49,42.45 158.58,42.45 161.06,44.92 162.01,44.92 169.06,51.97 169.06,52.39 169.3,52.63 169.3,54.46 169.81,54.97 170.72,54.97 171.57,55.82 171.57,56.33 173.12,57.89 173.53,57.89 174.09,58.45 174.09,58.62 173.55,59.16 173.55,59.34 173.67,59.46 173.83,59.46 174.38,58.91 174.55,58.91 174.67,59.03 174.67,59.19 174.12,59.74 174.12,59.9 174.24,60.02 174.41,60.02 174.96,59.48 175.12,59.48 175.33,59.69 v2(175.33,60.03)
  BOTTOM w0.109: v2(175.33,60.03) 175.33,60.81 174.43,61.71 173.98,61.71 173.64,61.37 173.46,61.37 173.33,61.5 173.33,61.68 173.82,62.16 173.82,62.32 173.69,62.45 173.49,62.45 173.03,61.99 172.84,61.99 172.72,62.12 172.72,62.3 173.23,62.81 173.23,62.98 173.09,63.11 172.79,63.11 172.64,62.96 172.13,62.96 JSPI1.3 170.87,64.21 RH178.1 ; v2(132.64,39.83) 133.02,39.44 RH723.1
PCH_SPI_D1: length 86
  TOP w0.089: 177.14,19.47 177.14,19.74 176.91,19.97 176.91,20.39 176.84,20.46 176.84,20.91 176.76,21 UH1.BA45
  TOP w0.109: 177.14,19.47 177.14,19.39 176.95,19.2 176.95,18.2 175.19,16.44 175.19,14.95 175.52,14.62 175.52,13.71 172.61,10.8 167.89,10.8 165.1,13.59 165.1,14.2 163,16.31 v2(162.07,16.31)
  BOTTOM w0.109: RH179.2 170.17,62.8 JSPI1.6 171.19,61.78 171.57,61.78 173.87,59.47 173.87,58.09 174.66,57.3 174.66,56.2 171.55,53.09 169.94,53.09 169.76,52.9 169.76,49.97 164.59,44.8 164.59,44.16 161.49,41.05 161.49,39.28 158.03,35.82 158.03,33.29 157.61,32.87 157.61,31.15 v1(157.47,31.01) 157.3,30.84 157.3,30.04 156.98,29.71 156.98,27.15 158.99,25.14 158.99,23.56 159.36,23.19 159.36,20.79 160.28,19.88 160.28,18.93 160.44,18.76 160.44,17.95 162.07,16.32 v2(162.07,16.31)
PCH_SPI_D1_0_R: length 10.2
  BOTTOM w0.109: v3(132.15,36.9) RH722.2 131.66,38.55 131.66,39.3 131.45,39.52 131.45,40.22 131.21,40.46 129.23,40.46 128.96,40.73 128.96,41.66 129.1,41.8 129.5,41.8 129.64,41.94 129.64,42.32 129.5,42.46 UC5.2
PCH_SPI_D1_1_R: length 9.7
  TOP w0.109: UC6.2 124.33,30.27 123.63,30.96 123.63,33.06 124.55,33.98 125.9,33.98 126.16,33.72 126.16,33.45 126.35,33.26 126.62,33.26 126.69,33.19 v1(127.08,33.19) 127.4,33.19 RH726.2
PCH_SPI_D1_2_R: length 3.2
  TOP w0.109: UZ12.24 122.82,25.41 123.01,25.61 123.01,25.95 v1(123.47,26.41) 124.64,26.41 RZ58.2
PCH_SPI_D1_R1: length 106.6
  TOP w0.109: v2(124.03,27.6) 124.07,27.57 RZ58.1 ; RH726.1 129.63,32.36 130.62,33.35 130.62,35.62 130.03,36.21 130.03,38.01 130.36,38.34 132.77,38.34 133.74,39.31 134.3,39.31 134.5,39.5 134.5,40.13 134.39,40.24 132.23,40.24 v2(131.86,39.87)
  IN2 w0.081: 131.86,39.8 131.86,39.76 134.55,37.07 137.32,37.07 137.6,37.34 144.95,37.34 145.22,37.07 149.89,37.07 150.51,37.69 151.82,37.69 151.98,37.53 153.5,37.53 155.66,39.69 156.11,39.69 157.2,40.78 157.2,41.84 157.56,42.2 158.65,42.2 161.15,44.69 162.11,44.69 169.29,51.88 169.29,52.3 169.56,52.57 169.56,53.24 171.79,55.48 171.79,56.24 173.22,57.66 173.88,57.66 v2(175.08,58.87) ; 131.86,39.8 v2(131.86,39.87) ; 131.86,39.8 131.22,39.16 130.24,39.16 129.69,38.61 129.69,35.69 129.1,35.09 125.1,35.09 124.27,34.26 124.27,32.99 122.66,31.38 122.16,31.38 121.16,30.38 v2(121.16,30.01) 121.16,29.25 121.99,28.43 122.87,28.43 123.7,27.6 v2(124.03,27.6)
  BOTTOM w0.109: v2(131.86,39.87) 132.15,39.58 RH722.1 ; RH179.1 170.23,63.44 JSPI1.5 171.33,62.34 171.52,62.34 174.28,59.59 174.28,58.44 174.96,57.76 174.96,56.66 175.1,56.51 175.31,56.51 175.44,56.64 175.44,58.51 v2(175.08,58.87)
PCH_SPI_D2: length 86.8
  TOP w0.089: UH1.AY48 177.17,19.98 177.34,19.81 177.34,19.47
  TOP w0.102: RH180.2 176.66,17.07 176.66,17.59 177.14,18.07 177.14,19.12 177.34,19.31 177.34,19.47
  TOP w0.109: RH180.2 176.39,16.6 RH30.2 176.68,16.01 176.68,15.13 176.57,15.02 176.23,15.02 175.96,14.76 175.96,13.82 172.67,10.53 166.73,10.53 166.25,11.01 166.25,11.86 v1(165.87,12.24) 164.86,13.24 164.86,14.11 163.17,15.8 161.8,15.8 161.62,15.97 161.17,15.97 v2(160.79,15.59)
  BOTTOM w0.109: RH183.2 167.84,60.52 168.2,60.52 JSPI1.12 168.99,59.73 169.19,59.73 171.1,57.82 171.1,54.62 170.37,53.89 169.67,53.89 169.05,53.28 169.05,50.27 165.21,46.42 164.41,46.42 162.47,44.48 162.47,43.56 162.34,43.42 161.8,43.42 160.7,42.33 160.7,39.66 155.51,34.47 155.51,32.14 156.54,31.11 156.54,30.28 156.27,30.01 156.27,26.8 158.25,24.81 158.25,23.64 157.91,23.3 157.91,21.05 157.67,20.81 157.67,20.46 157.17,19.95 157.17,19.23 158.67,17.73 159.2,17.73 160.69,16.24 160.69,15.69 160.79,15.59 v2(160.79,15.59)
PCH_SPI_D2_0_R: length 8.1
  BOTTOM w0.109: UC5.3 127.13,42.92 127.13,39.31 127.07,39.09 v1(127.07,39.09) 127.07,39.09 126.99,38.57 126.99,36.57 RH351.2
PCH_SPI_D2_1_R: length 7.4
  TOP w0.109: RH353.2 127.81,31.02 128.76,31.02 129.04,31.3 v1(129.26,31.3) 129.34,31.22 129.34,30.88 129.1,30.64 127.51,30.64 127.17,30.98 126.85,30.98 126.29,31.54 UC6.3
PCH_SPI_D2_R1: length 79.9
  TOP w0.109: v2(125.71,33.56) 126.25,33.02 126.52,33.02 126.67,32.87 126.87,32.87 RH353.1 ; v2(172.43,55.88) v1(171.62,55.88)
  IN2 w0.081: v2(125.71,33.56) 126.25,33.02 126.55,33.02 126.69,32.88 127.51,32.88 127.9,33.27 130.23,33.27 130.42,33.46 130.42,33.89 130.81,34.27 134.87,34.27 135.38,34.78 135.38,35.19 134.84,35.73 134.84,36.17 135.16,36.49 137.39,36.49 137.79,36.89 144.71,36.89 145.01,36.59 153.24,36.59 155.88,39.23 156.33,39.23 160.63,43.52 162.17,43.52 163.05,44.4 163.05,44.99 169.75,51.69 169.75,52.11 170.03,52.39 170.03,53.06 170.26,53.3 170.43,53.3 170.92,52.81 171.09,52.81 171.21,52.93 171.21,53.1 170.72,53.59 170.72,53.76 170.84,53.87 171.01,53.87 171.5,53.38 171.66,53.38 171.78,53.5 171.78,53.67 171.29,54.16 171.29,54.33 171.41,54.45 171.58,54.45 172.07,53.96 172.24,53.96 172.36,54.08 172.36,54.25 171.87,54.74 171.87,54.91 172.05,55.09 172.33,55.09 172.58,55.33 172.58,55.74 v2(172.43,55.88)
  BOTTOM w0.109: v2(125.71,33.56) 126.1,33.94 126.1,34.76 RH351.1 ; RH183.1 167.47,61.57 168.11,60.93 168.5,60.93 JSPI1.11 169.39,60.04 169.59,60.04 171.44,58.19 171.44,56.98 172.43,55.99 v2(172.43,55.88)
PCH_SPI_D2_XDP: length 227.8
  TOP w0.109: v2(269.63,94.53) 268.84,94.53 268.23,95.13 267.56,95.13 267.28,94.85 267.28,94.44 267.44,94.27 267.44,93.73 267.27,93.55 266.42,93.55 265.53,92.66 265.53,83.97 258.16,76.6 216.24,76.6 206.54,86.3 200.62,86.3 200.02,86.9 198.42,86.9 191.11,79.59 189.22,79.59 187.38,77.75 187.38,75.12 186.3,74.03 186.3,72.29 182.74,68.73 181.6,68.73 176.09,63.22 176.09,62.08 v3(173.96,59.95) 168.77,54.76 168.77,53.33 v2(168.37,52.94) ; v2(278.77,100.73) 278.28,100.25 RC127.2 ; RH180.1 177.12,15.14 v2(176.43,14.45)
  IN2 w0.081: v2(278.77,100.73) 278.77,96.96 277.05,95.24 269.98,95.24 269.63,94.89 v2(269.63,94.53)
  BOTTOM w0.109: v2(176.43,14.45) 176.26,14.28 176.26,11.97 175.76,11.47 166.9,11.47 166.14,10.71 163.82,10.71 161.69,12.84 160.05,12.84 158.82,14.08 158.82,15.99 157.98,16.83 155.94,16.83 155.35,17.42 154.07,17.42 153.41,18.07 153.41,19.7 154.89,21.18 154.89,23.79 154.87,23.81 154.87,26.65 155.15,26.93 155.15,29.55 156.05,30.46 156.05,30.93 155.04,31.94 155.04,34.67 160.23,39.86 160.23,43.16 164.06,46.99 165.11,46.99 168.46,50.34 168.46,52.85 v2(168.37,52.94)
PCH_SPI_D3: length 85.4
  TOP w0.089: 176.91,19.44 176.91,19.7 176.7,19.91 176.7,20.32 176.65,20.37 176.65,20.78 176.48,20.95 UH1.BA46
  TOP w0.109: v2(159.96,15.88) 161.05,16.97 163.01,16.97 165.11,14.87 RH335.2 167.42,14.87 RH334.2 166.85,14.25 166.85,13.24 168.35,11.74 172.26,11.74 172.56,12.04 172.56,12.78 174.31,14.53 174.31,15.08 174.19,15.2 174.19,15.72 176.75,18.28 176.75,19.28 176.91,19.44
  BOTTOM w0.109: RH184.2 167.2,59.83 167.48,59.83 JSPI1.14 168.31,59 168.51,59 169.08,58.43 169.08,56.68 170.52,55.24 170.52,54.37 170.27,54.13 169.57,54.13 168.82,53.37 168.82,50.36 165.11,46.66 164.06,46.66 160.47,43.06 160.47,39.76 155.28,34.57 155.28,32.04 156.31,31.01 156.31,30.38 156.03,30.11 156.03,26.7 157.27,25.46 157.27,23.59 157.41,23.45 157.41,22.74 v1(156.48,21.82) 156.01,21.35 156.01,19.46 159.59,15.88 v2(159.96,15.88)
PCH_SPI_D3_0_R: length 8.9
  BOTTOM w0.109: UC5.7 135.94,42.01 135.78,41.85 135.4,41.85 135.23,42.02 135.23,42.87 135.07,43.03 134.76,43.03 134.61,42.88 134.61,40.67 135.79,39.49 v1(135.79,38.96) 135.79,38.61 135.24,38.07 RH725.2
PCH_SPI_D3_1_R: length 12.4
  TOP w0.109: UC6.7 118.62,30.27 122.61,34.26 v1(123.57,34.26) 126.84,34.26 127.86,33.24 RH729.2
PCH_SPI_D3_R1: length 74
  TOP w0.109: RH729.1 130.06,33.24 130.36,33.53 130.36,35.33 v1(130.08,35.61) 129.69,36 129.69,38.01 130.27,38.59 132.66,38.59 133.89,39.83 v2(134.09,39.83)
  IN2 w0.081: v2(170.58,55.99) 170.18,55.99 168.81,54.62 168.81,53.92 168.69,53.8 168.24,53.8 168.12,53.68 168.12,53.51 168.24,53.39 168.69,53.39 168.81,53.27 168.81,52.78 168.6,52.58 168.6,52.16 161.98,45.54 160.81,45.54 158.35,43.08 156.7,43.08 155.62,42 154.92,42 154.02,41.11 152.58,41.11 152.46,40.99 152.46,40.45 152.34,40.33 152.17,40.33 152.05,40.45 152.05,40.99 151.93,41.11 151.35,41.11 150.78,40.54 141.6,40.54 141.15,40.99 140.13,40.99 139.85,40.71 139.85,40.54 140.22,40.17 140.22,40.03 140.1,39.91 139.92,39.91 139.57,40.26 139.39,40.26 139.27,40.14 139.27,39.97 139.42,39.82 139.42,39.65 139.3,39.53 139.13,39.53 138.94,39.72 138.84,39.72 137.51,38.4 134.8,38.4 134.09,39.11 v2(134.09,39.83)
  BOTTOM w0.109: v2(134.09,39.83) 134.09,39.77 134.77,39.08 RH725.1 ; v2(170.58,55.99) 170.1,55.99 169.7,56.39 169.7,56.66 169.86,56.81 170.64,56.81 170.84,57.01 170.84,57.38 170.41,57.8 170.23,57.8 169.7,57.26 169.51,57.26 169.39,57.39 169.39,57.57 169.92,58.11 169.92,58.29 169.03,59.19 168.83,59.19 JSPI1.13 167.76,60.25 167.44,60.25 166.77,60.92 RH184.1
PCH_TBT_PERST#: length 84.1
  TOP w0.109: RT500.1 117.59,12.67 117.91,12.34 120.1,12.34 120.31,12.56 122.36,12.56 122.59,12.79 123.51,12.79 123.73,13.01 RT621.1 v1(124.8,13.24) 125.73,13.24 126.5,12.48 127.41,12.48 v2(127.6,12.67) ; UH1.AM48 180.8,20 180.8,19.47 180.46,19.13 180.46,17.67 179.86,17.07 RT616.2 RT615.2 180.75,16.7 180.29,16.25 180.29,15.02 179.49,14.21 v2(179.39,14.21) 179.32,14.21 174.43,9.33 173.49,9.33 172.87,8.72 v2(172.87,8.46)
  IN4 w0.102: v2(172.87,8.46) 172.63,8.71 166.1,8.71 165.53,9.27 161.8,9.27 160.34,10.74 160.34,11.52 159.62,12.23 159.1,12.23 158.38,12.95 156.69,12.95 155.83,13.82 154.91,13.82 154.32,14.41 153.51,14.41 151.83,16.09 148.24,16.09 147.69,15.54 147.69,13.82 146.93,13.07 146.93,12.77 145.43,11.27 141.61,11.27 140.41,10.07 134.97,10.07 134.79,10.25 132.86,10.25 132.68,10.43 132.68,10.87 132.23,11.31 130.4,11.31 129.8,11.92 127.9,11.92 127.59,12.23 127.59,12.65 v2(127.6,12.67)
  BOTTOM w0.109: RT644.2 179.09,14.52 v2(179.39,14.21)
PCH_THERMTRIP#: length 7.8
  TOP w0.089: UH1.AD3 184.65,42.5 184.65,45.2 184.75,45.3 184.83,45.3 184.94,45.41 184.94,45.56 184.83,45.66 184.75,45.66 184.65,45.76 184.65,45.91 184.75,46.02 184.83,46.02 184.94,46.12 184.94,46.27 v1(184.83,46.37) 184.75,46.37 184.65,46.48 184.65,46.62 184.75,46.73 184.83,46.73 184.94,46.83 184.94,46.98 184.83,47.08 184.75,47.08 184.65,47.19 184.65,47.38 184.95,47.68 RH75.1
PCH_XDP_CLK_DN: length 129.2
  TOP w0.102: v2(273.03,86.13) 273.27,85.9 273.5,85.9 276.99,89.39 279.13,89.39 279.39,89.64 279.39,90.1 280.62,91.33 281.14,91.33 281.36,91.55 JXDP1.42 ; RH154.2 185.88,57.41 185.88,57.74 186.15,58.01 187.06,58.01 187.68,58.62 187.68,60.83 189.2,62.35 190.66,62.35 191.4,63.09 191.4,63.85 191.55,64 191.55,64.25 v2(191.78,64.49)
  IN1 w0.102: v2(213.36,89.16) 213.05,88.85 213.05,88.23 201.62,76.79 201.62,74.84 198.8,72.02 196.69,72.02 191.4,66.73 191.4,65.42 191.56,65.26 191.56,64.71 v2(191.78,64.49)
  IN3 w0.094: v2(213.36,89.16) 212.98,88.77 212.98,86.39 223.12,76.24 261.21,76.24 270.8,85.84 272.85,85.84 273.03,86.02 v2(273.03,86.13)
PCH_XDP_CLK_DN_R: length 15.5
  TOP w0.102: RH154.1 185.88,55.83 185.88,55.35 185.91,55.32 v4(185.91,54.13) 185.91,52.16 185.95,52.12 185.95,51.54 185.91,51.5 185.91,50.56 186.33,50.15 186.33,47.49 185.82,46.98 185.82,45.85 186.06,45.61 186.06,43.32 186.58,42.81 186.58,42.15 186.7,42.03 186.85,42.03 186.91,42.09 186.91,42.15 UH1.Y3
PCH_XDP_CLK_DP: length 129.3
  TOP w0.102: v2(191.12,64.49) 191.36,64.25 191.36,64.08 191.21,63.93 191.21,63.17 190.58,62.54 189.12,62.54 187.49,60.91 187.49,58.7 186.98,58.2 186.07,58.2 185.69,57.82 185.69,57.45 RH155.2 ; v2(273.03,85.47) 273.27,85.71 273.58,85.71 277.07,89.2 279.21,89.2 279.58,89.56 279.58,90.02 280.7,91.14 281.14,91.14 281.33,90.95 JXDP1.40
  IN1 w0.102: v2(212.7,89.16) 212.86,89 212.86,88.3 201.43,76.87 201.43,74.92 198.72,72.2 196.61,72.2 191.22,66.81 191.22,65.35 191.38,65.19 191.38,64.66 191.21,64.49 v2(191.12,64.49)
  IN3 w0.094: v2(273.03,85.47) 272.86,85.64 270.88,85.64 261.29,76.05 223.04,76.05 212.78,86.31 212.78,89.08 v2(212.7,89.16)
PCH_XDP_CLK_DP_R: length 15.5
  TOP w0.102: UH1.Y4 186.75,41.71 186.39,42.07 186.39,42.73 185.87,43.24 185.87,45.53 185.63,45.77 185.63,47.06 186.14,47.57 186.14,50.07 185.72,50.48 v4(185.72,51.83) 185.72,53.8 185.69,53.84 185.69,54.42 185.72,54.46 185.72,55.24 185.69,55.27 185.69,55.8 RH155.1
PCH_XDP_PRDY#: length 190.8
  TOP w0.102: UH1.AM5 181.15,41.55 181.17,41.57 181.17,41.58 181.3,41.71 181.3,44.37 180.77,44.91 180.77,46.42 179.91,47.28 179.91,47.62 179.36,48.17 179.36,48.55 178.82,49.1 v2(178.82,49.52)
  TOP w0.109: RC314.2 v2(260.76,105.69)
  IN4 w0.102: v2(260.76,105.69) 263.1,105.69 267,101.8 269.62,101.8 270.84,100.58 276.03,100.58 278.44,98.16 281.77,98.16 285.4,94.53 285.4,79.18 284.62,78.4 283.57,78.4 282.93,79.04 v2(282.82,79.04)
  BOTTOM w0.109: v2(178.82,49.52) 177.84,50.5 177.84,51.34 178.7,52.19 178.7,52.82 181.37,55.49 181.37,57.6 183.01,59.25 184.97,59.25 185.7,59.97 185.7,61.96 189.67,65.93 189.67,70.18 191.08,71.59 191.08,74.48 191.8,75.2 191.8,76.76 195.55,80.51 v1(196.22,80.51) 198.13,80.51 198.91,81.29 202.67,81.29 209.4,74.57 253.22,74.57 253.85,73.93 273.38,73.93 276.99,77.54 281.54,77.54 CC337.1 282.04,78.05 282.04,78.53 282.56,79.04 v2(282.82,79.04)
PCH_XDP_PREQ#: length 140.4
  TOP w0.102: v2(179.31,49.15) 179.55,48.91 179.55,48.25 180.13,47.68 180.13,47.34 180.97,46.49 180.97,45.96 181.68,45.25 181.68,43.18 181.56,43.07 UH1.AL2
  BOTTOM w0.109: RC315.2 CC338.1 282.13,76.29 276.07,76.29 273.29,73.51 253.83,73.51 253.19,74.14 209.38,74.14 202.49,81.03 198.99,81.03 198.1,80.14 195.52,80.14 192.04,76.66 192.04,75.1 191.32,74.38 191.32,71.49 189.91,70.08 189.91,65.7 v1(189.21,65) 186.03,61.82 186.03,59.86 185.18,59.01 183.11,59.01 181.6,57.5 181.6,55.38 178.93,52.71 178.93,52.09 178.11,51.27 178.11,50.83 179.31,49.62 v2(179.31,49.15)
PCI_CLK_LPC1: length 2
  TOP w0.089: v2(176.15,26.63) UH1.BB34
  BOTTOM w0.102: v2(176.15,26.63) 176.09,26.7 RH99.1
  BOTTOM w0.109: v1(176.37,26.01) 176.15,26.23 v2(176.15,26.63)
PCIE_PRX_C_DTX_N5: length 5.6
  BOTTOM w0.102: UL1.39 191.15,124.05 191.25,123.95 191.25,123.68 191.63,123.29 192.02,123.29 192.06,123.25 192.55,123.25 192.58,123.29 193.12,123.29 193.75,123.92 v4(194.15,123.92) 194.46,123.92 194.72,124.17 194.89,124.17 CL2.1
PCIE_PRX_C_DTX_N6: length 4.5
  BOTTOM w0.102: CR206.2 18.24,9.64 18.24,10.05 18.5,10.31 19,10.31 19.44,10.76 19.85,10.76 v4(20.08,10.99) 20.38,11.29 20.38,11.55 20.29,11.64 UR1.11
PCIE_PRX_C_DTX_P5: length 5.6
  BOTTOM w0.102: CL1.1 195.3,124.77 195.3,124.51 195.15,124.36 194.64,124.36 194.42,124.15 193.91,124.15 193.87,124.11 193.67,124.11 193.04,123.48 v4(192.29,123.48) 191.71,123.48 191.44,123.76 191.44,123.94 191.55,124.05 UL1.38
PCIE_PRX_C_DTX_P6: length 4.6
  BOTTOM w0.102: UR1.10 20.69,11.66 20.57,11.54 20.57,11.15 19.98,10.57 19.52,10.57 19.04,10.09 v4(18.82,10.09) 18.54,10.09 18.43,9.97 18.43,9.59 CR204.2
PCIE_PRX_C_TTX_N1: length 3.8
  BOTTOM w0.076: UT1.V22 33.97,33.7 33.97,33.09 34.24,32.82 34.27,32.82 34.28,32.8
  BOTTOM w0.102: 34.28,32.8 35.05,32.04 35.56,32.04 35.74,31.86 35.74,31.66 CT7.2
PCIE_PRX_C_TTX_N2: length 2.9
  BOTTOM w0.076: UT1.P22 32.14,33.69 32.14,33.12 32.33,32.93 32.36,32.93 32.37,32.92
  BOTTOM w0.102: 32.37,32.92 32.65,32.63 32.65,32.47 33.1,32.03 33.1,31.9 CT9.2
PCIE_PRX_C_TTX_N3: length 2.7
  BOTTOM w0.076: 30.15,32.92 30.15,32.94 30.13,32.96 30.13,33.23 30.29,33.39 30.29,33.7 UT1.K22
  BOTTOM w0.102: CT128.2 30.71,31.93 30.71,32.2 30.15,32.76 30.15,32.92
PCIE_PRX_C_TTX_N4: length 3.8
  BOTTOM w0.076: UT1.F22 28.45,33.71 28.45,33.39 28.31,33.25 28.31,32.44 28.39,32.35 28.39,32.32 28.42,32.29 28.42,32.28
  BOTTOM w0.102: 28.42,32.28 28.42,32.05 28.46,32.01 28.46,31.4 28.42,31.36 28.42,30.72 CT130.2
PCIE_PRX_C_TTX_P1: length 3.8
  BOTTOM w0.076: UT1.V23 33.74,33.63 33.69,33.68 33.58,33.68 33.5,33.61 33.5,33.34 34.13,32.71 34.13,32.68 34.15,32.67
  BOTTOM w0.102: CT6.2 35.55,31.61 35.55,31.78 35.48,31.85 34.97,31.85 34.15,32.67
PCIE_PRX_C_TTX_P2: length 2.9
  BOTTOM w0.076: 32.23,32.78 32.22,32.8 32.22,32.82 31.67,33.38 31.67,33.61 31.74,33.68 31.84,33.68 31.9,33.62 UT1.P23
  BOTTOM w0.102: CT8.2 32.91,31.91 32.91,31.95 32.46,32.39 32.46,32.55 32.23,32.78
PCIE_PRX_C_TTX_P3: length 2.6
  BOTTOM w0.076: UT1.K23 30.06,33.62 30,33.69 29.9,33.69 29.83,33.61 29.83,33.37 29.98,33.22 29.98,32.96 29.96,32.94 29.96,32.92
  BOTTOM w0.102: 29.96,32.92 29.96,32.68 30.52,32.12 30.52,31.96 CT127.2
PCIE_PRX_C_TTX_P4: length 3.8
  BOTTOM w0.076: UT1.F23 28.22,33.7 28.16,33.76 28.07,33.76 28,33.7 28,33.38 28.15,33.23 28.15,32.35 28.23,32.28
  BOTTOM w0.102: CT129.2 28.23,30.7 v4(28.23,31.72) 28.23,32.28
PCIE_PRX_DTX_N5: length 108.6
  TOP w0.094: v2(193.85,34.53) UH1.F20
  IN2 w0.094: v2(193.85,34.53) 193.61,34.53 193.46,34.68 193.46,35.03 193.66,35.23 194.45,35.23 195.19,35.97 195.19,38.48 195.47,38.76 195.47,41.08 195.29,41.26 195.29,47.19 194.67,47.82 194.67,50.28 195.42,51.03 197.56,51.03 198.53,52 198.53,53.51 199.38,54.35 200.6,54.35 201.33,55.09 201.33,59.17 203.01,60.85 203.01,64.74 202.13,65.62 202.13,66.86 202.89,67.62 202.89,77.85 200.86,79.89 200.86,81.46 199.01,83.31 199.01,86.11 197.39,87.73 197.39,88.72 194.43,91.69 194.43,96.42 194.24,96.61 194.24,101.43 195.15,102.34 195.15,104.5 196.27,105.62 196.27,108.28 196.78,108.79 196.78,110.78 200.14,114.14 200.34,114.14 200.75,113.72 v2(200.75,113.66)
  BOTTOM w0.102: CL2.2 196.21,124.21 196.39,124.21 196.6,124 196.6,121.29 197.76,120.13 197.76,115.85 199.72,113.9 200.52,113.9 v2(200.75,113.66)
PCIE_PRX_DTX_N6: length 217.2
  TOP w0.094: v2(191.18,33.01) 191.18,33.34 191.34,33.5 191.54,33.5 UH1.K21
  IN1 w0.102: v2(18,7.23) 18.21,7.44 18.21,7.75 18.55,8.09 20.95,8.09 21.3,8.43 22.73,8.43 23.58,9.29 28.86,9.29 30.21,7.93 31.85,7.93 32.26,8.34 32.26,8.48 33.74,9.96 37.69,9.96 45.48,17.74 47.15,17.74 47.44,18.03 48.01,18.03 48.2,18.22 49.69,18.22 49.88,18.03 51.71,18.03 51.92,17.82 53.72,17.82 55.32,16.22 56.16,16.22 57.89,14.5 59.6,14.5 60.65,15.55 60.65,18.93 61.89,20.17 66.09,20.17 67.6,21.68 69.09,21.68 69.09,21.68 70.49,21.68 73.54,24.73 77.13,24.73 77.43,25.03 79.99,25.03 81.16,23.86 84.33,23.86 85.25,22.94 91.83,22.94 92.55,22.22 93.63,22.22 96.63,19.22 101.15,19.22 101.65,19.72 107.92,19.72 108.31,20.11 109.99,20.11 110.38,19.72 116.78,19.72 117.99,18.52 118.79,18.52 119.26,18.05 123.06,18.05 123.9,18.88 125.8,18.88 125.92,18.76 126.33,18.76 126.56,18.99 127.92,18.99 128.41,18.5 129.68,18.5 130.55,19.37 131.23,19.37 131.42,19.19 132.29,19.19 132.65,19.55 136.95,19.55 137.84,20.45 138.62,20.45 138.88,20.7 138.88,21.68 140.59,23.4 141.27,23.4 142.78,21.88 144.12,21.88 145.77,23.53 146.61,23.53 147.45,24.38 147.87,24.38 148.37,24.87 156.37,24.87 156.81,25.32 158.04,25.32 159.04,24.33 160.68,24.33 160.91,24.55 162.16,24.55 162.75,25.15 163.31,25.15 164.17,24.29 166.26,24.29 166.42,24.13 167.08,24.13 167.89,23.33 168.65,23.33 169.32,23.99 171.14,23.99 172.95,22.19 172.95,21.89 173.88,20.96 174.7,20.96 174.88,20.78 175.61,20.78 175.79,20.6 176.48,20.6 177.8,19.27 177.8,18.43 178.77,17.47 181.1,17.47 182.31,18.67 182.69,18.67 183.49,19.48 183.49,20.55 183.22,20.82 183.22,21.45 183.91,22.14 183.91,23.04 184.44,23.57 184.44,26.34 186.12,28.02 188.52,28.02 188.88,28.38 188.88,30.48 188.49,30.87 188.49,31.7 188.89,32.1 190.85,32.1 191.47,32.72 191.47,32.95 191.4,33.01 v2(191.18,33.01)
  BOTTOM w0.102: v2(18,7.23) 18.19,7.42 18.19,8.3 CR206.1
PCIE_PRX_DTX_N7: length 158.2
  TOP w0.094: v2(191.92,32.36) UH1.L24
  IN4 w0.102: v2(191.92,32.36) 192.1,32.18 192.25,32.18 192.39,32.31 192.39,33.51 192.73,33.85 196.1,33.85 197.63,32.31 199.04,32.31 201.07,30.28 202.71,30.28 203.45,29.55 205.28,29.55 208.3,26.53 210.9,26.53 214.04,23.4 224.84,23.4 225.83,22.41 233.2,22.41 233.82,23.03 245.25,23.03 253.05,15.23 263.74,15.23 267.14,11.83 268.82,11.83 270.44,10.2 274.95,10.2 275.33,9.83 276.4,9.83 278.27,7.95 280.16,7.95 280.3,8.09 280.83,8.09 281.01,7.91 282.36,7.91 282.83,7.45 284.27,7.45 285.62,6.1 286.33,6.1 286.74,5.68 288.41,5.68 288.82,6.1 290.58,6.1 290.84,6.35 294.56,6.35 295.07,5.85 301.15,5.85 301.26,5.96 303.89,5.96 305.69,4.15 309.47,4.15 309.66,4.34 312.56,4.34 313.46,3.43 314.88,3.43 315.11,3.2 323.45,3.2 325.85,5.6 325.85,7.27 326.54,7.97 327.13,7.97 327.44,7.66 327.44,7.45 v2(327.65,7.24)
  BOTTOM w0.102: v2(327.65,7.24) 327.28,7.61 327.28,9.07 327.4,9.19 JNGFF1.35
PCIE_PRX_DTX_N8: length 126.7
  TOP w0.102: UH1.F24 193.71,32.09 193.71,32.46 v2(193.78,32.53)
  IN4 w0.102: v2(300.12,5.18) 299.91,4.97 299.91,4.81 299.58,4.48 295.25,4.48 294.19,5.54 291.13,5.54 290.89,5.3 289.14,5.3 288.73,4.9 286.42,4.9 286,5.31 285.29,5.31 283.94,6.66 282.51,6.66 282.04,7.13 281.37,7.13 281.1,6.86 278.2,6.86 276.18,8.88 272.8,8.88 270.65,6.73 268.13,6.73 266.92,7.94 266.92,9.69 262.26,14.35 252.82,14.35 252.63,14.53 247.11,20.05 233.62,20.05 232.05,21.62 225.32,21.62 224.32,22.62 213.66,22.62 210.59,25.68 207.52,25.68 206.89,26.31 203.95,26.31 201.01,29.24 200.79,29.24 198.76,31.27 197.42,31.27 195.7,33 193.63,33 193.42,32.78 193.42,32.61 193.49,32.53 v2(193.78,32.53)
  BOTTOM w0.102: JNGFF2.35 300,3.11 299.85,3.26 299.85,3.83 299.81,3.88 299.81,4.87 v2(300.12,5.18)
PCIE_PRX_DTX_N9: length 169.5
  TOP w0.094: UH1.G36 193.26,25.99 193.26,25.7 v2(193.17,25.61)
  IN2 w0.094: v2(193.17,25.61) 193.22,25.56 193.35,25.56 193.53,25.74 194.08,25.74 194.46,25.37 195.13,25.37 195.73,24.77 195.73,22.6 194.97,21.85 194.97,17.27 192.36,14.65 192.36,14.37 190.44,12.45 190.44,11.3 190.23,11.09 187.77,11.09 187.48,10.79 182.69,10.79 182.58,10.68 172.39,10.68 171.6,11.47 168.44,11.47 167.22,12.69 165.36,12.69 162.63,15.43 162.08,15.43 161.51,16 160.41,16 160.12,16.29 156.77,16.29 156.02,17.04 150.43,17.04 149.7,16.31 147.86,16.31 143.28,11.74 141.1,11.74 140.12,10.76 139.81,10.76 139.67,10.9 138.35,10.9 137.3,9.85 130.28,9.85 129.94,10.19 126.21,10.19 126.03,10.38 123.28,10.38 122.78,9.88 121.84,9.88 120.61,11.11 114.98,11.11 114.51,11.57 114.51,12.22 114.17,12.56 113.35,12.56 111.22,14.69 99.99,14.69 95.91,18.77 95.91,24.46 94.47,25.89 93.43,25.89 93.05,26.28 93.05,28.25 90.23,31.06 88.63,31.06 88.08,31.62 88.08,33.47 v2(87.86,33.69)
  BOTTOM w0.102: JNGFF3.5 77.12,48.2 77.38,47.94 78.38,47.94 78.93,47.39 80.45,45.87 80.45,45.29 81.41,44.33 81.41,40.08 82.19,39.29 82.19,37.18 81.25,36.24 81.25,35.49 82.38,34.37 82.72,34.37 83.15,33.94 86.31,33.94 87.12,33.13 88.05,33.13 88.27,33.35 88.27,33.59 88.17,33.69 v2(87.86,33.69)
PCIE_PRX_DTX_N10: length 166
  TOP w0.094: v2(191.46,25.06) 191.71,25.31 UH1.K37
  IN2 w0.094: v2(191.46,25.06) 191.55,25.04 191.63,24.89 191.63,24.89 191.56,24.68 191.56,24.5 191.78,24.28 192.29,24.28 192.81,24.79 193.12,24.79 193.37,24.54 194.64,24.54 194.96,24.23 194.96,23.03 194.15,22.22 194.15,17.64 191.27,14.77 191.27,14.4 189.4,12.53 188.8,12.53 188.24,11.96 187.31,11.96 187.02,11.67 182.37,11.67 182.25,11.55 174.57,11.55 172.99,13.13 172.99,13.74 172.49,14.25 165.04,14.25 162.37,16.92 160.61,16.92 160.37,17.17 157.68,17.17 156.96,17.89 150.04,17.89 149.35,17.2 147.48,17.2 142.89,12.61 140.86,12.61 140.38,12.14 139.27,12.14 139.06,11.92 138.01,11.92 137.02,10.93 134.96,10.93 134.62,11.27 130.81,11.27 130.6,11.06 126.58,11.06 126.39,11.25 125.12,11.25 124.45,11.92 117.88,11.92 117.29,12.51 115.48,12.51 114.45,13.53 113.5,13.53 111.39,15.64 100.26,15.64 96.71,19.2 96.71,24.94 95.45,26.2 95.45,26.92 95.2,27.18 94.78,27.59 94.78,29.84 94.73,29.89 94.73,30.37 90.54,34.56 88.15,34.56 87.88,34.29 87.2,34.29 86.77,33.86 85.97,33.86 85.72,33.61 85.72,33.43 v2(85.54,33.25)
  BOTTOM w0.102: JNGFF3.17 77.26,45.2 77.36,45.1 77.36,44.96 77.43,44.89 79.99,44.89 80.79,44.09 80.79,36.62 80.66,36.49 80.66,35.25 82.16,33.75 82.49,33.75 83.11,33.13 84.87,33.13 85.19,32.81 85.74,32.81 85.82,32.89 85.82,33.01 85.58,33.25 v2(85.54,33.25)
PCIE_PRX_DTX_N11: length 156.5
  TOP w0.094: UH1.G38 193.08,24.54 193,24.45 v2(193,24.39)
  IN2 w0.094: v2(193,24.39) 193.42,24.27 193.49,24.2 193.49,24.15 193.32,23.98 192.72,23.98 191.83,23.09 191.83,21.91 192.94,20.8 192.94,18.11 189.24,14.41 189.01,14.41 188,13.41 178.67,13.41 178.34,13.74 174.83,13.74 172.52,16.06 171.03,16.06 170.4,15.44 166.05,15.44 165.1,16.39 165.1,17.04 163.75,18.4 163.18,18.4 162.89,18.11 161.42,18.11 161.02,18.51 158.3,18.51 157.58,19.23 156.29,19.23 155.15,20.37 153.62,20.37 152.82,19.57 150.05,19.57 149.64,19.16 147.51,19.16 145.81,17.46 144.88,17.46 143.82,16.4 143.82,15.27 143.51,14.96 141.4,14.96 139.76,13.32 137.43,13.32 137.04,12.94 133.16,12.94 133.08,13.02 131.05,13.02 130.49,12.45 130.23,12.45 130.03,12.25 127.21,12.25 126.93,12.53 126.38,12.53 125.71,13.19 121.17,13.19 120.63,13.73 116.32,13.73 114.65,15.4 113.34,15.4 111.62,17.12 105.08,17.12 102.44,19.76 98.87,19.76 97.95,20.68 97.95,25.6 96.79,26.76 96.79,27.4 96.02,28.16 96.02,30.98 91.17,35.84 87.02,35.84 86.23,35.05 83.69,35.05 83.38,34.74 81.65,34.74 80.81,35.58 80.81,35.98 78.82,37.97 78.82,39.63 78.42,40.03 78.42,40.14 78.5,40.23 78.89,40.23 78.99,40.32 v2(78.99,40.48)
  BOTTOM w0.102: JNGFF3.29 77.11,42.2 77.27,42.05 77.61,42.05 77.95,41.7 78.5,41.7 78.99,41.21 v2(78.99,40.48)
PCIE_PRX_DTX_N12: length 152.1
  TOP w0.094: v2(193.46,22.74) 192.97,22.74 UH1.H42
  IN2 w0.094: v2(77.56,38.7) 77.76,38.9 77.84,38.9 78.02,38.72 78.02,37.64 78.76,36.9 78.76,35.47 80.79,33.44 84.98,33.44 85.81,34.26 86.61,34.26 87.03,34.69 87.72,34.69 88.08,35.05 90.68,35.05 95.23,30.5 95.23,27.83 95.93,27.12 95.93,26.4 97.12,25.21 97.12,19.47 97.7,18.9 98.46,18.9 101.16,16.2 111.42,16.2 113.63,13.99 114.69,13.99 115.76,12.92 117.53,12.92 118.04,12.4 124.71,12.4 125.38,11.74 126.61,11.74 126.89,11.46 130.44,11.46 130.65,11.66 134.91,11.66 135.13,11.45 136.77,11.45 137.73,12.4 138.85,12.4 138.99,12.53 140.14,12.53 141.3,13.69 143.36,13.69 147.36,17.69 149.28,17.69 150.37,18.78 153.15,18.78 153.33,18.96 154.29,18.96 154.88,18.37 157.2,18.37 157.92,17.65 160.44,17.65 160.78,17.32 162.66,17.32 165.33,14.65 172.76,14.65 174.55,12.86 177.93,12.86 178.27,12.52 182.58,12.52 182.94,12.16 186.78,12.16 187.09,12.47 188.18,12.47 188.63,12.93 189.23,12.93 190.88,14.57 190.88,14.93 193.73,17.79 193.73,21.77 193,22.5 193,22.67 193.18,22.85 193.35,22.85 v2(193.46,22.74)
  BOTTOM w0.102: JNGFF3.43 77.08,38.7 77.14,38.76 77.5,38.76 v2(77.56,38.7)
PCIE_PRX_DTX_N17: length 186.5
  TOP w0.094: v2(192.39,22.75) 192.34,22.8 UH1.K43
  IN1 w0.102: v2(352.19,10.46) 352.39,10.46 352.79,10.06 352.79,9.63 351.62,8.45 348.6,8.45 348.1,7.96 346.8,7.96 346.3,8.45 343.51,8.45 343.26,8.69 342.09,8.69 341.86,8.46 340.2,8.46 338.9,7.17 338.2,7.17 337.7,6.66 330.24,6.66 328.66,5.08 328.66,2.86 327.95,2.15 313.97,2.15 313.61,2.52 309.87,2.52 309.56,2.21 296.06,2.21 293.45,4.81 291.19,4.81 290.84,4.46 290.84,3.4 290.55,3.11 286.76,3.11 285.73,4.14 283.91,4.14 283.05,5 278.18,5 276.75,3.57 274.69,3.57 274.33,3.94 262.28,3.94 260.34,5.87 260.34,7.26 261.52,8.44 261.52,10.55 258.12,13.94 257.05,13.94 253.87,17.13 241.4,17.13 240.54,16.28 231.64,16.28 231.23,16.68 218.63,16.68 218.35,16.4 204.34,16.4 202.83,17.91 200.78,17.91 200.23,18.47 196.81,18.47 195.92,19.35 195.92,19.75 193.02,22.65 192.49,22.65 v2(192.39,22.75)
  BOTTOM w0.102: v2(352.19,10.46) 352.28,10.46 352.5,10.24 352.5,9.87 352.4,9.76 JNGFF4.43
PCIE_PRX_DTX_N18: length 192.3
  TOP w0.094: v2(190.3,23.81) 189.98,23.49 UH1.P41
  IN1 w0.102: v2(190.3,23.81) 190.3,24.07 190.4,24.17 190.69,24.17 190.85,24 191.63,24 191.89,24.26 192.19,24.26 192.85,24.92 193.17,24.92 193.5,24.59 194.57,24.59 195.94,23.22 202.47,23.22 203.33,22.36 206.15,22.36 206.81,21.7 206.81,21.09 208.84,19.06 216.18,19.06 216.53,19.42 232.15,19.42 232.75,18.82 238.99,18.82 239.85,19.67 242.71,19.67 243.48,20.45 254.27,20.45 257.87,16.85 259.97,16.85 266.95,9.86 266.95,8.01 268.1,6.86 271.12,6.86 272.79,8.52 279.42,8.52 279.7,8.79 281.05,8.79 281.31,8.54 284.15,8.54 284.82,7.88 285.94,7.88 287.79,6.03 288.79,6.03 290.14,7.38 295.51,7.38 296.27,6.63 303.28,6.63 303.83,6.08 306.77,6.08 307.18,5.67 311.37,5.67 311.55,5.49 314.32,5.49 314.44,5.61 316.2,5.61 316.68,6.09 320.38,6.09 320.73,5.75 322.13,5.75 326.23,9.84 332.65,9.84 333.26,10.46 336.35,10.46 336.9,11.01 340.29,11.01 340.74,11.46 342.87,11.46 343.31,11.9 346.82,11.9 347.31,11.41 350.29,11.41 351.11,12.23 353.75,12.23 354.17,12.65 355.24,12.65 356.57,11.32 356.93,11.32 357.03,11.22 357.03,10.07 356.71,9.76 355.77,9.76 355.56,9.97 355.56,10.83 355.67,10.94 355.92,10.94 355.99,10.87 v2(355.99,10.62)
  BOTTOM w0.102: v2(355.99,10.62) 355.7,10.33 355.7,9.97 355.9,9.77 JNGFF4.29
PCIE_PRX_DTX_N19: length 198.4
  TOP w0.102: v2(190,22.61) 190.25,22.61 190.61,22.25 UH1.M44
  IN1 w0.102: v2(359.04,10.49) 358.82,10.27 358.82,9.6 358.08,8.86 355.06,8.86 353.98,9.93 353.98,10.38 353.49,10.87 351.72,10.87 351.22,10.38 351.22,9.62 350.91,9.31 349.22,9.31 348.81,9.72 348.47,9.72 348.21,9.99 346.37,9.99 345.99,9.61 343.99,9.61 343.65,9.95 341.24,9.95 340.94,9.65 338.67,9.65 338.09,9.06 333.76,9.06 333.02,8.32 327.05,8.32 326,7.27 326,5.03 324.64,3.67 315.43,3.67 315.19,3.92 313.96,3.92 313.74,4.14 309.35,4.14 309.18,3.97 303.98,3.97 302.68,5.27 301.95,5.27 300.33,3.65 296.26,3.65 293.93,5.98 290.71,5.98 289.34,4.61 287.16,4.61 286.4,5.37 285.43,5.37 283.67,7.13 281.37,7.13 280.92,6.68 274.23,6.68 272.72,5.17 265.02,5.17 262.7,7.48 262.7,12.15 259.68,15.17 257.56,15.17 254.42,18.31 240.78,18.31 239.91,17.44 232.17,17.44 231.54,18.07 217.2,18.07 216.82,17.69 205.94,17.69 205,18.64 205,20.07 204.25,20.82 196.38,20.82 193.41,23.79 192.65,23.79 191.87,23.01 191.87,22.11 191.44,21.68 190.65,21.68 190.29,22.03 190.29,22.32 v2(190,22.61)
  BOTTOM w0.102: JNGFF4.17 358.9,9.8 358.75,9.95 358.75,10.2 v2(359.04,10.49)
PCIE_PRX_DTX_N20: length 193.9
  TOP w0.102: v2(189.84,26.18) 189.55,26.48 UH1.R35
  IN1 w0.102: v2(189.84,26.18) 189.86,26.18 190.11,25.94 190.25,25.94 190.43,26.11 190.43,26.62 190.89,27.08 191.96,27.08 192.44,26.61 193.06,26.61 193.49,26.18 193.99,26.18 194.39,26.58 197.99,26.58 199.25,25.32 207.08,25.32 208.95,23.45 208.95,21.22 209.51,20.65 215.53,20.65 215.85,20.97 232.95,20.97 233.54,20.38 238.09,20.38 238.93,21.22 241.73,21.22 242.6,22.09 254.99,22.09 258.15,18.94 260.63,18.94 265.89,13.68 265.89,13.12 267.01,12.01 269.65,12.01 271.58,10.08 278.58,10.08 279.35,10.85 284.31,10.85 285.75,9.41 289.46,9.41 289.85,9.02 296.32,9.02 297.15,8.19 307.14,8.19 307.94,8.99 309.39,8.99 309.87,8.51 312.67,8.51 313.56,7.62 320.23,7.62 320.83,8.22 322.34,8.22 324.67,10.55 324.67,11.28 325.97,12.58 339.63,12.58 340.67,13.62 342.88,13.62 343.72,14.46 344.21,14.46 344.72,13.95 347.59,13.95 347.81,13.72 350.3,13.72 350.56,13.47 352.07,13.47 352.5,13.04 353.42,13.04 353.82,13.44 355.61,13.44 356.94,12.1 357.46,12.1 357.67,11.89 359.68,11.89 360.13,11.43 361.67,11.43 361.82,11.28 361.82,10.98 v2(362.04,10.76)
  BOTTOM w0.102: v2(362.04,10.76) 361.73,10.45 361.73,10.01 361.9,9.84 JNGFF4.5
PCIE_PRX_DTX_N21: length 142.9
  TOP w0.102: v2(187.93,23.09) 188.48,22.53 188.56,22.53 UH1.T43
  IN1 w0.102: v2(74.53,14.31) 74.53,14 74.66,13.88 82.73,13.88 83.22,14.37 89.86,14.37 90.82,13.4 92.44,13.4 93.78,12.06 109.59,12.06 112.43,9.21 114.9,9.21 115.4,9.72 118.31,9.72 119.22,10.62 121.31,10.62 121.58,10.35 122.38,10.35 122.67,10.65 126.75,10.65 127.35,10.05 134.43,10.05 134.65,10.26 137.03,10.26 138.9,12.13 140.25,12.13 140.71,12.59 142.15,12.59 142.79,13.23 144.06,13.23 146.63,15.79 147.57,15.79 148.3,16.52 149.68,16.52 149.93,16.78 154.3,16.78 154.5,16.57 155.49,16.57 156.68,15.38 159.82,15.38 160.26,14.94 163.29,14.94 164.78,13.46 166.89,13.46 168.61,11.74 172.75,11.74 173.67,10.82 175.78,10.82 177.51,9.08 178.91,9.08 180.11,7.88 186.38,7.88 188.24,9.73 188.24,13.99 189.28,15.04 189.28,15.32 187.91,16.7 187.91,20.67 187.33,21.25 187.33,22.65 187.51,22.83 187.67,22.83 v2(187.93,23.09)
  BOTTOM w0.102: JNGFF5.41 75.66,14.15 75.51,14 74.85,14 v2(74.53,14.31)
PCIE_PRX_DTX_N22: length 141.8
  TOP w0.102: UH1.U40 188.21,24.08 188.16,24.04 187.94,24.04 v2(187.6,24.38)
  IN1 w0.102: v2(74.53,17.31) 74.53,16.99 74.64,16.88 77.02,16.88 77.13,16.99 84.19,16.99 85.41,15.77 90.35,15.77 91.38,14.74 93.05,14.74 94.38,13.41 111.85,13.41 113.03,12.24 113.03,11.56 113.51,11.08 117.76,11.08 118.69,12.01 120.63,12.01 120.77,12.15 124.78,12.15 124.95,11.99 127.3,11.99 127.76,11.53 130.13,11.53 130.54,11.93 135.09,11.93 135.35,11.67 136.54,11.67 138.43,13.56 139.78,13.56 141.23,15 143.89,15 146.02,17.13 146.89,17.13 147.64,17.88 149.1,17.88 149.91,18.69 150.47,18.69 150.8,19.02 152.81,19.02 153.69,18.15 155.11,18.15 155.35,17.92 157.22,17.92 157.82,17.33 160.8,17.33 161.21,16.91 162.76,16.91 163.32,16.36 163.94,16.36 165.44,14.86 172.7,14.86 173.44,14.12 173.44,13.39 174.13,12.7 175.82,12.7 177.74,10.78 179.27,10.78 180.8,9.25 184.17,9.25 184.75,9.84 185.32,9.84 186.64,11.16 186.64,15.56 187.3,16.22 187.3,20.26 186.84,20.73 186.84,23.91 187.11,24.19 187.41,24.19 v2(187.6,24.38)
  BOTTOM w0.102: v2(74.53,17.31) 74.85,17 75.53,17 75.68,17.15 JNGFF5.29
PCIE_PRX_DTX_N23: length 142.2
  TOP w0.102: v2(186.44,23.12) 187.04,22.52 187.12,22.52 UH1.W43
  IN1 w0.102: v2(74.47,20.31) 74.47,20.14 74.57,20.04 78.3,20.04 78.56,20.29 82,20.29 82.57,19.71 84.37,19.71 84.89,20.23 88.98,20.23 90.53,18.68 90.53,18.33 92.18,16.68 94.02,16.68 94.9,15.8 100.65,15.8 100.96,15.49 105.66,15.49 106.28,16.11 111.9,16.11 113.7,14.3 119.22,14.3 119.41,14.5 124.3,14.5 125.2,15.4 126.11,15.4 126.21,15.5 127.11,15.5 127.39,15.23 131.21,15.23 131.49,15.5 132.59,15.5 133.06,15.02 134.92,15.02 135.26,14.68 135.98,14.68 137.15,15.85 138.16,15.85 138.93,16.62 139.85,16.62 140.77,17.55 140.77,18.19 141.38,18.8 144.31,18.8 144.59,19.09 145.95,19.09 148.41,21.55 152.87,21.55 153.44,20.98 155.03,20.98 155.72,20.28 157.73,20.28 157.86,20.41 160.1,20.41 160.4,20.11 160.7,20.11 161.47,20.88 163.36,20.88 163.87,20.37 163.87,19.75 166.49,17.13 168.62,17.13 169.94,18.45 170.73,18.45 170.93,18.26 172.51,18.26 173.25,17.51 174.42,17.51 177.15,14.79 177.15,14.16 178.54,12.77 182.51,12.77 183.06,12.22 185.73,12.22 186.03,12.52 186.03,13.03 185.15,13.91 185.15,15.84 185.89,16.58 185.89,17.67 186.55,18.33 186.55,18.68 186.28,18.96 186.28,19.42 185.6,20.1 185.6,21.48 185.75,21.63 185.75,22.56 185.96,22.77 186.3,22.77 186.44,22.91 v2(186.44,23.12)
  BOTTOM w0.102: v2(74.47,20.31) 74.78,20 75.52,20 75.67,20.15 JNGFF5.17
PCIE_PRX_DTX_N24: length 132.7
  TOP w0.102: v2(186.31,24.49) 186.31,24.33 186.59,24.05 186.79,24.05 UH1.Y40
  IN1 w0.102: v2(74.96,23.16) 75.21,22.92 76.13,22.92 76.16,22.95 80.07,22.95 80.53,22.5 81.72,22.5 82.05,22.16 84.04,22.16 84.61,21.59 89.52,21.59 91.97,19.14 93.45,19.14 95.45,17.14 101.21,17.14 101.52,16.83 103.3,16.83 104.75,18.28 111.99,18.28 113.9,16.37 116.84,16.37 117.16,16.06 121.23,16.06 121.84,16.67 124.42,16.67 124.82,17.08 126.53,17.08 126.75,16.86 127.72,16.86 127.98,16.6 130.03,16.6 130.43,17 131.98,17 132.23,17.25 137.45,17.25 139.13,18.94 139.6,18.94 140.81,20.15 143.76,20.15 144.04,20.43 145.4,20.43 147.97,23 148.42,23 148.96,23.53 152.89,23.53 154.06,22.36 155.56,22.36 155.79,22.13 157.87,22.13 158.25,22.5 159.59,22.5 159.71,22.62 162.32,22.62 162.72,22.23 165.88,22.23 167.66,20.44 172.13,20.44 172.97,19.6 173.94,19.6 174.55,18.99 175.51,18.99 176.19,18.3 176.19,17.71 177.8,16.1 183.3,16.1 185.49,18.29 185.49,19.12 184.92,19.69 184.92,21.75 185.23,22.06 185.23,22.82 185.55,23.14 185.55,23.97 185.76,24.19 186,24.19 v2(186.31,24.49)
  BOTTOM w0.102: v2(74.96,23.16) 75.18,22.94 75.46,22.94 75.68,23.15 JNGFF5.5
PCIE_PRX_DTX_P5: length 108.7
  TOP w0.094: v2(193.11,34.34) UH1.G20
  IN2 w0.094: v2(193.11,34.34) 193.27,34.5 193.27,35.12 193.58,35.43 194.37,35.43 195,36.05 195,38.56 195.28,38.84 195.28,41 195.1,41.17 195.1,47.11 194.47,47.74 194.47,50.36 195.34,51.22 197.48,51.22 198.34,52.08 198.34,53.59 199.3,54.55 200.51,54.55 201.14,55.17 201.14,59.25 202.81,60.93 202.81,64.66 201.93,65.53 201.93,66.94 202.7,67.7 202.7,77.77 200.66,79.81 200.66,81.38 198.81,83.23 198.81,86.03 197.19,87.65 197.19,88.64 194.23,91.6 194.23,96.34 194.04,96.53 194.04,101.51 194.95,102.42 194.95,104.58 196.08,105.71 196.08,108.36 196.58,108.87 196.58,110.86 200.06,114.33 200.74,114.33 v2(200.75,114.32)
  BOTTOM w0.102: CL1.2 196.26,124.4 196.47,124.4 196.79,124.08 196.79,121.37 197.95,120.2 197.95,115.93 199.8,114.09 200.52,114.09 v2(200.75,114.32)
PCIE_PRX_DTX_P6: length 217.2
  TOP w0.094: v2(191.84,32.98) 192.08,33.22 192.08,33.32 UH1.J21
  IN1 w0.102: v2(191.84,32.98) 191.66,32.79 191.66,32.64 190.93,31.91 188.97,31.91 188.67,31.62 188.67,30.95 189.06,30.56 189.06,28.3 188.6,27.84 186.2,27.84 184.63,26.27 184.63,23.49 184.1,22.96 184.1,22.06 183.41,21.38 183.41,20.9 183.68,20.63 183.68,19.4 182.77,18.48 182.39,18.48 181.18,17.28 178.69,17.28 177.61,18.35 177.61,19.2 176.4,20.41 175.71,20.41 175.53,20.59 174.8,20.59 174.62,20.77 173.8,20.77 172.76,21.81 172.76,22.11 171.07,23.81 169.4,23.81 168.73,23.14 167.81,23.14 167,23.94 166.34,23.94 166.19,24.1 164.09,24.1 163.23,24.96 162.83,24.96 162.24,24.37 160.99,24.37 160.76,24.14 158.96,24.14 157.97,25.13 156.89,25.13 156.44,24.69 148.45,24.69 147.95,24.19 147.53,24.19 146.69,23.35 145.85,23.35 144.2,21.7 142.7,21.7 141.19,23.21 140.67,23.21 139.06,21.6 139.06,20.62 138.7,20.26 137.92,20.26 137.03,19.37 132.73,19.37 132.36,19 131.34,19 131.15,19.19 130.63,19.19 129.76,18.31 128.33,18.31 127.84,18.8 126.64,18.8 126.4,18.57 125.84,18.57 125.72,18.69 123.97,18.69 123.14,17.86 119.18,17.86 118.71,18.33 117.91,18.33 116.7,19.53 110.3,19.53 109.91,19.92 108.39,19.92 108,19.53 101.72,19.53 101.23,19.04 96.55,19.04 93.55,22.04 92.47,22.04 91.76,22.75 85.17,22.75 84.25,23.67 81.09,23.67 79.91,24.85 77.51,24.85 77.2,24.54 73.62,24.54 70.57,21.49 69.09,21.49 69.09,21.49 67.68,21.49 66.17,19.98 61.97,19.98 60.84,18.85 60.84,15.47 59.68,14.31 57.81,14.31 56.08,16.04 55.24,16.04 54.39,16.89 53.65,17.63 51.84,17.63 51.63,17.84 49.8,17.84 49.62,18.03 48.28,18.03 48.09,17.84 47.52,17.84 47.23,17.55 45.56,17.55 37.77,9.77 33.82,9.77 32.45,8.4 32.45,8.26 31.93,7.74 30.14,7.74 28.78,9.1 23.66,9.1 22.81,8.25 21.38,8.25 21.03,7.9 18.63,7.9 18.4,7.68 18.4,7.32 18.49,7.23 v2(18.71,7.23)
  BOTTOM w0.102: v2(18.71,7.23) 18.38,7.56 18.38,8.26 CR204.1
PCIE_PRX_DTX_P7: length 158.2
  TOP w0.102: UH1.J24 192.3,31.89 v2(192.62,31.56)
  IN4 w0.102: v2(192.62,31.56) 192.42,31.76 192.42,32.08 192.58,32.24 192.58,33.43 192.8,33.66 196.02,33.66 197.56,32.13 198.96,32.13 200.99,30.1 202.63,30.1 203.37,29.36 205.2,29.36 208.22,26.34 210.82,26.34 213.96,23.21 224.76,23.21 225.76,22.22 233.27,22.22 233.9,22.85 245.17,22.85 252.98,15.04 263.66,15.04 267.06,11.64 268.74,11.64 270.37,10.02 274.88,10.02 275.25,9.64 276.32,9.64 278.19,7.77 280.24,7.77 280.38,7.9 280.76,7.9 280.93,7.73 282.29,7.73 282.75,7.26 284.19,7.26 285.54,5.91 286.25,5.91 286.66,5.5 288.49,5.5 288.9,5.91 290.66,5.91 290.92,6.17 294.49,6.17 294.99,5.66 301.23,5.66 301.34,5.77 303.81,5.77 305.61,3.97 309.55,3.97 309.74,4.15 312.48,4.15 313.39,3.25 314.8,3.25 315.03,3.01 323.53,3.01 326.03,5.52 326.03,7.2 326.62,7.78 327.05,7.78 327.25,7.58 327.25,7.33 327.1,7.18 v2(326.87,7.18)
  BOTTOM w0.102: v2(326.87,7.18) 327.09,7.4 327.09,9.07 326.9,9.26 JNGFF1.33
PCIE_PRX_DTX_P8: length 126.6
  TOP w0.102: v2(193.05,32.56) 193,32.51 193,32.05 UH1.G24
  IN4 w0.102: v2(193.05,32.56) 193.23,32.74 193.23,32.86 193.56,33.18 195.77,33.18 197.5,31.46 198.83,31.46 200.87,29.43 201.09,29.43 204.02,26.5 206.97,26.5 207.59,25.87 210.67,25.87 213.74,22.8 224.4,22.8 225.39,21.81 232.13,21.81 233.7,20.24 247.19,20.24 252.9,14.53 262.34,14.53 267.11,9.76 267.11,8.02 268.21,6.91 270.57,6.91 272.72,9.07 276.26,9.07 278.28,7.05 281.02,7.05 281.29,7.32 282.12,7.32 282.59,6.85 284.02,6.85 285.37,5.5 286.08,5.5 286.5,5.09 288.66,5.09 289.06,5.49 290.82,5.49 291.05,5.72 294.27,5.72 295.33,4.67 299.5,4.67 299.72,4.89 299.72,5.09 299.65,5.16 v2(299.35,5.16)
  BOTTOM w0.102: v2(299.35,5.16) 299.62,4.89 299.62,3.8 299.66,3.75 299.66,3.31 299.5,3.15 JNGFF2.33
PCIE_PRX_DTX_P9: length 169.5
  TOP w0.094: v2(193.79,25.14) 193.75,25.19 UH1.F36
  IN2 w0.094: v2(88.76,33.72) 88.76,33.86 88.65,33.96 88.41,33.96 88.27,33.83 88.27,31.7 88.71,31.26 90.31,31.26 93.24,28.33 93.24,26.36 93.51,26.09 94.55,26.09 96.1,24.54 96.1,18.85 100.07,14.89 111.3,14.89 113.43,12.76 114.25,12.76 114.71,12.3 114.71,11.65 115.06,11.3 120.7,11.3 121.93,10.07 122.69,10.07 123.19,10.57 126.11,10.57 126.29,10.39 130.02,10.39 130.36,10.04 137.21,10.04 138.26,11.09 139.75,11.09 139.89,10.95 140.04,10.95 141.02,11.93 143.2,11.93 147.78,16.5 149.62,16.5 150.35,17.24 156.1,17.24 156.85,16.49 160.2,16.49 160.5,16.19 161.59,16.19 162.16,15.62 162.71,15.62 165.44,12.89 167.3,12.89 168.52,11.67 171.68,11.67 172.47,10.88 182.5,10.88 182.61,10.99 187.4,10.99 187.69,11.29 190.15,11.29 190.24,11.38 190.24,12.53 192.16,14.45 192.16,14.73 194.78,17.35 194.78,21.93 195.53,22.68 195.53,24.69 195.05,25.18 194.38,25.18 194,25.55 193.61,25.55 193.47,25.36 193.49,25.2 193.6,25.12 v2(193.79,25.14)
  BOTTOM w0.102: v2(88.76,33.72) 88.46,33.42 88.46,33.27 88.13,32.94 87.04,32.94 86.23,33.75 83.07,33.75 82.64,34.18 82.3,34.18 81.06,35.42 81.06,36.32 82,37.26 82,39.21 81.22,40 81.22,44.25 80.26,45.21 80.26,45.8 78.8,47.26 78.3,47.75 77.23,47.75 77.18,47.7 JNGFF3.7
PCIE_PRX_DTX_P10: length 165.9
  TOP w0.094: v2(192.04,24.91) 192.24,25.11 192.24,25.19 UH1.J37
  IN2 w0.094: v2(86.15,33.25) 86.06,33.25 85.92,33.4 85.92,33.53 86.05,33.67 86.85,33.67 87.28,34.09 87.96,34.09 88.23,34.36 90.46,34.36 94.54,30.29 94.54,29.81 94.59,29.76 94.59,27.51 95.25,26.84 95.25,26.12 96.51,24.86 96.51,19.12 100.18,15.45 111.3,15.45 113.42,13.33 114.37,13.33 115.39,12.31 117.21,12.31 117.8,11.72 124.36,11.72 125.04,11.05 126.3,11.05 126.5,10.86 130.69,10.86 130.89,11.07 134.54,11.07 134.88,10.74 137.1,10.74 138.09,11.72 139.14,11.72 139.36,11.94 140.46,11.94 140.94,12.42 142.97,12.42 147.56,17 149.43,17 150.12,17.69 156.88,17.69 157.6,16.97 160.28,16.97 160.53,16.72 162.29,16.72 164.96,14.05 172.4,14.05 172.8,13.66 172.8,13.05 174.49,11.36 182.33,11.36 182.45,11.48 187.1,11.48 187.39,11.77 188.32,11.77 188.88,12.33 189.48,12.33 191.47,14.32 191.47,14.69 194.35,17.56 194.35,22.14 195.15,22.95 195.15,24.31 194.72,24.74 193.45,24.74 193.2,24.99 192.73,24.99 192.21,24.47 191.86,24.47 191.76,24.58 191.76,24.65 191.8,24.78 191.93,24.91 v2(192.04,24.91)
  BOTTOM w0.102: v2(86.15,33.25) 86.01,33.11 86.01,32.81 85.82,32.62 85.11,32.62 84.8,32.94 83.03,32.94 82.41,33.56 82.08,33.56 80.47,35.17 80.47,36.56 80.6,36.7 80.6,44.01 79.91,44.7 JNGFF3.19
PCIE_PRX_DTX_P11: length 156.5
  TOP w0.094: UH1.F39 194.07,24.21 v2(194.07,24.09)
  IN2 w0.094: v2(194.07,24.09) 193.79,24.17 193.4,23.79 192.81,23.79 192.02,23.01 192.02,21.99 193.14,20.88 193.14,18.03 189.32,14.22 189.09,14.22 188.08,13.22 178.59,13.22 178.26,13.55 174.75,13.55 172.44,15.86 171.11,15.86 170.48,15.24 165.97,15.24 164.91,16.31 164.91,16.96 163.67,18.2 163.26,18.2 162.97,17.91 161.34,17.91 160.94,18.32 158.22,18.32 157.5,19.03 156.21,19.03 155.07,20.18 153.7,20.18 152.9,19.38 150.13,19.38 149.72,18.97 147.59,18.97 145.89,17.27 144.96,17.27 144.01,16.32 144.01,15.18 143.59,14.77 141.48,14.77 139.84,13.13 137.51,13.13 137.12,12.74 133.08,12.74 133,12.82 131.13,12.82 130.57,12.26 130.31,12.26 130.11,12.06 127.13,12.06 126.85,12.33 126.3,12.33 125.63,13 121.09,13 120.55,13.54 116.24,13.54 114.57,15.2 113.26,15.2 111.54,16.93 105,16.93 102.36,19.57 98.79,19.57 97.76,20.6 97.76,25.51 96.59,26.68 96.59,27.31 95.83,28.08 95.83,30.9 91.09,35.64 87.1,35.64 86.31,34.86 83.77,34.86 83.46,34.54 81.57,34.54 80.62,35.49 80.62,35.9 78.62,37.89 78.62,39.55 78.22,39.95 78.22,40.47 v2(78.23,40.48)
  BOTTOM w0.102: v2(78.23,40.48) 78.45,40.48 78.8,40.82 78.8,41.13 78.42,41.51 77.88,41.51 77.53,41.85 77.22,41.85 77.07,41.7 JNGFF3.31
PCIE_PRX_DTX_P12: length 152.1
  TOP w0.102: UH1.J41 192.57,23.61 192.88,23.61 193.01,23.48 v2(193.01,23.37)
  IN2 w0.094: v2(77.57,39.36) 77.83,39.1 77.92,39.1 78.22,38.81 78.22,37.72 78.96,36.98 78.96,35.55 80.88,33.63 84.9,33.63 85.72,34.46 86.53,34.46 86.95,34.88 87.64,34.88 87.99,35.24 90.76,35.24 95.42,30.58 95.42,27.91 96.13,27.21 96.13,26.48 97.32,25.29 97.32,19.55 97.78,19.09 98.54,19.09 101.24,16.39 111.5,16.39 113.71,14.19 114.77,14.19 115.84,13.12 117.61,13.12 118.12,12.6 124.79,12.6 125.46,11.93 126.69,11.93 126.97,11.65 130.36,11.65 130.57,11.86 134.99,11.86 135.21,11.64 136.69,11.64 137.64,12.6 138.77,12.6 138.9,12.73 140.06,12.73 141.22,13.89 143.28,13.89 147.28,17.89 149.2,17.89 150.29,18.98 153.07,18.98 153.24,19.16 154.37,19.16 154.96,18.56 157.28,18.56 158,17.85 160.52,17.85 160.86,17.51 162.74,17.51 165.41,14.84 172.84,14.84 174.63,13.06 178.01,13.06 178.35,12.72 182.66,12.72 183.02,12.36 186.7,12.36 187.01,12.67 188.1,12.67 188.55,13.12 189.15,13.12 190.68,14.65 190.68,15.01 193.54,17.87 193.54,21.69 192.81,22.42 192.81,22.75 193.12,23.06 193.12,23.26 v2(193.01,23.37)
  BOTTOM w0.102: JNGFF3.41 77.4,39.2 v2(77.57,39.36)
PCIE_PRX_DTX_P17: length 186.5
  TOP w0.094: v2(192.55,22.1) 192.36,22.3 192.2,22.3 192.04,22.14 UH1.K44
  IN1 w0.102: v2(192.55,22.1) 192.55,22.32 192.69,22.46 192.94,22.46 195.73,19.67 195.73,19.28 196.73,18.28 200.15,18.28 200.7,17.72 202.75,17.72 204.27,16.21 218.42,16.21 218.71,16.49 231.16,16.49 231.56,16.09 240.62,16.09 241.47,16.94 253.79,16.94 256.97,13.76 258.04,13.76 261.33,10.47 261.33,8.52 260.15,7.34 260.15,5.79 262.2,3.75 274.25,3.75 274.62,3.38 276.83,3.38 278.25,4.81 282.98,4.81 283.83,3.95 285.65,3.95 286.68,2.92 290.63,2.92 291.03,3.32 291.03,4.38 291.27,4.63 293.38,4.63 295.98,2.02 309.64,2.02 309.94,2.33 313.53,2.33 313.89,1.96 328.03,1.96 328.85,2.78 328.85,5 330.32,6.47 337.77,6.47 338.28,6.98 338.98,6.98 340.27,8.27 341.94,8.27 342.17,8.51 343.19,8.51 343.43,8.27 346.23,8.27 346.72,7.77 348.18,7.77 348.67,8.27 351.7,8.27 352.98,9.55 v2(352.98,10.46)
  BOTTOM w0.102: v2(352.98,10.46) 352.69,10.17 352.69,9.98 352.9,9.78 JNGFF4.41
PCIE_PRX_DTX_P18: length 192.3
  TOP w0.094: v2(190.06,24.35) 189.93,24.22 UH1.R40
  IN1 w0.102: v2(190.06,24.35) 190.77,24.35 190.93,24.19 191.55,24.19 191.81,24.45 192.12,24.45 192.77,25.11 193.25,25.11 193.58,24.77 194.65,24.77 196.02,23.41 202.55,23.41 203.41,22.55 206.23,22.55 207,21.78 207,21.17 208.92,19.25 216.1,19.25 216.45,19.6 232.23,19.6 232.83,19.01 238.91,19.01 239.77,19.86 242.63,19.86 243.4,20.64 254.35,20.64 257.95,17.03 260.05,17.03 267.14,9.94 267.14,8.09 268.18,7.04 271.05,7.04 272.71,8.7 279.34,8.7 279.62,8.98 281.13,8.98 281.38,8.73 284.23,8.73 284.89,8.07 286.02,8.07 287.87,6.21 288.71,6.21 290.07,7.57 295.59,7.57 296.34,6.81 303.36,6.81 303.91,6.27 306.84,6.27 307.26,5.86 311.44,5.86 311.62,5.68 314.24,5.68 314.36,5.8 316.12,5.8 316.6,6.28 320.46,6.28 320.8,5.94 322.06,5.94 326.15,10.03 332.57,10.03 333.19,10.65 336.27,10.65 336.82,11.2 340.21,11.2 340.66,11.65 342.79,11.65 343.23,12.09 346.9,12.09 347.39,11.6 350.22,11.6 351.04,12.42 353.67,12.42 354.09,12.84 355.31,12.84 356.65,11.51 357,11.51 357.21,11.3 357.21,10 356.79,9.57 355.69,9.57 355.37,9.89 355.37,10.4 v2(355.15,10.62)
  BOTTOM w0.102: v2(355.15,10.62) 355.51,10.26 355.51,9.89 355.52,9.89 355.4,9.77 JNGFF4.31
