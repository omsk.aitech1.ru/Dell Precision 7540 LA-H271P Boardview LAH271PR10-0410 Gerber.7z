# Allegro board LAH271PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_PTX_DRX_P7: length 147.5
  TOP w0.102: UH1.B23 195.58,32.65 195.49,32.65 195.4,32.56 195.4,32.47 195.52,32.35 195.76,32.35 195.77,32.34 195.78,32.34 196.04,32.09 203.77,32.09 204.18,31.68 204.18,31.14 v2(204.41,30.91)
  IN4 w0.102: v2(204.41,30.91) 204.05,30.91 203.94,30.79 203.94,30.44 204.12,30.27 205.6,30.27 208.66,27.2 211.18,27.2 214.31,24.07 225.3,24.07 226.26,23.11 232.86,23.11 233.49,23.73 246.26,23.73 253.93,16.05 263.89,16.05 267.44,12.51 269.09,12.51 270.5,11.1 276.25,11.1 278.31,9.04 280.83,9.04 281.29,8.58 282.64,8.58 283.11,8.12 284.55,8.12 285.89,6.77 290.3,6.77 290.58,7.05 294.88,7.05 295.39,6.53 300.87,6.53 300.97,6.63 305.45,6.63 306.91,5.16 307.17,5.16 308.71,5.16 311.86,5.16 312,5.03 312.82,5.03 313.74,4.1 315.16,4.1 315.38,3.88 323.05,3.88 324.32,5.16 324.32,5.35 323.92,5.75 v2(323.79,5.75)
  BOTTOM w0.102: v2(323.79,5.75) 323.95,5.75 324.08,5.88 324.08,6.09 324.34,6.34 325,6.34 325.26,6.6 325.26,6.75 CZ12.1
PCIE_PTX_DRX_P8: length 141.1
  TOP w0.102: UH1.C24 194.78,32.09 194.53,32.35 194.53,32.55 v2(194.59,32.61) ; CZ11.1 308.75,2.19 308.75,2 308.84,1.91 309.39,1.91 309.42,1.95 310.02,1.95 310.06,1.91 310.7,1.91 311.39,2.6 311.39,3.7 311.3,3.79 311.12,3.79 v2(310.99,3.65)
  IN4 w0.102: v2(194.59,32.61) 194.98,32.21 195.74,32.21 200.12,27.83 200.12,27.71 201.56,26.27 202.81,26.27 203.35,25.73 206.68,25.73 207.95,24.46 210.12,24.46 214.09,20.5 232.44,20.5 233.45,19.49 246.98,19.49 252.9,13.57 260.36,13.57 262.96,10.97 262.96,8.31 265.02,6.24 271.39,6.24 273.48,8.33 275.9,8.33 277.87,6.37 281.28,6.37 281.47,6.18 283.74,6.18 285.1,4.82 285.81,4.82 286.22,4.42 288.93,4.42 289.34,4.82 291.09,4.82 291.33,5.05 293.95,5.05 295.02,3.99 300.27,3.99 301.55,5.27 303.62,5.27 305.9,3 311.16,3 311.39,3.24 311.39,3.65 311.3,3.74 311.07,3.74 v2(310.99,3.65)
PCIE_PTX_DRX_P9: length 205.9
  TOP w0.102: v2(209.9,24.96) 209.69,25.18 209.69,25.78 209.13,26.34 199.51,26.34 198.88,26.97 196.59,26.97 196.49,27.07 195.89,27.07 195.69,27.07 194.98,27.07 UH1.D34
  IN2 w0.094: v2(209.9,24.96) 209.57,24.63 209.57,23.39 208.98,22.8 208.98,18.45 206.14,15.62 200.46,15.62 198.12,13.28 197.42,13.28 197.1,13.6 195.15,13.6 193.67,12.11 193.67,11.34 191.27,8.94 188.63,8.94 187.39,7.69 179.92,7.69 179.58,7.35 178.54,7.35 177.92,7.97 175.34,7.97 174.37,6.99 173.12,6.99 170.9,9.21 162.63,9.21 159.95,11.89 159.29,11.89 158.34,12.85 156.12,12.85 155.27,13.7 155.27,14.69 154.87,15.09 151.35,15.09 150.92,14.65 150.92,13.71 149.65,12.44 149.26,12.44 147.93,11.12 145.65,11.12 144.17,9.64 141.63,9.64 140.73,8.74 140.73,8.59 139.92,7.78 135.4,7.78 135.1,7.49 127.65,7.49 127.05,8.09 125.44,8.09 125.18,8.35 124.37,8.35 122.27,6.26 117.68,6.26 116.84,7.1 114.65,7.1 109.89,11.85 99.93,11.85 92.51,19.28 91.17,19.28 90.55,19.89 90.55,20.67 88.64,22.59 88.64,23.95 87.78,24.81 87.78,25.45 86.61,26.62 86.61,27.17 85.64,28.14 83.66,28.14 83.46,27.94 81.27,27.94 80.87,27.54 80.52,27.54 80.25,27.28 79.46,27.28 79,27.74 79,28.78 76.87,30.9 76.87,31.71 77.63,32.47 77.63,33.62 76.75,34.5 76.75,36.19 75,37.94 73.99,37.94 72.28,39.65 72.04,39.65 71.93,39.54 71.93,39.18 72.01,39.1 v2(72.19,39.1)
  BOTTOM w0.102: v2(72.19,39.1) 72.06,39.1 71.67,39.5 71.67,39.82 70.96,40.53 70.96,43.89 71.02,43.95 71.02,45.06 71.06,45.1 71.06,45.76 71.02,45.8 71.02,45.99 71.36,46.33 71.86,46.33 CN66.1
PCIE_PTX_DRX_P10: length 194.7
  TOP w0.102: UH1.B35 195.65,26.57 195.75,26.57 195.75,26.57 197.03,26.57 197.33,26.57 198.54,26.57 199.36,25.74 206.46,25.74 208.16,24.05 209.15,24.05 210.9,22.29 210.9,20.96 210,20.06 206.74,20.06 206.08,19.4 206.08,19.06 206.16,18.98 v2(206.46,18.98)
  IN2 w0.094: v2(206.46,18.98) 206.25,18.98 206.14,19.09 206.14,19.59 205.92,19.8 205.37,19.8 204.17,18.6 200.33,18.6 197.75,16.02 194.41,16.02 192.95,14.55 192.95,14.29 190.91,12.25 190.91,10.82 190.62,10.53 187.92,10.53 187.18,9.79 184.66,9.79 184.14,9.26 178.94,9.26 178.64,9.56 177.69,9.56 177.12,10.14 172.21,10.14 171.46,10.89 168.3,10.89 167.15,12.03 165.05,12.03 164.58,11.56 163.66,11.56 163.12,12.11 162.49,12.11 160.78,13.81 159.56,13.81 158.43,14.94 157.23,14.94 155.59,16.59 150.65,16.59 149.89,15.82 148.21,15.82 147.79,15.4 147.79,14.37 147.54,14.11 147.54,13.69 146.53,12.68 144.97,12.68 143.51,11.22 141.25,11.22 139.86,9.83 138.21,9.83 137.75,9.37 129.76,9.37 129.44,9.69 126.02,9.69 125.82,9.9 123.6,9.9 123.09,9.39 121.55,9.39 120.31,10.63 113.94,10.63 113.03,11.53 113.03,12.15 111.78,13.4 100.61,13.4 95.34,18.66 95.34,18.67 94.22,19.79 94.22,20.99 91.68,23.53 91.68,27.09 90.75,28.03 88.95,28.03 85.99,30.99 83.44,30.99 82.57,31.86 81.04,31.86 80.03,32.87 80.03,33.52 78.24,35.3 78.24,36.7 76.47,38.46 76.47,39.45 75.49,40.44 71.96,40.44 71.78,40.61 71.78,40.72 71.95,40.88 v2(72.01,40.88)
  BOTTOM w0.102: CN68.1 71.91,43.3 71.65,43.3 71.55,43.2 71.55,41.4 72.01,40.94 v2(72.01,40.88)
PCIE_PTX_DRX_P11: length 186.8
  TOP w0.102: UH1.C36 195.48,26.04 195.5,26.04 195.5,26.04 195.76,26.04 195.89,26.17 198.16,26.17 199.19,25.14 204.99,25.14 207.37,22.77 208,22.77 v2(208.25,23.02)
  IN2 w0.094: v2(74.21,39.3) 74.46,39.05 74.63,39.05 74.74,39.16 75.43,39.16 75.81,38.77 75.81,38.25 77.58,36.49 77.58,35.12 79.34,33.36 79.34,32.71 80.79,31.25 82.29,31.25 83.16,30.38 85.75,30.38 88.7,27.44 89.54,27.44 91.05,25.93 91.05,23.32 93.55,20.82 93.55,19.51 94.67,18.39 94.67,18.39 100.33,12.73 110.26,12.73 112.48,10.5 113.1,10.5 114.44,9.17 114.97,9.17 115.39,9.59 120.2,9.59 121.13,8.66 123.32,8.66 123.87,9.22 125.54,9.22 125.74,9.02 129.11,9.02 129.85,8.28 134.36,8.28 134.74,8.66 138.16,8.66 138.66,9.15 140.03,9.15 141.4,10.52 143.84,10.52 145.3,11.99 147.52,11.99 148.38,12.84 148.38,14.06 149.09,14.77 149.8,14.77 150.96,15.93 155.26,15.93 156.14,15.05 156.14,14.19 156.59,13.74 158.68,13.74 159.46,12.96 160.21,12.96 163.05,10.11 171.26,10.11 171.92,9.46 176.58,9.46 177.18,8.85 178.51,8.85 178.79,8.58 186.98,8.58 188.23,9.83 190.9,9.83 192.73,11.66 192.73,12.41 195.08,14.76 197.94,14.76 199.98,16.79 206.08,16.79 207.56,18.27 207.56,22.46 207.79,22.69 208.09,22.69 208.25,22.84 v2(208.25,23.02)
  BOTTOM w0.102: v2(74.21,39.3) 73.73,38.82 73.44,38.82 72.53,39.73 72.53,40.3 72.66,40.44 73.25,40.44 73.34,40.35 73.34,40.16 CN70.1
PCIE_PTX_DRX_P12: length 204.2
  TOP w0.102: v2(206.36,21.47) 206.14,21.7 206.14,23.06 204.65,24.54 199.13,24.54 198.56,25.11 198.45,25.11 v4(198.25,25.32) 197.82,25.75 196.05,25.75 196.05,25.74 196.02,25.74 195.84,25.56 194.9,25.56 UH1.E37
  IN2 w0.094: v2(206.36,21.47) 206.15,21.26 206.15,20.98 206.3,20.83 206.59,20.83 206.87,21.1 206.87,24.55 208.19,25.87 210.64,25.87 211.34,25.17 211.34,19.85 206.44,14.95 200.78,14.95 198.39,12.57 197.04,12.57 196.78,12.83 196.14,12.83 191.55,8.25 188.9,8.25 187.66,7.01 180.23,7.01 179.89,6.67 179.27,6.67 178.78,6.18 177.23,6.18 176.56,6.85 175.3,6.85 174.63,6.18 172.89,6.18 170.54,8.53 160.91,8.53 158.49,10.95 158.49,11.74 158.06,12.18 155.71,12.18 154.33,10.8 151.95,10.8 151.45,10.29 148.08,10.29 145.52,7.74 144.36,7.74 143.68,7.06 140.82,7.06 139.85,6.09 135.8,6.09 135.07,6.82 130.44,6.82 129.72,6.1 127.81,6.1 126.52,7.39 125.39,7.39 125.13,7.12 124.11,7.12 122.65,5.66 115.13,5.66 109.62,11.17 98.05,11.17 89.68,19.54 89.68,20.52 87.97,22.24 87.97,23.6 86.17,25.4 86.17,26.2 85.44,26.92 83.76,26.92 83.34,27.34 81.69,27.34 81.22,26.87 80.83,26.87 80.47,26.51 78.68,26.51 77.5,27.69 77.5,28.09 75.44,30.15 75.44,32.32 76.13,33.01 76.13,35.97 74.81,37.29 72.72,37.29 v2(72.49,37.06)
  BOTTOM w0.102: CN72.1 72.92,37.3 72.73,37.3 v2(72.49,37.06)
PCIE_PTX_DRX_P17: length 183.8
  TOP w0.076: UH1.B42 196.1,22.6 196.87,22.6 196.97,22.7 197.31,22.7 197.33,22.68 197.35,22.68
  TOP w0.102: 197.35,22.68 202.4,22.68 203.86,21.23 203.86,20.46 203.5,20.1 v2(203.2,20.1)
  IN1 w0.102: v2(348.07,9.37) 347.78,9.09 347.78,8.78 347.53,8.52 347.03,8.52 346.61,8.94 343.71,8.94 343.46,9.19 341.89,9.19 341.66,8.96 339.04,8.96 337.9,7.81 337.37,7.81 337.03,7.47 330.37,7.47 328.18,5.28 328.18,3.46 327.43,2.72 324.65,2.72 324.37,3 316.18,3 316.17,3 315.15,3 314.91,3.25 313.86,3.25 313.61,3 309.61,3 309.32,2.71 296.25,2.71 293.65,5.31 291,5.31 290.29,4.6 290.29,3.91 289.97,3.59 287.2,3.59 286.12,4.68 285.17,4.68 283.85,6 277.2,6 276.23,5.04 274.53,5.04 273.95,4.46 262.51,4.46 261.05,5.91 261.05,7.11 262.02,8.08 262.02,11.84 259.37,14.49 257.23,14.49 254.09,17.63 241.12,17.63 240.26,16.77 231.85,16.77 231.21,17.4 217.6,17.4 217.21,17.01 204.99,17.01 203.43,18.57 203.43,19.87 v2(203.2,20.1)
  BOTTOM w0.102: v2(348.07,9.37) 347.76,9.37 347.61,9.51 347.61,10.04 348.78,11.21 349.16,11.21 v4(349.42,11.48) 350,12.05 350,12.1 350.58,12.68 350.64,12.74 351.03,12.74 351.15,12.62 351.15,12.3 351.08,12.22 CN187.1
PCIE_PTX_DRX_P18: length 177.6
  TOP w0.076: 197.35,23.45 197.34,23.45 197.32,23.43 196.74,23.43 196.66,23.51 195.91,23.51 195.76,23.36 195.1,23.36 195.03,23.35 UH1.D42
  TOP w0.102: 197.35,23.45 197.52,23.45 197.6,23.52 v4(200.56,23.52) 202.71,23.52 203.18,23.06 203.68,23.06 203.79,23.17 203.79,23.28 203.29,23.78 v2(203.2,23.78)
  IN1 w0.102: v2(203.2,23.78) 203.4,23.98 203.4,24.25 203.61,24.46 205.35,24.46 207.73,22.08 207.73,21.41 209.19,19.95 215.84,19.95 216.17,20.27 232.6,20.27 233.19,19.68 238.52,19.68 239.38,20.54 242.28,20.54 243.09,21.36 254.65,21.36 258.07,17.94 260.68,17.94 265.13,13.48 265.13,12.91 266.72,11.33 269.37,11.33 271.32,9.38 278.88,9.38 279.68,10.18 281,10.18 281.78,9.4 284.51,9.4 285.17,8.74 289.18,8.74 289.59,8.33 295.9,8.33 296.72,7.51 303.65,7.51 304.14,7.02 307.05,7.02 307.5,6.57 312.51,6.57 312.83,6.89 314.7,6.89 315,6.58 315.83,6.58 316.2,6.95 320.88,6.95 321.13,6.7 321.82,6.7 325.85,10.73 332.32,10.73 333.46,11.87 339.88,11.87 340.83,12.82 347.46,12.82 347.67,13.04 348.83,13.04 349.08,12.78 349.08,12.58 v2(349.3,12.35)
  BOTTOM w0.102: CN185.1 353.22,13.06 353.22,13.18 352.9,13.49 349.6,13.49 348.88,12.78 348.88,12.23 348.97,12.15 349.1,12.15 v2(349.3,12.35)
PCIE_PTX_DRX_P19: length 184.1
  TOP w0.076: 197.48,22.1 197.47,22.11 197.44,22.11 197.15,22.4 195.95,22.4 195.65,22.7 195.33,22.7 UH1.D43
  TOP w0.102: v2(201.51,22.25) 201.68,22.25 201.81,22.12 201.81,21.87 201.66,21.72 200.48,21.72 v4(200.47,21.73) 200.47,21.72 197.86,21.72 197.48,22.1
  IN1 w0.102: v2(355.22,12.09) 355.01,11.88 355.01,11.7 354.57,11.25 354.06,11.25 353.76,11.55 351.39,11.55 350.58,10.74 341.01,10.74 340.6,10.33 338.41,10.33 337.85,9.77 333.52,9.77 332.91,9.16 326.62,9.16 325.12,7.66 325.12,6.69 324.6,6.17 323.55,6.17 321.72,4.34 315.71,4.34 315.47,4.59 314.27,4.59 314.04,4.81 311.25,4.81 311.08,4.98 306.86,4.98 306.51,5.33 303.61,5.33 302.99,5.95 295.9,5.95 295.19,6.66 290.44,6.66 289.13,5.35 287.43,5.35 286.74,6.04 285.71,6.04 283.95,7.8 281.16,7.8 281.06,7.9 280.35,7.9 280.19,7.74 273.19,7.74 271.29,5.84 265.38,5.84 263.41,7.81 263.41,12.43 259.82,16.01 257.72,16.01 257.52,16.21 254.36,19.38 243.52,19.38 243.13,18.99 240.26,18.99 239.39,18.12 232.49,18.12 231.86,18.75 216.84,18.75 216.47,18.37 208.52,18.37 206.11,20.78 205.24,20.78 204.51,21.51 201.87,21.51 201.65,21.73 201.65,22.1 v2(201.51,22.25)
  BOTTOM w0.102: CN183.1 356.3,12.59 356.38,12.68 356.38,12.98 356.14,13.22 355.32,13.22 354.76,12.66 354.76,12.21 354.88,12.09 v2(355.22,12.09)
PCIE_PTX_DRX_P20: length 181.4
  TOP w0.102: UH1.B44 196.13,21.72 196.88,21.72 197.85,20.75 201.62,20.75 203.44,18.93 204.75,18.93 206.58,20.76 209.71,20.76 210.04,21.09 210.04,21.52 v2(210.27,21.75)
  IN1 w0.102: v2(210.27,21.75) 209.98,21.75 209.79,21.55 209.79,21.39 209.85,21.33 212.82,21.33 214.09,22.59 232.7,22.59 233.69,21.6 238.27,21.6 238.57,21.9 241.38,21.9 242.25,22.77 255.36,22.77 258.48,19.66 260.89,19.66 266.64,13.91 266.64,13.33 267.26,12.72 269.89,12.72 271.39,11.21 278.59,11.21 278.9,11.52 284.6,11.52 285.56,10.56 289.86,10.56 290.71,9.7 299.17,9.7 299.35,9.52 307.5,9.52 307.65,9.66 309.67,9.66 310.14,9.2 312.93,9.2 313.83,8.29 319.05,8.29 319.42,8.66 319.42,9.27 319.63,9.48 322.22,9.48 323.78,11.04 323.78,11.39 325.66,13.27 339.31,13.27 340.37,14.32 342.55,14.32 343.44,15.21 344.44,15.21 345.01,14.64 347.62,14.64 347.84,14.86 350.12,14.86 350.84,14.14 352.37,14.14 352.62,13.89 353.25,13.89 353.49,14.13 355.88,14.13 357.23,12.77 357.9,12.77 358.23,13.11 358.23,13.44 358.14,13.53 357.86,13.53 v2(357.81,13.48)
  BOTTOM w0.102: v2(357.81,13.48) 358.05,13.23 358.05,12.95 CN181.1
PCIE_PTX_DRX_P21: length 141.6
  TOP w0.076: 194.14,19.2 194.14,19.22 194.12,19.24 194.12,19.84 193.89,20.08 193.89,20.38 UH1.F46
  TOP w0.102: v2(186.22,9.11) 185.95,9.37 185.95,9.73 185.97,9.76 186.86,9.76 187.7,8.92 191.49,8.92 194.14,11.57 194.14,12.76 195.54,14.16 195.54,16.2 195.06,16.68 195.06,17.92 194.14,18.84 194.14,19.2 ; CN201.1 79.79,12.29 80.26,12.29 v4(81.18,13.2) 82.09,14.12 82.09,15.37 v2(82.23,15.52)
  IN1 w0.102: v2(82.23,15.52) 81.93,15.82 81.93,16.03 82.03,16.13 83.46,16.13 84.69,14.89 90.01,14.89 91.02,13.88 92.67,13.88 94.01,12.54 110.52,12.54 112.85,10.21 118.11,10.21 119.02,11.12 120.98,11.12 121.16,11.29 124.37,11.29 124.54,11.13 126.95,11.13 127.41,10.67 130.49,10.67 130.89,11.07 134.7,11.07 135.03,10.74 136.83,10.74 138.78,12.7 140.14,12.7 141.15,13.71 143.82,13.71 146.39,16.27 147.37,16.27 148.1,17 149.48,17 149.77,17.29 154.64,17.29 154.88,17.05 155.7,17.05 156.29,16.46 160.45,16.46 160.94,15.97 161.54,15.97 162.08,15.43 163.62,15.43 165.05,14 172.34,14 172.53,13.81 172.53,12.73 173.92,11.34 175.94,11.34 177.72,9.56 179.11,9.56 180.3,8.37 185.78,8.37 185.97,8.56 185.97,8.86 v2(186.22,9.11)
PCIE_PTX_DRX_P22: length 140.9
  TOP w0.076: 192.48,19.57 192.48,19.59 192.46,19.61 192.46,20.31 192.61,20.46 192.73,20.46 192.77,20.42 192.77,20.25 UH1.H48
  TOP w0.102: 192.48,19.57 192.48,19.34 192.48,19.34 192.48,18.17 193.26,17.39 193.26,14.72 192.27,13.73 192.27,13.07 190.11,10.91 188.8,10.91 186.34,13.37 183.21,13.37 182.78,12.94 182.78,12.59 182.95,12.42 182.95,11.7 182.36,11.12 182.36,10.02 182.42,9.96 v2(182.64,9.74) ; v2(81.97,18.28) 81.76,18.07 81.76,17.72 81.31,17.27 81.31,17.21 80.9,16.8 80.85,16.8 80.69,16.64 80.69,15.74 80.14,15.19 79.75,15.19 CN199.1
  IN1 w0.102: v2(81.97,18.28) 81.77,18.08 81.77,17.84 81.89,17.72 84.77,17.72 86.03,16.46 90.61,16.46 91.66,15.41 93.37,15.41 94.7,14.09 106.49,14.09 107.15,14.75 111.47,14.75 113.2,13.01 119.25,13.01 119.56,12.7 120.31,12.7 120.52,12.91 125.24,12.91 126.06,13.73 127.44,13.73 128.23,12.94 130.6,12.94 130.77,13.11 137.03,13.11 138.15,14.23 139.51,14.23 142.28,17 143.42,17 143.87,17.45 144.78,17.45 145.13,17.8 146.59,17.8 147.43,18.65 147.91,18.65 148.68,19.42 150.21,19.42 150.48,19.7 153.11,19.7 153.65,19.15 154.4,19.15 154.55,19.01 155.21,19.01 155.62,18.59 157.55,18.59 158.13,18 161.07,18 161.49,17.59 163.09,17.59 163.48,17.2 164.64,17.2 166.3,15.53 170.51,15.53 171.07,16.09 172.5,16.09 175.2,13.38 176.1,13.38 178.01,11.47 179.53,11.47 180.03,10.97 181.77,10.97 182.34,10.4 182.34,10.04 v2(182.64,9.74)
PCIE_PTX_DRX_P23: length 140
  TOP w0.076: UH1.G48 193.48,19.97 193.66,19.78 193.66,18.77 193.68,18.75 193.68,18.73
  TOP w0.102: v2(81.06,19.51) 80.89,19.34 80.89,19.07 80.07,18.25 79.76,18.25 CN197.1 ; v2(184.22,10.34) 183.99,10.58 183.99,10.78 184.22,11.01 185.22,11.01 185.8,10.43 187.21,10.43 188.06,9.58 191.16,9.58 192.47,10.89 192.52,10.89 192.99,11.36 192.99,11.41 193.5,11.92 193.5,13.09 194.92,14.51 194.92,15.89 194.46,16.35 194.46,17.74 193.68,18.52 193.68,18.73
  IN1 w0.102: v2(184.22,10.34) 183.96,10.61 183.96,11 183.68,11.28 182.87,11.28 182.59,11.56 180.28,11.56 179.75,12.09 178.27,12.09 176.36,14 175.87,14 175.69,14.18 175.69,14.82 175.15,15.36 175.15,15.83 174.15,16.83 172.96,16.83 172.39,17.4 170.89,17.4 169.61,16.13 166.55,16.13 164.28,18.39 163.25,18.39 163.12,18.27 161.74,18.27 161.41,18.6 158.5,18.6 157.91,19.18 155.87,19.18 154.76,20.29 152.45,20.29 151.87,20.88 151.4,20.88 150.93,20.41 150.32,20.41 149.95,20.04 148.41,20.04 147.66,19.29 147.13,19.29 146.26,18.41 144.87,18.41 144.51,18.05 143.62,18.05 143.18,17.61 142.04,17.61 139.26,14.83 137.9,14.83 136.79,13.71 130.85,13.71 130.42,14.14 127.93,14.14 127.75,14.32 125.16,14.32 124.6,13.76 119.62,13.76 119.47,13.61 113.44,13.61 111.65,15.4 106.72,15.4 106.14,14.82 100.68,14.82 100.4,15.11 94.61,15.11 93.71,16 91.9,16 90.79,17.11 86.8,17.11 84.96,18.95 81.03,18.95 80.84,19.14 80.84,19.28 v2(81.06,19.51)
PCIE_PTX_DRX_P24: length 141.5
  TOP w0.102: v2(184.09,12.77) 183.91,12.95 183.7,12.95 183.61,12.85 183.61,12.26 183.94,11.92 185.82,11.92 186.3,11.43 187.38,11.43 188.36,10.46 190.93,10.46 192.7,12.23 192.7,13.54 v4(192.96,13.81) 193.68,14.52 193.68,17.52 192.82,18.37 192.82,19.79 192.98,19.95 192.98,20.88 192.9,20.95 192.9,21.31 UH1.G45 ; CN195.1 79.49,21.3 79.62,21.43 81.05,21.43 81.14,21.34 81.14,21.22 v2(80.82,20.91)
  IN1 w0.102: v2(80.82,20.91) 80.82,20.91 80.82,21.64 81.01,21.83 81.44,21.83 81.78,21.49 83.15,21.49 83.73,20.91 89.25,20.91 91.2,18.96 91.2,18.61 92.46,17.35 94.3,17.35 95.18,16.47 100.93,16.47 101.24,16.16 105.21,16.16 105.85,16.8 112.48,16.8 113.6,15.68 116.52,15.68 116.83,15.37 121.64,15.37 121.95,15.68 124.43,15.68 124.83,16.08 125.74,16.08 125.84,16.17 127.41,16.17 127.68,15.9 130.83,15.9 131.17,16.24 133.05,16.24 133.33,16.52 137.72,16.52 138.98,17.78 139.53,17.78 139.84,18.09 139.84,18.22 141.1,19.47 144.03,19.47 144.32,19.76 145.67,19.76 148.2,22.28 148.69,22.28 149.27,22.86 151.34,22.86 151.97,22.23 153.25,22.23 153.81,21.66 155.29,21.66 155.49,21.46 159.58,21.46 160.07,21.94 160.6,21.94 160.99,21.55 165.24,21.55 166.68,20.1 166.68,19.59 167.47,18.8 169.27,18.8 170.02,19.55 172.06,19.55 172.69,18.93 172.92,18.93 173.56,18.28 174.62,18.28 179.44,13.46 181.92,13.46 182.18,13.72 183.6,13.72 183.85,13.47 183.85,13 v2(184.09,12.77)
PCIE_PTX_TRX_N1: length 213.2
  TOP w0.102: v2(202.46,38.14) 202.25,38.34 201.11,38.34 200.61,37.85 200.4,37.85 v4(200.14,37.6) 199.91,37.37 199.77,37.37 198.17,35.77 196.34,35.77 196.05,35.49 196.05,35.37 196.15,35.27 UH1.A17
  IN1 w0.102: v2(36.53,29.62) 36.53,28.3 38.9,25.93 41.14,25.93 41.31,26.1 42.75,26.1 43.01,26.36 44.9,26.36 47.01,24.25 47.97,24.25 49.08,23.14 50.22,23.14 50.77,23.7 51.77,23.7 52.4,23.07 53.33,23.07 53.89,22.51 54.54,22.51 55.53,23.5 56.75,23.5 57.77,24.53 58.38,24.53 59.31,25.46 60.51,25.46 60.82,25.78 61.2,25.78 63.43,28.01 66.59,28.01 68.15,29.58 73.54,29.58 75.02,31.06 76.23,31.06 78.02,32.85 79.42,32.85 79.77,33.2 82.87,33.2 84.78,31.29 87.54,31.29 88.13,30.7 90.93,30.7 92.29,29.33 96.56,29.33 98.69,27.2 103.07,27.2 103.85,26.42 105.79,26.42 106.37,26.99 108.15,26.99 109.16,25.98 110.06,25.98 110.07,25.97 110.57,25.97 110.58,25.98 110.66,25.98 111.18,25.98 111.18,25.98 112.48,25.98 112.7,26.19 115.41,26.19 116.07,25.53 117.25,25.53 117.91,26.19 118.63,26.19 120.51,28.07 120.51,28.73 120.92,29.14 121.25,29.14 121.86,29.75 121.86,30.21 124.27,32.62 124.27,32.92 124.4,33.05 124.4,33.67 125.45,34.73 129.34,34.73 129.95,35.34 129.95,37.27 130.37,37.69 130.38,37.69 130.47,37.78 130.47,37.78 130.56,37.86 130.9,37.86 130.99,37.78 132.81,37.78 132.89,37.86 133.23,37.86 133.31,37.78 134.82,37.78 135.65,36.95 137.27,36.95 139.19,35.03 145.81,35.03 146.91,33.93 152.8,33.93 153.62,34.75 154.01,34.75 161.05,41.79 162.17,41.79 162.38,42 163.25,42 165.53,44.28 165.53,45.25 170.19,49.91 171.27,49.91 173.05,51.69 177.55,51.69 177.92,52.06 179.67,52.06 180.51,51.22 185.76,51.22 188.25,48.74 189.61,48.74 189.86,48.98 193.62,48.98 194.89,47.71 195.42,47.71 197.51,45.62 197.51,44.93 197.9,44.54 197.9,43.45 199.86,41.49 199.86,40.56 199.99,40.43 202.12,38.3 202.29,38.3 v2(202.46,38.14)
  BOTTOM w0.102: v2(36.53,29.62) 36.77,29.85 36.77,29.97 37.35,30.56 37.35,30.66 CT3.2
PCIE_PTX_TRX_N2: length 217.5
  TOP w0.102: v2(203.45,37.34) 203.16,37.63 202.84,37.63 201.84,36.63 199.61,36.63 198.32,35.33 197.17,35.33 196.68,34.84 196.04,34.84 195.83,35.05 195.47,35.05 195.41,34.99 195.41,34.8 195.47,34.74 195.59,34.74 UH1.B18
  IN1 w0.102: v2(203.45,37.34) 202.24,37.34 199.11,40.47 199.11,41.26 197.2,43.18 197.2,44.28 196.88,44.6 196.88,45.36 195.18,47.06 194.69,47.06 193.37,48.38 191.67,48.38 190.82,47.54 188.26,47.54 185.79,50.02 182.93,50.02 182.35,50.59 180.15,50.59 179.29,51.45 178.44,51.45 178.06,51.08 173.8,51.08 173.1,50.38 172.6,50.38 171.51,49.29 170.69,49.29 166.24,44.84 166.24,43.46 165.38,42.6 164.74,42.6 163.52,41.38 162.68,41.38 162.5,41.2 161.32,41.2 154.8,34.67 154.8,34.32 153.72,33.24 146.56,33.24 145.37,34.43 138.74,34.43 136.81,36.36 135.12,36.36 134.71,36.76 130.89,36.76 130.67,36.55 130.67,35.17 129.63,34.13 125.71,34.13 125.16,33.58 125.16,32.96 124.87,32.67 124.87,31.16 119.31,25.6 118.15,25.6 117.49,24.93 115.81,24.93 115.16,25.59 113.07,25.59 112.87,25.39 112.74,25.39 112.72,25.37 108.91,25.37 108.89,25.39 108.84,25.39 107.93,26.3 106.68,26.3 106.17,25.79 102.11,25.79 101.88,26.02 99.6,26.02 99.16,25.58 97.75,25.58 94.72,28.62 91.95,28.62 90.47,30.1 87.79,30.1 87.21,30.68 84.4,30.68 83.24,31.85 80.32,31.85 78.81,30.33 75.29,30.33 73.88,28.93 68.44,28.93 66.85,27.35 64.49,27.35 63.21,26.06 62.33,26.06 61.44,25.17 61.07,25.17 60.76,24.87 59.56,24.87 58.63,23.93 58.06,23.93 57.03,22.9 55.77,22.9 54.79,21.92 53.64,21.92 53.08,22.47 52.16,22.47 51.53,23.09 51.04,23.09 50.48,22.53 48.82,22.53 47.7,23.65 46.76,23.65 45.08,25.34 42.83,25.34 42.69,25.48 41.6,25.48 41.46,25.33 37.78,25.33 35.29,27.83 35.29,28.01 34.7,28.6 34.52,28.6 34.28,28.84 34.28,29.28 v2(34.13,29.43)
  BOTTOM w0.102: v2(34.13,29.43) 34.33,29.63 34.33,29.92 34.18,30.07 34.18,30.27 CT5.2
PCIE_PTX_TRX_N3: length 208.4
  TOP w0.102: v2(197.84,34.46) 198.07,34.46 198.17,34.56 198.17,34.79 198.08,34.88 197.4,34.88 196.87,34.36 195.35,34.36 195.29,34.3 195.29,34.21 195.37,34.13 UH1.B19
  IN1 w0.102: v2(197.84,34.46) 198.12,34.74 198.12,35.78 195.66,38.23 195.66,40.58 195.08,41.16 195.08,41.91 195.26,42.09 195.26,42.52 193.43,44.35 193.43,46.31 192.84,46.91 192.12,46.91 191.38,46.17 185.15,46.17 183.63,47.69 177.4,47.69 176.8,48.28 173.06,48.28 172.34,47.56 172.34,46.78 169.31,43.75 168.63,43.75 167.85,42.96 167.85,41.99 167.16,41.3 166.57,41.3 165.68,40.41 165.01,40.41 163.91,39.31 161.35,39.31 156.16,34.12 156.16,33.77 154.3,31.9 145.23,31.9 145.02,32.11 138.47,32.11 138.15,32.44 136.32,32.44 135.11,33.65 132.21,33.65 131.08,32.52 129.56,32.52 129.22,32.18 127.96,32.18 125.42,29.64 125.42,27.36 123.61,25.55 122.64,25.55 120.02,22.92 117.38,22.92 117.26,23.05 115.77,23.05 114.98,23.84 113.4,23.84 113.14,23.57 112.5,23.57 112.06,23.13 105.84,23.13 105.17,23.8 103.63,23.8 103.21,24.22 96.92,24.22 95.27,25.87 92.65,25.87 90.7,27.82 89.94,27.82 89.85,27.91 87.44,27.91 86.51,28.83 83.12,28.83 82.85,28.55 80.76,28.55 80.75,28.57 80.67,28.57 80.51,28.73 80.49,28.73 80.25,28.97 79.92,28.97 79.51,28.55 76.46,28.55 75.07,27.17 72.56,27.17 70.08,24.69 68.01,24.69 68,24.68 66.43,24.68 66.37,24.62 63.76,24.62 62.97,23.83 61.63,23.83 61.33,23.53 61.32,23.53 61.32,23.52 60.48,23.52 59.27,22.31 58.85,22.31 56.78,20.24 52.92,20.24 52.3,20.86 50.6,20.86 50.27,21.19 46.66,21.19 44.81,23.03 43.85,23.03 43.38,23.5 39.43,23.5 38.96,23.97 36.89,23.97 33.44,27.41 32.58,27.41 32.26,27.74 32.26,28.08 v2(32.02,28.31)
  BOTTOM w0.102: v2(32.02,28.31) 32.25,28.55 32.25,28.97 31.7,29.53 31.7,30.04 CT124.2
PCIE_PTX_TRX_N4: length 233.8
  TOP w0.102: v2(201.15,34.26) 200.92,34.49 v4(199.96,34.49) 199.58,34.49 198.9,33.81 195.98,33.81 195.71,33.54 194.94,33.54 194.87,33.58 UH1.D20
  IN1 w0.102: v2(201.15,34.26) 201.37,34.48 201.62,34.48 203.13,35.98 204.66,35.98 205.51,36.84 205.51,39.11 200.86,43.76 200.4,43.76 199.89,44.27 199.89,44.77 199.43,45.23 199.43,46.05 196.66,48.81 196.66,49.36 196.99,49.68 196.99,50.67 196.34,51.31 195.91,51.31 194.45,52.77 194.45,53.47 193.13,54.79 185.78,54.79 184.85,53.87 181.69,53.87 181.36,54.19 173.33,54.19 170.85,51.72 169.75,51.72 167.5,49.47 167.5,49.47 162.8,44.76 162.8,44.1 162.3,43.6 161.71,43.6 161.42,43.32 160.39,43.32 154.05,36.97 153.07,36.97 151.56,35.46 150.07,35.46 148.92,36.61 145.23,36.61 144.22,37.62 139.05,37.62 138.06,38.61 136.27,38.61 135.46,39.42 129.78,39.42 126.62,36.26 124.8,36.26 123.21,34.67 122.72,34.67 122.27,34.22 122.27,33.38 121.83,32.94 121.83,32.56 117.01,27.75 112.68,27.75 112.27,28.15 110.84,28.15 110.75,28.06 109.51,28.06 108.84,28.73 99.54,28.73 93.34,34.94 84.15,34.94 83.99,34.78 76.1,34.78 74.21,32.89 67.27,32.89 66.73,32.35 66.73,31.9 65.89,31.05 62.39,31.05 60.69,29.36 59.95,29.36 59.57,28.98 59.57,28.55 58.98,27.95 58.98,27.2 58.77,26.99 58.68,26.99 57.91,26.22 57.18,26.22 56.12,25.16 53.73,25.16 53.59,25.31 50.41,25.31 48.98,26.74 47.32,26.74 46.58,27.49 45.93,27.49 44.73,28.69 43.34,28.69 43.15,28.88 41.84,28.88 41.59,28.63 40.59,28.63 40.45,28.78 39.52,28.78 38.47,29.82 38.47,30.09 37,31.57 32.16,31.57 31.91,31.32 29.92,31.32 29.04,30.44 29.04,28.16 v2(28.88,28)
  BOTTOM w0.102: CT126.2 29.25,30.96 29.25,29.49 29.12,29.36 29.12,28.24 v2(28.88,28)
PCIE_PTX_TRX_P1: length 213.2
  TOP w0.102: v2(202.46,38.74) 202.25,38.53 201.03,38.53 200.53,38.04 200.27,38.04 199.79,37.56 199.69,37.56 198.09,35.96 196.26,35.96 UH1.B17
  IN1 w0.102: v2(202.46,38.74) 202.46,38.61 202.34,38.49 202.2,38.49 200.05,40.64 200.05,41.57 198.09,43.53 198.09,44.61 197.7,45 197.7,45.7 195.5,47.89 194.97,47.89 193.69,49.17 189.78,49.17 189.54,48.92 188.32,48.92 185.84,51.41 180.59,51.41 179.75,52.25 177.85,52.25 177.47,51.87 172.97,51.87 171.2,50.1 170.11,50.1 165.34,45.33 165.34,44.36 163.18,42.19 162.31,42.19 162.09,41.98 160.97,41.98 153.94,34.94 153.55,34.94 152.72,34.12 146.99,34.12 145.89,35.22 139.27,35.22 137.35,37.14 135.73,37.14 134.9,37.96 133.39,37.96 133.3,38.05 132.82,38.05 132.73,37.96 131.07,37.96 130.98,38.05 130.48,38.05 130.39,37.96 130.3,37.88 130.28,37.88 130.28,37.86 129.76,37.34 129.76,37.19 129.76,37.19 129.76,35.41 129.26,34.92 125.37,34.92 124.21,33.75 124.21,33.13 124.08,33 124.08,32.7 121.68,30.29 121.68,29.83 121.17,29.33 120.84,29.33 120.32,28.81 120.32,28.15 118.56,26.38 117.83,26.38 117.17,25.72 116.15,25.72 115.49,26.38 112.62,26.38 112.4,26.16 111.1,26.16 111.1,26.16 110.74,26.16 110.5,26.16 110.49,26.15 110.15,26.15 110.14,26.17 109.24,26.17 108.22,27.18 106.29,27.18 105.71,26.6 103.93,26.6 103.15,27.38 98.77,27.38 96.64,29.52 92.37,29.52 91,30.88 88.21,30.88 87.62,31.47 84.86,31.47 82.95,33.38 79.69,33.38 79.34,33.04 77.94,33.04 76.15,31.24 74.94,31.24 73.46,29.76 68.08,29.76 66.51,28.2 63.35,28.2 61.12,25.97 60.74,25.97 60.43,25.65 59.24,25.65 58.3,24.71 57.68,24.71 56.66,23.69 55.45,23.69 54.46,22.7 53.96,22.7 53.41,23.26 52.48,23.26 51.84,23.89 50.7,23.89 50.14,23.33 49.15,23.33 48.05,24.44 47.09,24.44 44.98,26.55 42.93,26.55 42.67,26.28 41.23,26.28 41.06,26.12 38.98,26.12 36.72,28.37 36.72,29.2 v2(37.13,29.62)
  BOTTOM w0.102: CT2.2 37.54,30.66 37.54,30.48 36.96,29.89 36.96,29.79 v2(37.13,29.62)
PCIE_PTX_TRX_P2: length 217.5
  TOP w0.102: UH1.C18 195.23,35.08 195.27,35.12 195.39,35.24 195.91,35.24 196.11,35.03 196.6,35.03 197.09,35.52 198.23,35.52 199.52,36.82 201.76,36.82 202.76,37.82 203.24,37.82 203.24,37.82 v2(203.45,38.03)
  IN1 w0.102: v2(203.45,38.03) 202.95,37.53 202.32,37.53 199.3,40.55 199.3,41.34 197.39,43.26 197.39,44.36 197.07,44.67 197.07,45.44 195.26,47.25 194.77,47.25 193.45,48.57 191.59,48.57 190.75,47.73 188.34,47.73 185.86,50.21 183,50.21 182.43,50.78 180.22,50.78 179.37,51.64 178.36,51.64 177.99,51.26 173.73,51.26 173.03,50.56 172.52,50.56 171.43,49.47 170.61,49.47 166.05,44.91 166.05,43.54 165.3,42.78 164.67,42.78 163.44,41.56 162.6,41.56 162.42,41.38 161.24,41.38 154.61,34.75 154.61,34.4 153.64,33.43 146.64,33.43 145.45,34.62 138.81,34.62 136.89,36.54 135.19,36.54 134.79,36.95 130.81,36.95 130.49,36.63 130.49,35.25 129.56,34.32 125.63,34.32 124.97,33.66 124.97,33.04 124.68,32.75 124.68,31.24 119.23,25.78 118.08,25.78 117.41,25.12 115.89,25.12 115.23,25.78 112.99,25.78 112.79,25.58 112.66,25.58 112.64,25.56 108.99,25.56 108.97,25.58 108.92,25.58 108.01,26.49 106.6,26.49 106.09,25.97 102.19,25.97 101.96,26.21 99.52,26.21 99.09,25.77 97.83,25.77 94.79,28.81 92.03,28.81 90.55,30.29 87.87,30.29 87.29,30.87 84.48,30.87 83.31,32.03 80.24,32.03 78.73,30.52 75.21,30.52 73.81,29.12 68.36,29.12 66.77,27.53 64.41,27.53 63.13,26.25 62.25,26.25 61.36,25.36 60.99,25.36 60.68,25.06 59.48,25.06 58.55,24.12 57.98,24.12 56.95,23.09 55.69,23.09 54.71,22.1 53.72,22.1 53.16,22.66 52.23,22.66 51.61,23.28 50.97,23.28 50.41,22.72 48.9,22.72 47.78,23.84 46.84,23.84 45.14,25.54 42.89,25.54 42.77,25.67 41.53,25.67 41.38,25.52 37.86,25.52 35.47,27.91 35.47,28.08 34.77,28.78 34.6,28.78 34.46,28.92 34.46,29.17 v2(34.73,29.43)
  BOTTOM w0.102: v2(34.73,29.43) 34.52,29.63 34.52,30 34.37,30.15 34.37,30.27 CT4.2
PCIE_PTX_TRX_P3: length 208.4
  TOP w0.102: v2(198.53,34.46) 198.36,34.63 198.36,34.87 198.15,35.07 197.32,35.07 196.79,34.55 195.27,34.55 UH1.C19
  IN1 w0.102: v2(32.68,28.31) 32.44,28.08 32.44,27.82 32.66,27.6 33.52,27.6 36.96,24.16 39.04,24.16 39.51,23.69 43.46,23.69 43.93,23.22 44.89,23.22 46.73,21.38 50.35,21.38 50.68,21.05 52.38,21.05 53,20.43 56.7,20.43 58.77,22.5 59.19,22.5 60.4,23.71 61.24,23.71 61.24,23.72 61.25,23.72 61.56,24.02 62.89,24.02 63.68,24.8 66.29,24.8 66.36,24.87 67.92,24.87 67.93,24.88 70.01,24.88 72.48,27.36 74.99,27.36 76.38,28.74 79.43,28.74 79.85,29.16 80.33,29.16 80.57,28.92 80.59,28.92 80.75,28.75 80.83,28.75 80.84,28.74 82.77,28.74 83.05,29.02 86.59,29.02 87.52,28.09 89.93,28.09 90.01,28.01 90.78,28.01 92.73,26.06 95.34,26.06 97,24.41 103.28,24.41 103.71,23.99 105.25,23.99 105.92,23.32 111.98,23.32 112.42,23.76 113.06,23.76 113.33,24.03 115.05,24.03 115.84,23.24 117.33,23.24 117.46,23.11 119.94,23.11 122.57,25.74 123.53,25.74 125.23,27.44 125.23,29.72 127.88,32.37 129.14,32.37 129.48,32.71 131.01,32.71 132.13,33.84 135.19,33.84 136.4,32.62 138.22,32.62 138.55,32.3 145.1,32.3 145.31,32.09 154.22,32.09 155.97,33.84 155.97,34.2 161.27,39.5 163.84,39.5 164.93,40.6 165.6,40.6 166.49,41.49 167.08,41.49 167.66,42.07 167.66,43.03 168.56,43.93 169.23,43.93 172.15,46.85 172.15,47.64 172.98,48.47 176.88,48.47 177.48,47.87 183.71,47.87 185.23,46.35 191.31,46.35 192.05,47.1 192.91,47.1 193.62,46.39 193.62,44.43 195.45,42.6 195.45,42.01 195.27,41.83 195.27,41.24 195.85,40.66 195.85,38.31 198.3,35.85 198.3,34.69 v2(198.53,34.46)
  BOTTOM w0.102: v2(32.68,28.31) 32.44,28.55 32.44,29.05 31.89,29.6 31.89,30.02 CT123.2
PCIE_PTX_TRX_P4: length 233.8
  TOP w0.102: v2(201.15,35.1) 201.3,34.95 201.3,34.75 201.23,34.68 199.5,34.68 198.82,34 195.9,34 195.64,33.73 195.11,33.73 UH1.C20
  IN1 w0.102: v2(29.54,28) 29.46,28 29.23,28.24 29.23,30.36 30,31.13 31.99,31.13 32.24,31.38 36.92,31.38 38.28,30.01 38.28,29.74 39.44,28.59 40.37,28.59 40.51,28.45 41.66,28.45 41.91,28.7 43.07,28.7 43.27,28.5 44.65,28.5 45.86,27.3 46.5,27.3 47.25,26.55 48.91,26.55 50.34,25.12 53.51,25.12 53.66,24.98 56.2,24.98 57.26,26.03 57.99,26.03 58.76,26.81 58.85,26.81 59.17,27.12 59.17,27.87 59.76,28.47 59.76,28.9 60.03,29.17 60.77,29.17 62.47,30.87 65.97,30.87 66.92,31.82 66.92,32.27 67.35,32.7 74.28,32.7 76.18,34.6 84.07,34.6 84.22,34.75 93.26,34.75 99.47,28.54 108.76,28.54 109.43,27.88 110.83,27.88 110.92,27.96 112.2,27.96 112.6,27.56 117.09,27.56 122.02,32.48 122.02,32.86 122.46,33.3 122.46,34.14 122.8,34.48 123.29,34.48 124.88,36.07 126.69,36.07 129.86,39.23 135.39,39.23 136.2,38.42 137.98,38.42 138.97,37.43 144.14,37.43 145.15,36.42 148.85,36.42 150,35.27 151.63,35.27 153.15,36.78 154.12,36.78 160.47,43.13 161.5,43.13 161.78,43.42 162.38,43.42 162.98,44.02 162.98,44.69 167.64,49.34 169.83,51.53 170.93,51.53 173.41,54.01 181.28,54.01 181.61,53.68 184.93,53.68 185.85,54.6 193.05,54.6 194.26,53.4 194.26,52.69 195.83,51.12 196.27,51.12 196.8,50.59 196.8,49.76 196.47,49.43 196.47,48.73 199.24,45.97 199.24,45.15 199.7,44.69 199.7,44.2 200.32,43.57 200.78,43.57 205.33,39.03 205.33,36.92 204.58,36.17 203.05,36.17 201.55,34.67 200.97,34.67 200.83,34.81 200.83,35 200.93,35.1 v2(201.15,35.1)
  BOTTOM w0.102: CT125.2 29.44,30.96 29.44,29.41 29.31,29.28 29.31,28.24 v2(29.54,28)
PCIE_WAKE#: length 609.5
  TOP w0.109: RE274.1 126.81,20.32 126.69,20.21 124.73,20.21 124.25,19.73 v2(124.25,19.31) ; RT448.1 40.75,44.27 40.13,43.65 v2(40.01,43.65) ; v2(82.8,35.87) 84.38,34.29 84.38,30.1 84.27,29.98 84.27,29.39 83.34,28.46 83.34,25.69 83.54,25.5 83.54,23.07 83.1,22.63 83.1,19.25 83.29,19.05 83.29,13.52 82.17,12.4 82.17,11.69 v1(82.37,11.49) 82.66,11.2 v2(82.66,10.9) ; v2(143.27,15.92) 143.09,16.1 141.82,16.1 RE275.1 ; v2(315.66,6.99) 315.66,3.87 v2(314.63,2.84) 313.01,1.22 293.19,1.22 292.74,1.68 292.74,2.24 293.41,2.92 v2(293.41,2.97) ; v2(162.01,53.29) 162.01,54.34 163.1,55.43 163.1,55.93 179.79,72.63 179.79,74.85 179.55,75.09 179.55,76.9 178.89,77.57 178.89,82.14 177.42,83.61 176.72,83.61 176.47,83.36 JDGFF1.E2
  IN1 w0.102: v2(188.61,17.44) 189.29,17.44 189.46,17.61 189.46,18.23 189.58,18.35 190.06,18.35 192.5,15.91 200.65,15.91 201.51,15.05 210.73,15.05 211.41,14.36 217.99,14.36 219.18,15.55 230.77,15.55 231.27,15.05 241.19,15.05 242.15,16 243.41,16 244.42,14.99 254.41,14.99 256.12,13.27 256.12,11.04 255.44,10.36 255.44,7.95 256.28,7.12 257.32,7.12 261.64,2.8 273.87,2.8 274.41,2.26 279.7,2.26 281.27,3.82 282.31,3.82 283.12,3.01 285.26,3.01 286.29,1.98 291.24,1.98 292.52,3.26 293.14,3.26 293.41,2.99 v2(293.41,2.97)
  IN2 w0.081: v2(188.61,17.44) 187.4,17.44 186.96,17.88 185.84,17.88 185.72,18.01 184.75,18.01 184.57,18.18 183.75,18.18 183.13,17.56 182.27,17.56 181.97,17.87 181.97,18.55 182.23,18.81 182.68,18.81 183.16,19.29 183.16,19.86 182.77,20.25 179.14,20.25 178.72,19.83 178.72,18.36 177.56,17.2 170.97,17.2 169.67,15.91 166.25,15.91 165.57,16.58 165.57,17.23 163.66,19.15 159.78,19.15 158.52,20.41 157.66,20.41 157.54,20.29 156.25,20.29 155.27,21.26 152.2,21.26 150.98,20.04 149.85,20.04 149.46,19.65 147.31,19.65 145.63,17.96 144.71,17.96 143.33,16.58 143.33,15.98 v2(143.27,15.92) 141.64,15.92 139.51,13.79 137.19,13.79 136.81,13.41 133.34,13.41 133.26,13.49 130.5,13.49 129.88,12.86 128.66,12.86 127.99,13.53 127.01,13.53 v2(126.61,13.13) ; JNGFF4.54 349.65,7.76 349.22,8.19 347.48,8.19 346.99,8.68 340.79,8.68 340.42,9.05 334.7,9.05 334.68,9.03 329.3,9.03 328.82,8.56 327.26,8.56 325.72,7.01 325.72,5.64 323.48,3.4 315.19,3.4 v2(314.63,2.84) ; v2(331.71,11.6) 331.56,11.75 327.92,11.75 324.67,8.49 323.45,8.49 321.67,6.71 318.16,6.71 317.88,6.99 v2(315.66,6.99)
  IN3 w0.081: v2(303.36,11.38) 303.91,11.92 305.82,11.92 306.87,10.87 307.73,10.87 308.09,10.51 308.68,10.51 309.96,9.24 312.83,9.24 313.9,8.17 314.47,8.17 v2(315.66,6.99) ; v2(92.83,41.76) 92.39,41.32 91.62,41.32 91.01,40.71 88.38,40.71 87.97,40.3 84.81,40.3 84.43,39.92 81.74,39.92 79.95,41.71 76.86,41.71 75.21,43.36 71.69,43.36 70.33,42 69.74,42 66.93,39.2 66.93,38.89 66.7,38.66 66.37,38.66 66.24,38.8 58.12,38.8 57.42,38.09 56.31,38.09 55.96,38.44 53.73,38.44 53.44,38.74 49.86,38.74 49.24,38.11 46.87,38.11 46.57,37.82 46.24,37.82 44.97,39.1 44.32,39.1 44.04,39.38 44.04,40.26 40.64,43.65 v2(40.01,43.65)
  IN4 w0.102: v2(124.25,19.31) 124.25,16.62 126.61,14.26 v2(126.61,13.13)
  BOTTOM w0.109: v2(82.8,35.87) 82.81,35.87 82.89,35.95 JNGFF3.54 84.67,35.95 84.95,35.67 85.42,35.67 85.6,35.84 85.6,38.17 86.4,38.97 90.03,38.97 v2(92.83,41.76) 93.14,42.08 93.14,43.74 90.59,46.3 90.59,50.32 90.93,50.66 94.35,50.66 94.81,50.2 110.07,50.2 110.52,50.65 115.48,50.65 117.23,48.9 117.23,47.52 119.87,44.88 122.95,44.88 127.62,49.56 151.28,49.56 151.6,49.87 154.73,49.87 159.02,54.16 161.14,54.16 v2(162.01,53.29) ; JNGFF1.47 330.4,11.09 330.91,11.6 v2(331.71,11.6) ; v2(303.36,11.38) 302.75,10.76 JNGFF2.46 ; v2(82.66,10.9) JNGFF5.54 84.58,10.9 85.27,11.6 92.34,11.6 93.71,12.96 109.18,12.96 109.67,13.45 117.04,13.45 117.79,12.71 117.79,11.1 116.51,9.82 115.19,8.5 114.86,8.5 114.77,8.41 114.77,6.41 115.37,5.81 120.39,5.81 120.86,6.29 120.86,7.09 120.61,7.35 120.61,8.48 121.35,9.22 122.87,9.22 123.94,10.29 124.72,10.29 126.61,12.18 v2(126.61,13.13)
PCIE_WAKE#_AR: length 19.4
  TOP w0.109: RT622.2 37.18,51.01 v2(37.18,51.29) 37.18,51.8 37.37,51.99 39.79,51.99 41.08,50.69 RT441.2 ; v1(38.08,48.48) 38.28,48.28 v2(38.28,47.73)
  IN1 w0.102: v2(38.28,47.73) 38.28,48.07 37.9,48.44 37.9,50.57 v2(37.18,51.29)
  BOTTOM w0.089: 34.89,43.86 34.89,43.44 UT1.Y2
  BOTTOM w0.109: v2(38.28,47.73) 38.84,47.73 39.26,47.31 39.26,46.02 38.2,44.97 38.2,44.95 38.03,44.77 RT613.1 38.01,44.76 36.87,44.76 36.78,44.85 35.64,44.85 34.89,44.11 34.89,43.86
PCIE_WAKE#_AR_R: length 3.3
  TOP w0.109: v1(41.98,49.85) 41.76,50.07 RT441.1 40.5,50.07 RT440.2 40.49,49.7 40.56,49.64 UT32.4
PCIE_WAKE#_R: length 5
  TOP w0.102: 139.53,19.62 UE1.N13
  TOP w0.109: v1(142.61,16.77) 142.2,17.17 RE275.2 RE35.1 140.79,18.36 139.53,19.62
PCIECOMP: length 6.1
  TOP w0.089: 199.87,39.72 199.55,39.72 199.4,39.57 199.4,38.89 198.93,38.42 198.93,37.85 v1(198.58,37.49) 198.36,37.28 196.46,37.28 UH1.A13
  TOP w0.109: RH192.1 200.06,39.72 199.87,39.72
PCIECOMP#: length 6.5
  TOP w0.089: UH1.B12 195.8,37.7 196.61,37.7 196.74,37.56 198.21,37.56 198.75,38.1 198.75,38.7 v1(199.01,38.95) 199.21,39.15 199.21,39.65 199.47,39.91 200.03,39.91 RH192.2
PD#: length 13.8
  TOP w0.203: UA1.2 341.68,25.03 341.36,25.36 RA18.2
  TOP w0.254: RA50.2 CA31.2 ; CA31.2 338.38,24.89 338.11,24.62 337.12,24.62 335.9,23.4 335.9,21.83 336.06,21.67 v1(336.06,20.92) 336.25,20.73 RA48.2 337.85,20.73 DA8.2 ; CA31.2 338.83,25.39 338.87,25.35 340.15,25.35 340.16,25.36 RA18.2
PECI_EC_R: length 6
  TOP w0.109: UE1.K13 140.21,22.05 140.53,22.37 140.97,22.37 141.72,23.12 142.45,23.12 142.83,23.51 v1(143.7,23.51) 143.98,23.23 144.79,23.23 RE60.1
PEG_COMP: length 5.9
  TOP w0.076: v2(222.87,88.56) 222.55,88.24 UC1.G2
  BOTTOM w0.109: 222.43,88.12 221.86,88.12 221.5,87.76 221.5,87.5
  BOTTOM w0.127: 221.5,87.5 221.5,86.39 221.49,86.37 v1(221.49,85.15) RC2.2 ; v2(222.87,88.56) 222.43,88.12
PEG_CRX_C_GTX_N0: length 18.6
  TOP w0.102: JDGFF2.C8 172.87,102.3 173.07,102.49 173.07,102.75 v2(172.88,102.94)
  IN4 w0.102: v2(172.88,102.94) 173.02,102.8 173.02,102.45 173.53,101.93 177.96,101.93 178.94,100.96 179.79,100.96 180.85,99.9 180.85,97.96 181.52,97.29 182.24,97.29 v2(182.33,97.2)
  BOTTOM w0.102: CV428.1 185.57,96.58 v4(184.38,96.58) 183.22,96.58 182.76,97.04 182.76,97.33 182.65,97.44 182.58,97.44 v2(182.33,97.2)
PEG_CRX_C_GTX_N1: length 25.2
  TOP w0.102: v2(171.49,103.15) 171.69,103.15 171.79,103.25 171.79,103.55 172.05,103.8 172.36,103.8 172.46,103.9 172.46,104.02 172.27,104.21 JDGFF2.B9
  BOTTOM w0.102: v2(171.49,103.15) 171.62,103.01 171.76,103.01 171.87,103.12 171.86,103.55 171.86,104.1 171.65,104.31 v4(171.38,104.31) 171.11,104.31 170.85,104.05 170.85,103.09 171.86,102.08 171.86,101.29 171.79,101.23 171.79,98.66 173.04,97.42 175.9,97.42 177.47,98.99 178.09,98.99 178.13,99.03 178.87,99.03 179.28,99.44 180.43,99.44 180.66,99.2 182.56,99.2 182.97,98.8 182.97,98.3 183.23,98.05 183.62,98.05 183.73,98.16 183.73,98.33 CV430.1
PEG_CRX_C_GTX_N2: length 14.2
  TOP w0.102: v2(174.67,103.01) 174.88,102.8 174.88,102.54 174.67,102.33 JDGFF2.C5
  BOTTOM w0.102: CV432.1 185.58,99.12 185.03,99.12 184.88,99.27 183.08,99.27 182.7,99.65 v4(181.88,99.65) 180.97,99.65 179.91,100.7 178.86,100.7 178.08,101.48 177.29,101.48 176.54,102.23 175.79,102.23 175.64,102.38 175.1,102.38 174.87,102.61 174.87,102.81 v2(174.67,103.01)
PEG_CRX_C_GTX_N3: length 12.5
  TOP w0.102: JDGFF2.B6 174.07,104.23 174.27,104.03 174.27,103.92 v2(173.99,103.64)
  BOTTOM w0.102: v2(173.99,103.64) 174.15,103.8 174.15,104.03 174.43,104.3 175.71,104.3 177.6,102.42 178.26,102.42 179.19,101.49 179.32,101.49 179.36,101.53 179.96,101.53 180,101.49 180.54,101.49 181.34,100.69 183.08,100.69 CV434.1
PEG_CRX_C_GTX_N4: length 12.8
  TOP w0.102: JDGFF2.B3 175.87,104.23 176.1,104.01 176.1,103.78 176.46,103.41 178.53,103.41 178.59,103.35 178.59,103.16 v2(178.36,102.93)
  BOTTOM w0.102: CV436.1 185.61,101.8 184.98,101.8 184.88,101.9 v4(182.15,101.9) 181.37,101.9 179.67,103.6 178.8,103.6 178.55,103.36 178.55,103.12 v2(178.36,102.93)
PEG_CRX_C_GTX_N5: length 15.7
  TOP w0.102: v2(172.38,106.82) 172.64,106.57 172.64,106.35 173.07,105.92 173.07,105.79 172.87,105.59 JDGFF2.A8
  BOTTOM w0.102: v2(172.38,106.82) 172.55,106.99 172.55,107.33 172.77,107.56 173.17,107.56 173.75,106.98 173.75,106.26 174.94,105.07 175.99,105.07 176.86,104.2 180.18,104.2 180.22,104.24 180.83,104.24 180.87,104.2 181.38,104.2 182.44,103.14 183.09,103.14 CV438.1
PEG_CRX_C_GTX_N6: length 14.3
  TOP w0.102: JDGFF2.A5 174.67,105.69 174.91,105.93 174.91,106.48 v2(174.68,106.71)
  BOTTOM w0.102: v2(174.68,106.71) 174.83,106.56 174.83,106.1 175.45,105.48 176.2,105.48 177.02,104.66 182,104.66 182.53,104.13 184.81,104.13 184.99,103.95 185.65,103.95 CV440.1
PEG_CRX_C_GTX_N7: length 10.5
  TOP w0.102: v2(175.98,107.01) 176.32,106.67 176.32,106.32 176.65,105.99 176.65,105.76 176.47,105.58 JDGFF2.A2
  BOTTOM w0.102: CV442.1 183.07,105.31 179.62,105.31 179.58,105.27 178.96,105.27 178.92,105.31 177.24,105.31 176.48,106.07 176.48,106.23 176.16,106.55 176.16,106.83 v2(175.98,107.01)
PEG_CRX_C_GTX_N8: length 16
  TOP w0.102: v2(172.76,109.11) 173.05,109.4 173.05,109.7 172.87,109.88 JDGFF3.H8
  BOTTOM w0.102: v2(172.76,109.11) 172.96,108.91 172.96,108.38 173.92,107.42 179.18,107.42 180.07,106.53 181.49,106.53 181.52,106.49 182.11,106.49 182.14,106.53 185.62,106.53 CV444.1
PEG_CRX_C_GTX_N9: length 11.4
  TOP w0.102: JDGFF3.H5 174.67,109.82 174.86,109.63 174.86,109.32 174.82,109.29 v2(174.59,109.05)
  BOTTOM w0.102: v2(174.59,109.05) 174.74,108.9 174.74,108.4 175.12,108.02 179.47,108.02 179.74,108.29 179.92,108.29 179.96,108.25 180.67,108.25 180.71,108.29 182.03,108.29 182.58,107.74 183.08,107.74 CV446.1
PEG_CRX_C_GTX_N10: length 13.4
  TOP w0.102: JDGFF3.H2 176.47,109.99 176.66,109.8 176.66,109.62 176.25,109.21 176.25,108.96 v2(175.96,108.67)
  BOTTOM w0.102: v2(175.96,108.67) 176.1,108.81 176.1,109.2 177.19,110.28 179,110.28 179.52,109.76 180.98,109.76 181.01,109.79 181.6,109.79 181.64,109.76 182.49,109.76 182.97,109.28 185.54,109.28 CV448.1
PEG_CRX_C_GTX_N11: length 11.9
  TOP w0.102: v2(173.97,112.2) 174.32,111.86 174.32,111.62 174.07,111.37 JDGFF3.G6
  BOTTOM w0.102: v2(173.97,112.2) 174.19,111.98 174.19,111.53 175.02,110.7 v4(175.57,110.7) 179.25,110.7 179.69,110.27 183.03,110.27 CV450.1
PEG_CRX_C_GTX_N12: length 12.4
  TOP w0.102: v2(175.88,111.95) 176.09,111.74 176.09,111.59 175.87,111.37 JDGFF3.G3
  BOTTOM w0.102: CV452.1 185.63,112.03 185.2,112.03 184.95,111.78 182.87,111.78 182.39,111.31 v4(181.07,111.31) 180.16,111.31 179.53,111.94 178.51,111.94 177.88,112.58 176.2,112.58 176.03,112.4 176.03,112.1 v2(175.88,111.95)
PEG_CRX_C_GTX_N13: length 13.7
  TOP w0.102: v2(172.24,112.27) 172.51,112.01 172.51,111.64 172.27,111.41 JDGFF3.G9
  BOTTOM w0.102: v2(172.24,112.27) 172.4,112.43 172.4,112.76 172.84,113.2 173.61,113.2 174.18,113.06 175.02,113.07 175.18,113.2 178.11,113.2 178.77,112.54 181.85,112.54 182.4,113.1 183.06,113.1 CV454.1
PEG_CRX_C_GTX_N14: length 15.4
  TOP w0.102: JDGFF3.F5 174.67,113.28 174.87,113.08 174.87,112.78 175.1,112.55 177.42,112.55 179.08,114.2 179.08,114.5 v2(179.28,114.7)
  BOTTOM w0.102: v2(179.28,114.7) 179,114.7 178.85,114.86 178.85,115.49 179.13,115.77 180.25,115.77 180.9,115.11 180.9,115.06 181.31,114.65 181.37,114.65 181.88,114.13 184.78,114.13 184.9,114.25 185.29,114.25 CV456.1
PEG_CRX_C_GTX_N15: length 25.3
  TOP w0.102: v2(170.93,111.99) 171.22,112.28 171.22,112.7 171.48,112.97 173.01,112.97 173.07,113.03 173.07,113.12 172.87,113.33 JDGFF3.F8
  BOTTOM w0.102: v2(170.93,111.99) 171.07,112.13 171.07,112.51 170.9,112.68 170.2,112.68 169.79,113.1 169.79,117.24 170.41,117.86 171.82,117.86 172.43,118.47 175.96,118.47 177.89,116.54 178.44,116.54 178.63,116.74 179.1,116.74 179.15,116.79 179.73,116.79 179.78,116.74 180.44,116.74 181.61,115.57 183.07,115.57 183.08,115.59 183.09,115.59 CV458.1
PEG_CRX_C_GTX_P0: length 18.6
  TOP w0.102: v2(173.47,102.94) 173.26,102.73 173.26,102.49 173.47,102.28 JDGFF2.C7
  IN4 w0.102: v2(182.33,97.86) 182.33,97.77 182.04,97.48 181.6,97.48 181.04,98.04 181.04,99.98 179.87,101.15 179.02,101.15 178.04,102.12 173.61,102.12 173.21,102.52 173.21,102.75 173.39,102.94 v2(173.47,102.94)
  BOTTOM w0.102: v2(182.33,97.86) 182.56,97.63 182.73,97.63 182.95,97.41 182.95,97.12 183.3,96.77 183.99,96.77 184.03,96.81 184.69,96.81 184.72,96.77 185.58,96.77 CV427.1
PEG_CRX_C_GTX_P1: length 25.2
  TOP w0.102: JDGFF2.B8 172.87,104.25 172.65,104.03 172.65,103.82 172.44,103.61 172.12,103.61 171.99,103.47 171.99,103.22 172.05,103.16 v2(172.26,103.16)
  BOTTOM w0.102: CV429.1 183.31,97.86 183.15,97.86 182.78,98.23 182.78,98.72 182.49,99.01 180.58,99.01 180.35,99.25 179.36,99.25 178.91,98.8 v4(178.42,98.8) 177.55,98.8 175.98,97.23 172.96,97.23 171.6,98.59 171.6,101.31 171.67,101.37 171.67,102 170.66,103.01 170.66,104.13 171.08,104.55 171.69,104.55 172.05,104.18 172.05,103.55 172.05,103.36 v2(172.26,103.16)
PEG_CRX_C_GTX_P2: length 14.3
  TOP w0.102: JDGFF2.C4 175.27,102.33 175.07,102.53 175.07,102.73 175.35,103.01 v2(175.42,103.01)
  BOTTOM w0.102: CV431.1 185.56,99.32 185.11,99.32 184.96,99.46 183.16,99.46 182.78,99.84 182.21,99.84 182.17,99.87 181.57,99.87 181.53,99.84 181.05,99.84 179.99,100.89 178.94,100.89 178.12,101.71 v4(177.74,101.71) 177.33,101.71 176.62,102.42 175.87,102.42 175.72,102.57 175.18,102.57 175.06,102.69 175.06,102.88 175.19,103.01 v2(175.42,103.01)
PEG_CRX_C_GTX_P3: length 12.4
  TOP w0.102: v2(174.73,103.64) 174.46,103.9 174.46,104.02 174.67,104.22 JDGFF2.B5
  BOTTOM w0.102: CV433.1 182.98,100.5 181.26,100.5 180.46,101.3 v4(179.67,101.3) 179.11,101.3 178.18,102.23 177.52,102.23 176.89,102.86 175.63,104.11 174.5,104.11 174.34,103.95 174.34,103.77 174.48,103.64 v2(174.73,103.64)
PEG_CRX_C_GTX_P4: length 12.8
  TOP w0.102: JDGFF2.B2 176.47,104.19 176.29,104.01 176.29,103.86 176.54,103.6 178.61,103.6 178.78,103.43 178.78,103.3 v2(179.12,102.97)
  BOTTOM w0.102: CV435.1 185.53,101.61 184.9,101.61 184.8,101.71 182.48,101.71 182.44,101.67 181.85,101.67 181.81,101.71 181.29,101.71 179.59,103.41 178.87,103.41 178.74,103.28 178.74,103.01 178.87,102.89 179.04,102.89 v2(179.12,102.97)
PEG_CRX_C_GTX_P5: length 15.7
  TOP w0.102: v2(173.1,106.82) 172.83,106.56 172.83,106.43 173.26,106 173.26,105.75 173.47,105.54 JDGFF2.A7
  BOTTOM w0.102: CV437.1 182.98,102.95 182.36,102.95 181.3,104.01 v4(180.52,104.01) 176.78,104.01 175.91,104.88 174.86,104.88 173.56,106.18 173.56,106.9 173.09,107.37 172.85,107.37 172.74,107.25 172.74,106.93 172.85,106.82 v2(173.1,106.82)
PEG_CRX_C_GTX_P6: length 14.3
  TOP w0.102: v2(175.39,106.71) 175.1,106.42 175.1,105.91 175.27,105.74 JDGFF2.A4
  BOTTOM w0.102: v2(175.39,106.71) 175.18,106.71 175.02,106.55 175.02,106.18 175.53,105.67 176.28,105.67 177.1,104.85 182.13,104.85 v4(182.38,104.61) 182.67,104.32 184.89,104.32 185.07,104.14 185.5,104.14 CV439.1
PEG_CRX_C_GTX_P7: length 10.5
  TOP w0.102: v2(176.79,107.02) 176.51,106.74 176.51,106.39 176.84,106.07 176.84,105.82 177.07,105.59 JDGFF2.A1
  BOTTOM w0.102: v2(176.79,107.02) 176.57,107.02 176.35,106.81 176.35,106.63 176.67,106.31 176.67,106.15 177.32,105.5 v4(179.28,105.5) 182.99,105.5 CV441.1
PEG_CRX_C_GTX_P8: length 16
  TOP w0.102: v2(173.53,109.11) 173.24,109.41 173.24,109.7 173.47,109.93 JDGFF3.H7
  BOTTOM w0.102: v2(173.53,109.11) 173.27,109.11 173.15,109 173.15,108.46 173.99,107.61 179.25,107.61 180.15,106.72 v4(181.82,106.72) 185.48,106.72 CV443.1
PEG_CRX_C_GTX_P9: length 11.4
  TOP w0.102: v2(175.39,109.02) 175.05,109.36 175.05,109.62 175.27,109.84 JDGFF3.H4
  BOTTOM w0.102: v2(175.39,109.02) 175.13,109.02 174.93,108.82 174.93,108.48 175.2,108.21 179.39,108.21 179.66,108.48 v4(180.29,108.48) 182.11,108.48 182.66,107.93 182.98,107.93 CV445.1
PEG_CRX_C_GTX_P10: length 13.3
  TOP w0.102: v2(176.74,108.67) 176.44,108.95 176.44,109.14 176.85,109.54 176.85,109.77 177.07,109.99 JDGFF3.H1
  BOTTOM w0.102: v2(176.74,108.67) 176.45,108.67 176.29,108.82 176.29,109.12 177.26,110.09 178.92,110.09 179.44,109.57 v4(181.31,109.57) 182.41,109.57 182.89,109.09 185.59,109.09 CV447.1
PEG_CRX_C_GTX_P11: length 11.9
  TOP w0.102: v2(174.83,112.23) 174.51,111.92 174.51,111.54 174.51,111.54 174.67,111.38 JDGFF3.G5
  BOTTOM w0.102: v2(174.83,112.23) 174.46,112.23 174.38,112.15 174.38,111.61 175.1,110.89 175.24,110.89 175.27,110.93 175.86,110.93 175.9,110.89 179.38,110.89 v4(179.63,110.65) 179.82,110.46 183.04,110.46 CV449.1
PEG_CRX_C_GTX_P12: length 12.4
  TOP w0.102: v2(176.58,111.95) 176.28,111.66 176.28,111.54 176.47,111.35 JDGFF3.G2
  BOTTOM w0.102: v2(176.58,111.95) 176.36,111.95 176.22,112.09 176.22,112.32 176.28,112.39 177.8,112.39 178.43,111.75 179.45,111.75 180.08,111.12 180.74,111.12 180.77,111.08 181.36,111.08 181.4,111.12 182.47,111.12 182.94,111.59 185.03,111.59 185.28,111.84 185.51,111.84 CV451.1
PEG_CRX_C_GTX_P13: length 13.7
  TOP w0.102: JDGFF3.G8 172.87,111.4 172.7,111.57 172.7,111.95 v2(173.03,112.28)
  BOTTOM w0.102: CV453.1 183.03,112.9 182.54,112.9 v4(182.27,112.64) 181.98,112.35 178.69,112.35 178.03,113.01 175.25,113.01 175.08,112.88 174.16,112.87 173.59,113.01 172.92,113.01 172.59,112.68 172.59,112.4 172.71,112.28 v2(173.03,112.28)
PEG_CRX_C_GTX_P14: length 15.4
  TOP w0.102: JDGFF3.F4 175.27,113.36 175.06,113.15 175.06,112.86 175.18,112.74 177.34,112.74 178.89,114.28 178.89,114.86 178.83,114.91 178.69,114.91 v2(178.48,114.7)
  BOTTOM w0.102: v2(178.48,114.7) 178.66,114.88 178.66,115.57 179.05,115.96 180.32,115.96 v4(181.27,115.02) 181.96,114.32 184.7,114.32 184.82,114.44 185.4,114.44 CV455.1
PEG_CRX_C_GTX_P15: length 25.2
  TOP w0.102: JDGFF3.F7 173.47,113.32 173.27,113.11 173.27,112.95 173.09,112.77 171.56,112.77 171.41,112.62 171.41,112.26 v2(171.68,111.99)
  BOTTOM w0.102: v2(171.68,111.99) 171.43,111.99 171.26,112.16 171.26,112.59 170.98,112.87 170.28,112.87 169.98,113.17 169.98,117.16 170.49,117.67 171.9,117.67 172.51,118.28 175.88,118.28 177.81,116.35 178.51,116.35 178.71,116.55 v4(179.44,116.55) 180.36,116.55 181.53,115.38 182.99,115.38 CV457.1
PEG_CRX_GTX_N0: length 38.4
  TOP w0.102: v2(220.81,93.07) 221.14,93.4 UC1.E10
  BOTTOM w0.076: v2(220.81,93.07) 220.81,92.83 220.71,92.73 220.53,92.73 220.45,92.82 220.45,93.27 220.4,93.32 218.74,93.32 218.21,93.84 217.6,93.84 217.58,93.82 217.56,93.82
  BOTTOM w0.102: CV428.2 186.86,96.58 187.67,96.58 188.39,95.86 190.88,95.86 192.33,94.42 v4(193.11,94.42) 194.19,94.42 194.71,94.94 195.61,94.94 195.65,94.9 196.23,94.9 196.27,94.94 196.52,94.94 197.03,94.43 200.01,94.43 200.88,95.3 206.82,95.3 207.44,94.68 207.7,94.43 214.75,94.43 215.36,93.82 217.56,93.82
