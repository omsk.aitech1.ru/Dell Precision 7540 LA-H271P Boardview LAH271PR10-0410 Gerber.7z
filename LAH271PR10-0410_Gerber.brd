# Allegro board LAH271PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SW_TBT_B_USB20_P2_R: length 10.4
  TOP w0.102: JUSBC1.1A6 7.55,63.48 7.55,63.47 7.78,63.47 7.97,63.29 8.17,63.29 8.41,63.05 9.96,63.05 11.06,61.94 11.12,61.94 11.47,61.59 11.47,61.53 12.72,60.29 v4(12.72,59.97) 12.72,59.63 13.15,59.19 DT12.7 DT12.4 13.15,57.22 13.05,57.12 RT541.1
SYS_PWROK: length 267.5
  TOP w0.089: v2(174.86,47.16) 175.74,47.16 177.06,45.84 177.06,45.68 177.07,45.67 177.07,45.63 178.12,44.57 178.12,43.92 178.4,43.64 178.4,43.02 178.43,42.99 178.43,42.48 178.65,42.26 UH1.AU3
  TOP w0.102: UE1.G4 v2(131.93,24.85)
  IN3 w0.081: v2(183.19,81.87) 182.61,81.87 179.36,78.62 179.36,77.46 178.64,76.75 178.64,75.72 179.6,74.77 179.6,71.72 177.32,69.44 177.32,67.52 161.54,51.74 161.06,51.74 v2(160.77,52.03)
  IN4 w0.102: v2(183.19,81.87) 183.19,81.57 185.03,79.74 185.03,76.24 185.7,75.57 186.57,75.57 186.95,75.95 v2(190.07,75.95)
  BOTTOM w0.102: v2(131.93,24.85) 131.55,25.23 130.75,25.23 130.58,25.06 RE548.2
  BOTTOM w0.109: RE548.2 130.07,25.29 129.87,25.49 129.36,25.49 129.16,25.29 RE548.1 129.15,25.06 RE56.1 127.19,26.21 126.55,26.21 126.11,26.65 126.11,30.3 124.14,32.26 122.95,32.26 122,33.21 122,34.61 122.43,35.04 124.91,35.04 125.76,35.89 125.76,36.47 126.51,37.22 126.51,38.39 126.48,38.42 126.48,39.16 126.65,39.59 126.65,45.49 127.52,46.36 128.24,46.36 129.79,47.91 135.09,47.91 135.64,47.36 137.9,47.36 138.25,47 139.05,47 v3(140.08,48.03) 141.13,49.08 151.48,49.08 151.8,49.4 154.94,49.4 158.06,52.52 160.27,52.52 v2(160.77,52.03) ; v2(174.86,47.16) 175.75,47.16 RH199.1 176.34,48.59 176.34,50.84 177.99,52.49 177.99,53.11 180.66,55.78 180.66,57.95 188.03,65.32 188.03,69.95 190.07,71.99 v2(190.07,75.95) 190.08,75.96 190.69,75.96 190.94,76.21 190.94,77.22 192.94,79.22 192.94,79.89 194.86,81.81 197.4,81.81 198.5,82.91 204.58,82.91 211.15,76.33 255.18,76.33 255.82,75.7 272.4,75.7 276.53,79.82 277.55,79.82 278.79,81.07 278.79,81.9 278.18,82.51 278.18,83.33 RC129.1
SYS_PWROK_R: length 166.5
  TOP w0.109: v2(200.72,65.76) 201.37,65.76 202.31,64.83 211.16,64.83 215.95,69.62 235.35,69.62 239.24,65.73 247.98,65.73 248.85,66.59 250.15,66.59 v1(252.92,69.36) 254.4,70.85 267.44,70.85 273.31,64.98 277.78,64.98 278.27,65.47 278.27,67.1 279.06,67.89 280.19,67.89 282.02,66.06 v2(282.02,65.63) ; JXDP1.47 284.04,93.05 v2(283.81,92.82)
  IN1 w0.102: v2(200.72,65.76) 200.29,65.34 193.02,65.34 v2(192.19,66.17)
  IN2 w0.081: v2(192.19,66.17) 192.03,66.33 190.95,66.33 190.18,67.1 185.28,67.1 184.56,66.38 v2(181.54,66.38)
  IN4 w0.102: v2(282.02,65.63) 282.02,67.97 283.15,69.1 283.15,71.21 282.2,72.16 282.2,75.27 278.63,78.84 278.63,84.13 277.91,84.85 v2(277.91,85.43)
  BOTTOM w0.109: RC133.2 RC129.2 279.57,84.26 CC33.1 ; CC33.1 280.08,85.74 280.69,85.74 281.74,86.79 281.74,89.03 282.49,89.78 284.01,89.78 284.32,90.09 284.32,92.31 v2(283.81,92.82) ; CC33.1 278.6,84.74 v2(277.91,85.43) ; RC128.2 168.74,64.07 170.34,65.67 180.84,65.67 v2(181.54,66.38)
SYS_RESET#: length 244
  TOP w0.089: v2(174.38,49.97) 174.91,49.45 175.25,49.45 175.44,49.25 175.44,48.23 CC302.1 177.24,46.44 177.24,45.76 177.25,45.74 177.25,45.7 178.33,44.62 178.33,43.99 178.59,43.73 178.59,43.1 178.68,43.01 UH1.AU2
  TOP w0.109: v2(19.22,4.61) 19.36,4.74 JAPS1.13 ; UC3.4 172.13,48.8 172.58,48.35 RH66.1 172.81,48.19 173.52,48.89 v1(173.52,49.11) v2(174.38,49.97)
  IN3 w0.081: v2(19.22,4.61) 19.99,3.84 22.38,3.84 25.99,7.45 25.99,9.72 25.22,10.48 25.22,17.55 28.62,20.94 30.75,20.94 31.15,21.34 31.15,22.65 32.99,24.49 35.39,24.49 36.6,25.7 38.1,25.7 v2(40.37,27.97) ; v2(47.97,39.77) 49.21,41.01 51.16,41.01 51.91,41.76 54.06,41.76 54.42,41.41 54.42,41.14 54.77,40.79 56.88,40.79 57.21,40.46 65.25,40.46 65.95,41.17 66.5,41.17 66.62,41.28 68.32,42.98 68.32,45.21 68.95,45.84 69.23,45.84 70.46,47.07 75.72,47.07 77.63,45.16 80.31,45.16 81.34,44.12 83.65,44.12 85,42.77 89.23,42.77 95.93,49.47 109.48,49.47 110.18,48.78 114.47,48.78 116.94,46.31 116.94,45.39 117.49,44.85 118.41,44.85 119.38,43.88 122.79,43.88 124.51,45.6 127.78,45.6 130.73,48.56 134.76,48.56 135.5,47.82 136.98,47.82 137.49,48.33 138.88,48.33 139.53,47.68 154,47.68 156.59,45.09 160.58,45.09 163.2,47.71 163.2,50.55 175.77,63.12 v2(179.6,63.12)
  BOTTOM w0.109: v2(179.6,63.12) 177.74,61.27 177.74,53.93 177.15,53.34 177.15,52.65 174.47,49.97 v2(174.38,49.97) ; v2(47.97,39.77) 47.67,39.47 47.67,38.43 46.56,37.31 46.56,34.91 46.13,34.48 44.97,34.48 44.9,34.41 43.48,34.41 43.22,34.15 41.04,34.15 40.31,33.42 40.31,32.61 40.23,32.52 40.23,28.12 v2(40.37,27.97)
SYSTEM_ID: length 3.4
  TOP w0.102: UE1.J10 v2(137.53,22.45)
  BOTTOM w0.109: v2(137.53,22.45) 137.53,22.44 137.96,22.02 v1(137.96,22.02) 138.79,22.02 139.09,21.71 CE47.1 139.09,21.7 RE300.2
TACH_FAN1: length 250.1
  TOP w0.102: UE1.E3 v2(131.13,26.45)
  TOP w0.109: JFAN1.3 302.05,48.4 301.55,48.89 v2(301.55,50.74) 301.18,51.11 RZ508.2 ; v2(183.45,58.18) 183.25,58.38 183.25,60.54 191.46,68.75 191.46,71.7 191.16,72.01 191.16,75.37 199.56,83.78 203.67,83.78 213.47,73.98 259.57,73.98 270.24,84.65 274.16,84.65 274.59,85.08 v2(274.59,85.81)
  IN2 w0.081: v2(131.13,26.45) 131.53,26.05 136.9,26.05 137.12,26.27 137.12,26.61 137.39,26.87 139.07,26.87 139.87,27.67 140.31,27.67 141.02,28.38 141.93,28.38 142.24,28.7 142.24,29.6 142.62,29.98 144.14,29.98 144.26,29.86 145.61,29.86 146.67,30.92 152.23,30.92 152.66,31.35 156.59,31.35 158.34,33.1 158.34,33.84 160.24,35.73 162.73,35.73 163.62,36.62 165.9,36.62 166.18,36.89 166.99,36.89 167.55,37.45 167.55,37.9 168.36,38.71 168.36,39.19 169.29,40.12 170.06,40.12 172.68,42.74 172.68,43.44 173.17,43.93 173.17,45.63 173.27,45.73 173.27,47.34 173.95,48.02 175.24,48.02 176.21,49 176.21,50.83 182.09,56.71 182.09,57.88 182.39,58.18 v2(183.45,58.18) ; v2(301.55,50.74) 301.98,50.74 303.14,51.9 303.14,56.3 300.03,59.4 298.65,59.4 292.3,65.75 291.38,65.75 289.22,67.92 289.22,73.5 286.88,75.83 278.35,75.83 274.43,79.76 274.43,84.95 274.62,85.14 274.62,85.78 v2(274.59,85.81)
  BOTTOM w0.109: v3(185.18,58.61) 183.87,58.61 v2(183.45,58.18)
TACH_FAN2: length 90
  TOP w0.109: v2(79.82,56.82) 79.2,56.2 JFAN2.3 79.2,54.62 78.55,53.97 78.55,53.27 76.9,51.62 76.9,48.91 75,47 73.58,47 73.14,46.56 73.14,44.98 73.38,44.75 v2(73.79,44.75) ; v2(127.58,28.85) 127.58,28.6 129.33,26.85 UE1.D1
  IN2 w0.081: v2(127.58,28.85) 127.82,28.61 127.82,26.21 127.04,25.43 127.04,24.09 126.83,23.88 125.82,23.88 123.8,25.9 123.47,25.9 121.99,27.39 120.25,27.39 115.02,32.62 109.81,32.62 108.11,34.32 108.11,34.85 104.5,38.46 102.67,38.46 102.15,38.98 99.67,38.98 98.74,39.91 98.74,40.57 97.13,42.19 91.7,42.19 90.97,41.45 83.86,41.45 83.17,42.14 82.2,42.14 81.76,42.58 81.16,42.58 80.59,43.15 78.33,43.15 78.11,43.37 77.08,43.37 75.77,44.67 73.86,44.67 v2(73.79,44.75)
  BOTTOM w0.254: v2(79.82,56.82) v3(80.55,56.82) 80.85,56.52 RZ507.2
TB_STAT#: length 330.6
  TOP w0.109: v2(253.42,9.37) 253.42,9.94 262.51,19.03 266.04,19.03 266.28,19.28 270.87,19.28 272.36,17.79 272.72,17.79 v2(273.13,18.2) ; PQ704.2 v2(283.45,21.14)
  TOP w0.203: PU700.16 286.67,27.82 286.42,27.57 285.57,27.57 v2(285.36,27.36) 284.36,26.37 283.87,26.37 PR725.1
  IN1 w0.102: v2(285.36,27.36) 285.36,26.95 282.7,24.29 282.7,22.67 283.45,21.92 v2(283.45,21.14) 282.94,21.14 282.79,21.29 278.93,21.29 275.84,18.2 v2(273.13,18.2) ; v2(12.12,12.48) 11.69,12.06 11.69,10.45 11.98,10.16 11.98,8.06 14.88,5.15 24.73,5.15 25.12,5.54 28.67,5.54 29.61,6.48 34.9,6.48 36.13,7.71 40.83,7.71 41.63,6.91 52.01,6.91 53.41,5.51 64.08,5.51 65.14,6.57 65.67,6.57 66.11,7 66.11,9.3 66.85,10.05 69.45,10.05 71.1,8.4 73.73,8.4 74.25,7.88 76.35,7.88 78.2,6.03 94.32,6.03 95.03,5.33 95.03,3.93 96.66,2.29 100.37,2.29 101.15,1.51 114.01,1.51 117.22,4.72 120.19,4.72 120.55,5.07 121.35,5.07 123.33,7.05 126.19,7.05 127.63,5.61 127.63,4.44 128.19,3.87 129.76,3.87 130.28,3.36 130.28,3.04 131.1,2.21 137.74,2.21 138.99,3.46 138.99,6.3 140.66,7.97 140.66,8.72 141.83,9.88 143.29,9.88 143.93,10.52 148.25,10.52 149.07,9.71 155.54,9.71 156.11,10.28 157.64,10.28 161.01,6.9 164.88,6.9 165.73,7.75 169.69,7.75 173.53,3.91 177.1,3.91 178.77,2.24 189.41,2.24 190.77,3.6 192.05,3.6 192.13,3.67 197.6,3.67 199.04,5.11 204.53,5.11 205.37,4.27 209.34,4.27 210.1,5.02 210.1,9.02 210.74,9.66 215.8,9.66 217.1,10.96 219.22,10.96 219.78,11.51 228.16,11.51 228.71,10.96 236.93,10.96 238.35,9.54 247.73,9.54 248.17,9.98 252.81,9.98 253.42,9.37 v2(253.42,9.37)
  BOTTOM w0.109: UE12.5 11.94,12.66 v2(12.12,12.48)
TBT_A_SBU1: length 44.7
  IN1 w0.102: v2(28.7,42.18) 28.88,42.36 28.88,42.54 28.68,42.74 28.68,43.2 29.07,43.59 30.14,43.59 30.84,44.29 34.76,44.29 35.57,45.1 37.03,45.1 37.59,44.54 37.59,43.05 39.64,41 42.92,41 44.01,39.91 44.01,39.43 44.32,39.12 48.74,39.12 49.09,39.47 49.09,40.47 49.44,40.81 49.44,41.2 v2(49.22,41.41)
  BOTTOM w0.102: RT606.2 58.26,36.06 58.26,36.91 58.44,37.1 58.44,37.52 58.88,37.95 58.88,38.23 59.27,38.63 RT387.2 58.96,39.18 58.96,40.03 56.87,42.12 49.74,42.12 49.43,41.81 49.43,41.62 v2(49.22,41.41) ; v2(28.7,42.18) UT1.H4
TBT_A_SBU2: length 44.6
  IN1 w0.102: v2(29.36,42.83) 29.25,42.71 28.97,42.71 28.87,42.82 28.87,43.12 29.14,43.4 30.22,43.4 30.91,44.1 34.84,44.1 35.65,44.91 36.95,44.91 37.4,44.46 37.4,42.97 39.56,40.81 42.84,40.81 43.82,39.83 43.82,39.35 44.24,38.93 48.82,38.93 49.28,39.39 49.28,40.39 49.62,40.74 49.62,41.32 49.71,41.41 v2(49.96,41.41)
  BOTTOM w0.102: RT607.2 58.07,36.01 58.07,36.99 58.25,37.17 58.25,37.59 58.69,38.03 58.69,38.23 58.26,38.66 RT388.2 58.43,38.87 58.51,38.79 58.66,38.79 58.76,38.89 58.76,39.95 56.79,41.93 49.81,41.93 49.62,41.73 49.62,41.5 49.74,41.39 49.94,41.39 v2(49.96,41.41) ; UT1.J4 29.67,42.52 v2(29.36,42.83)
TBT_A_TRX_C_DTX_N1: length 5.5
  TOP w0.229: JUSBC1.A10 7.74,45.28 arc(7.82,45.27) 7.89,45.24 7.92,45.23 8.35,45.17 8.85,44.89 arc(9.03,44.78) 9.2,44.63 9.24,44.59 arc(9.42,44.33) 9.48,44.02 9.48,43.96 arc(9.53,43.68) 9.69,43.44 9.84,43.29 arc(10.16,43.07) 10.55,43 10.83,43 arc(11,43.03) RT631.1 11.19,43.1 arc(11.3,43.02) 11.44,42.99 11.47,42.99 arc(11.59,43.02) 11.69,43.09 CT392.1
TBT_A_TRX_C_DTX_N2: length 8.1
  TOP w0.216: JUSBC1.B10 5.95,49.02 6.24,49.02 arc(6.32,49.04) 6.38,49.08 6.58,49.28 arc(6.63,49.31) v2(6.69,49.32)
  BOTTOM w0.229: v2(6.69,49.32) 6.75,49.39 arc(6.83,49.44) 6.91,49.45 7.97,49.45 8.88,49.36 12.91,49.36 arc(13.06,49.33) 13.2,49.24 RT488.1 13.23,49.25 arc(13.33,49.31) 13.46,49.34 13.57,49.34 arc(13.67,49.32) 13.76,49.26 CT390.2
TBT_A_TRX_C_DTX_P1: length 5.5
  TOP w0.229: CT393.1 11.72,42.56 arc(11.62,42.63) 11.51,42.65 11.38,42.65 arc(11.27,42.63) 11.17,42.56 RT504.1 arc(11,42.65) 10.83,42.68 10.55,42.68 arc(10.04,42.78) 9.62,43.07 9.47,43.21 arc(9.24,43.56) 9.16,43.96 9.16,44.02 arc(9.12,44.21) 9.02,44.36 8.97,44.41 arc(8.84,44.52) 8.7,44.62 8.25,44.86 8.11,44.88 7.86,44.78 JUSBC1.A11
TBT_A_TRX_C_DTX_P2: length 8.1
  TOP w0.216: JUSBC1.B11 6.1,49.53 v2(6.69,49.9)
  BOTTOM w0.229: CT391.2 13.74,49.75 arc(13.66,49.7) 13.57,49.68 13.44,49.68 arc(13.35,49.7) 13.27,49.75 RT489.1 arc(13.06,49.71) 12.89,49.67 8.9,49.67 7.99,49.77 7.01,49.77 arc(6.83,49.81) v2(6.69,49.9)
TBT_A_TRX_DTX_N1: length 9.3
  TOP w0.229: RT594.1 18.49,38.16 arc(18.33,38.05) 18.14,38.01 17.97,38.01 arc(17.85,38.04) 17.74,38.11 17.68,38.17 arc(17.6,38.29) 17.57,38.44 17.57,39.26 arc(17.43,39.97) 17.03,40.57 14.91,42.69 arc(14.56,42.92) 14.15,43 13.41,43 arc(13.19,43.05) DT14.1 12.93,43.12 arc(12.79,43.03) 12.64,42.99 12.61,42.99 arc(12.45,43.03) CT392.2
TBT_A_TRX_DTX_N1_R: length 9.7
  TOP w0.229: RT594.2 19.2,38.04 arc(19.25,38) 19.31,37.99 19.35,37.99 arc(19.61,37.94) 19.83,37.79 20.33,37.29 arc(20.39,37.23) 20.42,37.15 arc(20.45,37.01) 20.46,36.86 arc(20.51,36.63) 20.64,36.43 22.85,34.22 arc(23.22,33.98) 23.65,33.89 24.39,33.89 arc(24.56,33.93) v2(24.71,34.02)
  BOTTOM w0.076: v2(24.71,34.02) 24.85,33.88 arc(24.9,33.85) 24.95,33.84 25.07,33.84 arc(25.12,33.85) 25.17,33.88 25.19,33.9 25.61,34.32 arc(25.62,34.34) 25.63,34.37 25.63,34.49 arc(25.69,34.63) 25.83,34.68 25.88,34.68 arc(25.94,34.67) 25.99,34.64 arc(26.01,34.59) 25.99,34.54 25.94,34.48 arc(25.93,34.48) UT1.A21
TBT_A_TRX_DTX_N2: length 15.6
  BOTTOM w0.229: CT390.1 14.38,49.25 arc(14.52,49.34) 14.68,49.38 arc(14.83,49.35) 14.96,49.26 DT9.1 arc(15.24,49.3) 15.47,49.35 15.48,49.35 15.61,49.35 arc(17.3,48.65) 18,46.97 18,41.94 arc(18.3,40.43) 19.16,39.14 20.28,38.02 arc(20.45,37.9) 20.66,37.86 20.71,37.86 arc(20.8,37.85) 20.87,37.8 RT596.1
TBT_A_TRX_DTX_N2_R: length 5.2
  BOTTOM w0.076: UT1.B15 26.14,37.07 arc(26.07,37.03) 25.99,37.02 25.85,37.02 arc(25.76,37.04) 25.69,37.09 25.58,37.19 arc(25.54,37.22) 25.49,37.23 25.4,37.23 arc(25.26,37.25) 25.15,37.33 25.1,37.38 arc(25.02,37.44) 24.92,37.45 24.72,37.45 arc(24.71,37.45) 24.71,37.45 arc(24.69,37.45) 24.68,37.44 arc(24.66,37.43) 24.65,37.42 24.61,37.38 24.58,37.38
  BOTTOM w0.229: RT596.2 21.62,37.79 arc(21.68,37.83) 21.75,37.85 22.63,37.85 arc(22.83,37.8) 23.01,37.69 23.07,37.63 arc(23.34,37.45) 23.65,37.38 24.58,37.38
TBT_A_TRX_DTX_P1: length 9.3
  TOP w0.229: RT595.1 18.48,37.56 arc(18.33,37.66) 18.14,37.7 17.97,37.7 arc(17.72,37.75) 17.52,37.89 17.46,37.94 arc(17.31,38.17) 17.25,38.44 17.25,39.26 arc(17.14,39.85) 16.81,40.34 14.69,42.47 arc(14.44,42.63) 14.15,42.69 13.41,42.69 arc(13.19,42.64) DT13.1 12.93,42.57 arc(12.82,42.65) 12.68,42.68 12.59,42.68 arc(12.44,42.65) CT393.2
TBT_A_TRX_DTX_P1_R: length 9.7
  TOP w0.229: v2(24.71,33.44) arc(24.56,33.54) 24.38,33.57 23.65,33.57 arc(23.09,33.68) 22.63,34 20.42,36.21 arc(20.21,36.51) 20.14,36.86 arc(20.14,36.86) 20.14,36.87 arc(20.14,36.96) 20.12,37.06 arc(20.11,37.06) 20.11,37.07 19.61,37.57 arc(19.5,37.65) 19.36,37.68 arc(19.21,37.64) RT595.2
  BOTTOM w0.076: v2(24.71,33.44) 24.92,33.65 arc(24.95,33.67) 24.97,33.67 25.07,33.67 arc(25.19,33.7) 25.29,33.77 25.69,34.17 25.7,34.17 arc(25.79,34.23) 25.89,34.25 26.01,34.25 arc(26.15,34.28) 26.26,34.36 UT1.B21
TBT_A_TRX_DTX_P2: length 15.6
  BOTTOM w0.229: RT597.1 20.85,38.22 arc(20.81,38.19) 20.76,38.18 20.66,38.18 arc(20.58,38.2) 20.5,38.25 19.38,39.37 arc(18.59,40.55) 18.32,41.94 18.32,46.97 arc(17.52,48.88) 15.61,49.67 15.29,49.67 arc(15.22,49.68) 15.17,49.72 DT10.1 14.94,49.73 arc(14.9,49.7) 14.85,49.69 14.56,49.69 arc(14.47,49.71) 14.4,49.76 CT391.1
TBT_A_TRX_DTX_P2_R: length 5.2
  BOTTOM w0.076: UT1.A15 26.03,37.24 arc(26.1,37.26) 26.13,37.33 26.13,37.36 arc(26.1,37.44) 26.02,37.48 25.82,37.48 arc(25.76,37.47) 25.71,37.43 arc(25.67,37.4) 25.61,37.39 25.4,37.39 arc(25.32,37.41) 25.26,37.45 25.21,37.5 arc(25.08,37.59) 24.92,37.62 24.72,37.62 arc(24.7,37.62) 24.68,37.63 24.5,37.63 arc(24.4,37.65) 24.32,37.7
  BOTTOM w0.229: 24.32,37.7 23.65,37.7 arc(23.46,37.74) 23.29,37.85 23.23,37.91 arc(22.95,38.1) 22.63,38.16 21.92,38.16 arc(21.72,38.2) RT597.2
TBT_A_TTX_C_DRX_N1: length 6.8
  TOP w0.229: JUSBC1.B3 6.11,45.52 arc(6.23,45.5) 6.34,45.44 6.48,45.31 arc(6.57,45.24) v2(6.69,45.22)
  BOTTOM w0.229: v2(6.69,45.22) 6.76,45.16 arc(6.84,45.1) 6.95,45.08 7.63,45.08 arc(8.02,45) 8.36,44.77 9.7,43.43 arc(10.17,43.12) 10.72,43.01 10.85,43.01 arc(11.02,43.04) RT490.1 arc(11.3,43.03) 11.47,43 arc(11.6,43.03) 11.7,43.1 CT96.2
TBT_A_TTX_C_DRX_N2: length 6.6
  TOP w0.229: JUSBC1.A3 7.8,48.78 8.12,48.87 8.55,48.87 arc(9.03,48.97) 9.45,49.25 9.46,49.26 arc(9.57,49.33) 9.69,49.36 10.93,49.36 11.06,49.36 11.06,49.36 12.96,49.36 arc(13.07,49.33) 13.16,49.27 RT219.1 13.24,49.25 arc(13.33,49.32) 13.45,49.34 13.54,49.34 arc(13.67,49.31) CT98.2
TBT_A_TTX_C_DRX_P1: length 6.8
  TOP w0.229: v2(6.69,44.64) 6.68,44.64 6.53,44.79 arc(6.26,44.96) JUSBC1.B2
  BOTTOM w0.229: v2(6.69,44.64) arc(6.82,44.73) 6.98,44.76 7.63,44.76 arc(7.9,44.7) 8.13,44.55 9.48,43.2 arc(10.05,42.82) 10.72,42.69 10.84,42.69 arc(11.01,42.65) RT491.1 arc(11.27,42.62) 11.4,42.65 11.5,42.65 arc(11.62,42.63) CT95.2
TBT_A_TTX_C_DRX_P2: length 6.6
  TOP w0.229: CT97.2 13.78,49.79 arc(13.64,49.7) 13.48,49.67 arc(13.36,49.69) 13.26,49.76 RT632.1 arc(13.06,49.71) 12.89,49.67 10.93,49.67 9.69,49.67 arc(9.44,49.62) 9.24,49.49 9.22,49.47 arc(8.91,49.26) 8.55,49.19 8.13,49.19 7.74,49.28 JUSBC1.A2
TBT_A_TTX_DRX_N1: length 14.2
  BOTTOM w0.229: RT624.1 arc(22.99,35.06) 22.81,35.03 22.3,35.03 arc(21.99,35.09) 21.73,35.26 14.26,42.73 arc(13.98,42.91) 13.65,42.98 13.36,42.98 arc(13.2,43.01) 13.07,43.1 DT6.1 12.94,43.13 arc(12.81,43.04) 12.65,43.01 12.58,43.01 arc(12.43,43.04) CT96.1
TBT_A_TTX_DRX_N1_R: length 3
  BOTTOM w0.076: UT1.B19 26.38,35.39 26.26,35.5 arc(26.2,35.55) 26.13,35.58 arc(26.05,35.61) 25.95,35.62 25.85,35.62 arc(25.75,35.59) 25.66,35.53 25.58,35.45 arc(25.54,35.42) 25.49,35.39 arc(25.39,35.35) 25.28,35.33 25.28,35.33 25.03,35.33 24.96,35.41 24.94,35.41
  BOTTOM w0.229: 24.94,35.41 arc(24.71,35.36) 24.52,35.23 24.48,35.19 arc(24.33,35.09) 24.15,35.06 24.03,35.06 arc(24,35.06) 23.98,35.05 23.98,35.06 arc(23.84,35.08) RT624.2
TBT_A_TTX_DRX_N2: length 18.8
  TOP w0.229: v2(22.73,36.2) arc(22.58,36.3) 22.41,36.33 22.04,36.33 arc(21.81,36.38) 21.61,36.51 21.48,36.64 arc(21.35,36.84) 21.31,37.07 arc(21.25,37.35) 21.09,37.59 18.57,40.11 arc(18.08,40.85) 17.9,41.72 17.9,46.93 arc(17.19,48.64) 15.48,49.35 15.47,49.35 arc(15.24,49.3) DT18.1 arc(14.86,49.3) 14.63,49.35 arc(14.49,49.32) CT98.1
  BOTTOM w0.229: RT626.1 23.33,36.25 arc(23.25,36.31) 23.15,36.33 23.15,36.33 arc(23.14,36.33) 23.14,36.33 22.96,36.33 arc(22.87,36.31) 22.79,36.26 v2(22.73,36.2)
TBT_A_TTX_DRX_N2_R: length 2.6
  BOTTOM w0.076: 24.53,36.26 24.56,36.23 25.55,36.23 arc(25.6,36.22) 25.65,36.19 25.66,36.18 arc(25.75,36.12) 25.85,36.1 26.04,36.1 arc(26.11,36.11) 26.17,36.13 arc(26.21,36.15) 26.25,36.18 UT1.B17
  BOTTOM w0.229: 24.53,36.26 24.48,36.3 arc(24.46,36.32) 24.43,36.33 24.17,36.33 arc(24.09,36.31) 24.02,36.27 RT626.2
TBT_A_TTX_DRX_P1: length 14.2
  BOTTOM w0.229: CT95.1 12.34,42.59 arc(12.45,42.66) 12.58,42.69 12.67,42.69 arc(12.8,42.66) 12.91,42.59 DT5.1 13.03,42.54 arc(13.16,42.63) 13.31,42.66 13.65,42.66 arc(13.86,42.62) 14.04,42.5 21.5,35.04 arc(21.87,34.79) 22.3,34.71 22.81,34.71 arc(22.99,34.67) RT623.1
TBT_A_TTX_DRX_P1_R: length 3
  BOTTOM w0.076: UT1.A19 25.92,35.39 26.04,35.39 arc(26.11,35.37) 26.14,35.3 26.14,35.24 arc(26.12,35.19) 26.07,35.17 25.02,35.17 24.94,35.09
  BOTTOM w0.229: RT623.2 23.8,34.64 arc(23.9,34.71) 24.03,34.74 24.15,34.74 arc(24.45,34.8) 24.71,34.97 24.74,35.01 arc(24.83,35.07) 24.94,35.09
TBT_A_TTX_DRX_P2: length 18.8
  TOP w0.229: CT97.1 14.38,49.78 arc(14.49,49.71) 14.62,49.68 14.69,49.68 arc(14.88,49.72) 15.03,49.82 DT17.1 15.14,49.75 arc(15.23,49.69) 15.34,49.66 15.48,49.66 arc(17.42,48.86) 18.22,46.93 18.22,41.72 arc(18.37,40.97) 18.79,40.33 21.32,37.81 arc(21.54,37.47) 21.63,37.07 arc(21.65,36.96) 21.71,36.86 21.84,36.74 arc(21.93,36.67) 22.04,36.65 22.41,36.65 arc(22.59,36.69) v2(22.73,36.78)
  BOTTOM w0.229: v2(22.73,36.78) 22.86,36.71 arc(23.12,36.65) 23.36,36.77 RT625.1
TBT_A_TTX_DRX_P2_R: length 2.6
  BOTTOM w0.076: UT1.A17 26.02,36.32 arc(26.1,36.37) 26.09,36.46 26.09,36.46 arc(26.03,36.51) 25.95,36.53 25.81,36.53 arc(25.74,36.52) 25.68,36.48 25.63,36.43 arc(25.61,36.42) 25.59,36.41 24.82,36.41 24.75,36.48
  BOTTOM w0.229: RT625.2 24.01,36.74 arc(24.12,36.67) 24.25,36.64 24.43,36.64 arc(24.58,36.61) 24.71,36.53 24.75,36.48
TBT_A_USB20N: length 46
  IN2 w0.094: v2(20.66,33.71) 20.93,33.45 21.21,33.45 21.5,33.16 21.5,32.19 21.74,31.95 27.81,31.95 29.53,33.67 34.56,33.67 35.53,34.64 37,34.64 37.76,33.88 41.12,33.88 41.3,33.7 42.66,33.7 43.01,33.35 43.01,32.77 43.56,32.22 46.3,32.22 46.95,32.87 50.93,32.87 51.23,33.18 54.73,33.18 54.88,33.33 56.63,33.33 57.52,32.44 57.52,31.03 57.64,30.92 57.82,30.92 v2(58.01,31.11)
  BOTTOM w0.102: RT562.1 21.08,33.48 20.89,33.48 v2(20.66,33.71) 20.45,33.49 20.15,33.49 RT560.1 ; v2(58.01,31.11) 57.77,30.87 57.54,30.87 UT5.A7
TBT_A_USB20P: length 46
  IN2 w0.094: v2(58,30.5) 57.78,30.72 57.56,30.72 57.33,30.95 57.33,32.36 56.55,33.13 54.96,33.13 54.81,32.98 51.31,32.98 51.01,32.68 47.03,32.68 46.38,32.03 43.48,32.03 42.81,32.69 42.81,33.27 42.57,33.5 41.22,33.5 41.04,33.69 37.67,33.69 36.92,34.44 35.61,34.44 34.64,33.47 29.61,33.47 27.89,31.75 21.66,31.75 21.3,32.1 21.3,33.08 21.13,33.25 20.86,33.25 v2(20.66,33.05)
  BOTTOM w0.102: v2(58,30.5) 57.83,30.68 57.51,30.68 UT5.A6 ; RT559.1 20.15,33.3 20.41,33.3 v2(20.66,33.05) 20.91,33.29 21.07,33.29 RT561.1
TBT_B_SBU1: length 41.6
  TOP w0.102: v2(54.52,36.48) 54.35,36.66 54.35,37.17 53.44,38.07 53.44,40.17 53,40.62 53,40.78 v2(53.23,41.01)
  IN1 w0.102: v2(30.01,42.18) 30.51,42.18 30.65,42.32 30.65,42.63 31.47,43.45 35,43.45 36.04,42.41 37.1,42.41 39.83,39.68 40.63,39.68 41.73,38.58 41.73,37.97 42.04,37.66 42.57,37.66 43.03,38.12 45.74,38.12 46.23,37.63 48.63,37.63 49.99,38.99 49.99,40.1 51.29,41.39 52.85,41.39 v2(53.23,41.01)
  IN3 w0.094: v2(51.09,35.68) 51.09,35.91 51.19,36 51.44,36 51.65,35.8 53.9,35.8 54.15,36.05 54.15,36.1 v2(54.52,36.48)
  BOTTOM w0.102: RT385.1 55.83,36.48 v2(54.52,36.48) ; RT608.1 51.64,35.23 51.19,35.68 v2(51.09,35.68) ; UT1.L4 30.01,42.19 v2(30.01,42.18)
TBT_B_SBU2: length 41.6
  TOP w0.102: v2(53.93,36.49) 54.15,36.72 54.15,37.09 53.25,37.99 53.25,40.1 52.81,40.54 52.81,40.79 v2(52.62,40.98)
  IN1 w0.102: v2(30.01,41.54) 30.14,41.41 30.3,41.41 30.42,41.52 30.42,41.67 30.29,41.8 30.29,41.92 30.36,41.99 30.58,41.99 30.84,42.24 30.84,42.55 31.55,43.26 34.92,43.26 35.97,42.22 37.02,42.22 39.75,39.49 40.55,39.49 41.54,38.5 41.54,37.89 41.96,37.47 42.64,37.47 43.11,37.94 45.66,37.94 46.15,37.44 48.71,37.44 50.18,38.91 50.18,40.02 51.36,41.21 52.39,41.21 v2(52.62,40.98)
  IN3 w0.094: v2(50.5,35.69) 50.59,35.69 51.09,36.2 51.52,36.2 51.73,36 53.81,36 53.93,36.11 v2(53.93,36.49)
  BOTTOM w0.102: UT1.L5 30.01,41.54 v2(30.01,41.54) ; RT609.1 51.07,35.12 v2(50.5,35.69) ; v2(53.93,36.49) 53.62,36.19 53.62,35.77 53.7,35.69 53.84,35.69 RT386.1
TBT_B_TRX_C_DTX_N1: length 4.4
  TOP w0.229: JUSBC1.1A10 7.8,61.48 arc(7.94,61.45) 8.06,61.37 8.06,61.37 arc(8.52,61.28) 8.92,61.01 9.45,60.48 arc(9.74,60.06) 9.84,59.57 arc(9.84,59.57) 9.84,59.57 arc(9.84,59.56) 9.84,59.54 arc(9.88,59.38) RT638.1 9.95,59.22 arc(9.87,59.1) 9.84,58.96 9.84,58.93 arc(9.87,58.79) 9.95,58.67 CT396.1
TBT_B_TRX_C_DTX_N2: length 15.1
  TOP w0.229: v2(6.69,65.52) 6.58,65.52 arc(6.57,65.52) 6.56,65.51 6.3,65.26 arc(6.27,65.23) 6.22,65.23 JUSBC1.1B10
  BOTTOM w0.229: v2(6.69,65.52) 6.78,65.61 arc(6.86,65.67) 6.96,65.69 7.11,65.69 arc(7.31,65.64) 7.49,65.52 7.61,65.4 arc(7.91,65.2) 8.27,65.13 10.76,65.13 arc(11.28,65.03) 11.73,64.73 12.43,64.03 13.12,63.13 13.98,61.74 15.35,59.2 15.36,59.18 arc(15.54,58.81) 15.6,58.41 15.6,57.95 arc(15.58,57.86) 15.53,57.79 RT635.1 arc(15.53,57.6) 15.56,57.47 15.56,57.36 arc(15.54,57.24) CT395.2
TBT_B_TRX_C_DTX_P1: length 3.9
  TOP w0.229: CT397.1 9.43,58.69 arc(9.49,58.79) 9.51,58.9 9.51,58.96 arc(9.49,59.1) 9.41,59.21 RT637.1 arc(9.49,59.39) 9.53,59.56 arc(9.44,59.94) 9.23,60.26 8.69,60.79 arc(8.4,60.98) 8.06,61.05 7.83,60.97 7.55,60.97 JUSBC1.1A11
TBT_B_TRX_C_DTX_P2: length 15.6
  TOP w0.229: JUSBC1.1B11 6.13,65.73 arc(6.21,65.74) 6.28,65.79 6.53,66.04 arc(6.6,66.09) v2(6.69,66.1)
  BOTTOM w0.229: CT394.2 16,57.17 arc(15.95,57.25) 15.93,57.35 15.93,57.44 arc(15.96,57.59) 16.04,57.71 RT636.1 arc(15.95,57.85) 15.92,58.02 15.92,58.41 arc(15.84,58.9) 15.63,59.35 15.62,59.37 14.26,61.9 13.38,63.31 12.67,64.24 11.95,64.95 arc(11.4,65.32) 10.76,65.45 8.27,65.45 arc(8.03,65.49) 7.83,65.63 7.71,65.75 arc(7.44,65.94) 7.11,66.01 6.96,66.01 arc(6.96,66.01) 6.95,66.01 arc(6.93,66.01) 6.91,66.01 arc(6.79,66.03) v2(6.69,66.1)
TBT_B_TRX_DTX_N1: length 26.8
  TOP w0.229: CT396.2 9.96,58.08 arc(9.87,57.95) 9.84,57.79 9.84,55.32 arc(10.53,53.42) 12.28,52.41 12.62,52.35 12.77,52.34 arc(13.01,52.4) DT45.1 13.23,52.52 arc(13.41,52.4) 13.62,52.36 14.11,52.36 arc(15.55,52.07) 16.78,51.25 17.86,50.17 17.86,50.17 18.11,49.92 arc(18.97,48.63) 19.27,47.12 19.27,41.85 arc(19.36,41.44) 19.59,41.09 21.8,38.88 21.96,38.79 arc(22.24,38.73) 22.5,38.86 RT598.2
TBT_B_TRX_DTX_N1_R: length 3.6
  TOP w0.229: RT598.1 23.19,38.77 arc(23.25,38.73) 23.32,38.72 23.7,38.72 arc(23.87,38.75) 24.01,38.84 v2(24.04,38.88)
  BOTTOM w0.076: v2(24.04,38.88) 24.19,38.74 arc(24.26,38.69) 24.34,38.67 24.6,38.67 arc(24.91,38.64) 25.2,38.53 25.44,38.41 arc(25.46,38.4) 25.48,38.39 25.99,38.39 arc(26.11,38.37) 26.22,38.31 arc(26.24,38.3) 26.25,38.28 UT1.B13
TBT_B_TRX_DTX_N2: length 16
  BOTTOM w0.229: CT395.1 arc(15.56,56.43) 15.58,56.28 15.58,56.18 arc(15.56,56.05) 15.49,55.95 DT51.1 arc(15.55,55.68) 15.59,55.45 15.59,55.24 arc(15.85,53.93) 16.6,52.82 18.32,51.1 arc(19.67,49.08) 20.14,46.69 20.14,43.25 20.19,43.2 arc(20.26,43.08) 20.34,42.97 20.4,42.91 arc(20.68,42.73) RT600.2
TBT_B_TRX_DTX_N2_R: length 5.7
  BOTTOM w0.076: UT1.A7 25.99,40.92 arc(26.06,40.88) 26.09,40.81 26.09,40.79 arc(26.06,40.72) 25.98,40.68 25.78,40.68 arc(25.73,40.69) 25.69,40.72 25.67,40.74 arc(25.64,40.79) 25.63,40.85 arc(25.62,40.89) 25.6,40.93 25.57,40.95 arc(25.53,40.98) 25.48,40.99 25.15,40.99 arc(24.96,41.02) 24.8,41.13 24.71,41.22 24.59,41.22 24.51,41.31
  BOTTOM w0.229: 24.51,41.31 23.75,42.06 arc(23.5,42.23) 23.22,42.28 23.21,42.28 22.84,42.28 arc(22.59,42.33) 22.38,42.47 22.12,42.74 arc(22.03,42.8) 21.93,42.82 21.86,42.82 arc(21.75,42.79) 21.65,42.73 RT600.1
TBT_B_TRX_DTX_P1: length 27.3
  TOP w0.229: RT599.2 22.41,38.36 arc(22.35,38.4) 22.28,38.41 22.16,38.41 arc(21.85,38.47) 21.58,38.65 19.36,40.87 arc(19.06,41.32) 18.96,41.85 18.96,47.12 arc(18.68,48.51) 17.89,49.69 17.64,49.95 16.56,51.03 arc(15.43,51.78) 14.11,52.04 13.62,52.04 arc(13.4,52) DT44.1 arc(13.06,51.97) 12.89,52.02 12.59,52.03 12.23,52.09 arc(10.29,53.22) 9.52,55.32 9.52,57.79 arc(9.49,57.95) CT397.2
TBT_B_TRX_DTX_P1_R: length 3.6
  TOP w0.229: RT599.1 23.19,38.36 arc(23.23,38.39) 23.29,38.4 23.8,38.4 arc(23.93,38.37) v2(24.04,38.3)
  BOTTOM w0.076: UT1.A13 25.99,38.09 arc(26.01,38.06) 26.02,38.02 26.02,38 arc(25.99,37.94) 25.93,37.91 25.71,37.91 arc(25.65,37.94) 25.63,38 25.63,38.14 arc(25.6,38.2) 25.54,38.23 25.48,38.23 arc(25.41,38.24) 25.35,38.27 25.13,38.38 arc(24.93,38.46) 24.73,38.5 arc(24.66,38.5) 24.6,38.51 24.46,38.51 arc(24.27,38.47) 24.11,38.36 v2(24.04,38.3)
TBT_B_TRX_DTX_P2: length 15.5
  BOTTOM w0.229: RT601.2 20.9,43.17 arc(20.81,43.12) 20.7,43.11 arc(20.66,43.13) 20.61,43.15 arc(20.61,43.15) 20.61,43.15 20.57,43.2 arc(20.49,43.32) 20.46,43.46 20.46,46.69 arc(19.96,49.2) 18.54,51.32 16.82,53.04 arc(16.15,54.05) 15.91,55.24 15.91,55.45 arc(15.96,55.68) DT53.1 16.05,55.91 arc(15.95,56.07) 15.91,56.26 15.92,56.35 arc(15.96,56.46) CT394.1
TBT_B_TRX_DTX_P2_R: length 5.7
  BOTTOM w0.076: UT1.B7 26.26,41.04 arc(26.13,41.12) 25.98,41.15 25.15,41.15 arc(25.02,41.18) 24.91,41.25 24.82,41.34 24.82,41.44 24.8,41.46
  BOTTOM w0.229: 24.8,41.46 23.97,42.29 arc(23.62,42.52) 23.22,42.6 22.84,42.6 arc(22.71,42.63) 22.61,42.7 22.34,42.96 arc(22.15,43.09) 21.93,43.13 arc(21.74,43.17) RT601.1
TBT_B_TTX_C_DRX_N1: length 5.9
  TOP w0.229: v2(6.69,61.42) 6.59,61.42 arc(6.58,61.43) 6.56,61.43 6.26,61.7 arc(6.23,61.72) 6.19,61.73 JUSBC1.1B3
  BOTTOM w0.229: v2(6.69,61.42) 6.81,61.3 arc(6.85,61.27) 6.91,61.26 8.29,61.13 arc(8.81,60.99) 9.25,60.68 9.45,60.47 arc(9.73,60.05) 9.83,59.55 arc(9.87,59.38) RT634.1 9.96,59.23 arc(9.89,59.11) 9.86,58.97 9.86,58.91 arc(9.86,58.88) 9.86,58.86 arc(9.9,58.75) CT360.2
TBT_B_TTX_C_DRX_N2: length 13.2
  TOP w0.229: JUSBC1.1A3 7.93,64.98 8.01,65 8.08,65.02 8.17,65.05 8.19,65.05 8.51,65.14 10.73,65.14 arc(11.29,65.03) 11.77,64.71 12.21,64.27 13.06,63.09 14.81,60.19 14.82,60.18 15.31,59.36 arc(15.51,58.91) 15.57,58.42 15.57,57.99 arc(15.57,57.93) 15.55,57.87 RT639.1 arc(15.53,57.6) 15.56,57.47 15.56,57.36 arc(15.54,57.24) CT365.2
TBT_B_TTX_C_DRX_P1: length 5.4
  TOP w0.229: v2(6.69,60.84) 6.42,61.07 arc(6.29,61.15) 6.15,61.19 JUSBC1.1B2
  BOTTOM w0.229: CT359.2 arc(9.5,58.8) 9.54,58.96 arc(9.52,59.07) 9.45,59.17 RT633.1 arc(9.48,59.38) 9.51,59.54 9.51,59.55 arc(9.51,59.55) 9.51,59.56 arc(9.44,59.93) 9.23,60.25 9.02,60.45 arc(8.67,60.7) 8.26,60.81 7.24,60.91 arc(7.14,60.91) 7.04,60.92 arc(6.99,60.92) 6.95,60.92 6.89,60.92 arc(6.78,60.9) v2(6.69,60.84)
TBT_B_TTX_C_DRX_P2: length 13.8
  TOP w0.229: JUSBC1.1A2 7.73,65.48 7.98,65.37 8.14,65.37 8.46,65.46 10.73,65.46 arc(11.41,65.32) 12,64.94 12.45,64.48 13.33,63.27 15.09,60.35 15.09,60.34 15.58,59.52 arc(15.81,58.99) 15.89,58.42 15.89,57.97 arc(15.89,57.93) 15.91,57.88 15.96,57.79 RT640.1 16.03,57.7 arc(15.94,57.57) 15.91,57.42 15.91,57.36 arc(15.93,57.27) 15.99,57.18 CT366.2
TBT_B_TTX_DRX_N1: length 26.4
  BOTTOM w0.229: CT360.1 arc(9.87,57.95) 9.84,57.79 9.84,55.31 arc(10.7,53.22) 12.79,52.36 arc(13.01,52.4) 13.2,52.53 DT48.1 13.22,52.53 arc(13.41,52.4) 13.63,52.36 arc(15.8,51.93) 17.63,50.7 17.81,50.52 arc(18.99,48.75) 19.4,46.67 19.4,41.77 arc(19.53,41.15) 19.88,40.62 20.56,39.94 arc(20.99,39.65) 21.51,39.55 22.05,39.55 arc(22.22,39.58) RT628.2
TBT_B_TTX_DRX_N1_R: length 3.9
  BOTTOM w0.076: 24.17,39.77 24.22,39.73 24.57,39.73 arc(24.72,39.7) 24.84,39.62 25.29,39.17 arc(25.32,39.15) 25.36,39.14 25.58,39.14 arc(25.6,39.15) 25.62,39.16 25.7,39.24 arc(25.77,39.28) 25.85,39.3 26.11,39.3 arc(26.16,39.29) 26.19,39.27 UT1.B11
  BOTTOM w0.229: 24.17,39.77 23.96,39.77 arc(23.73,39.73) 23.54,39.6 arc(23.45,39.54) 23.34,39.52 23.33,39.52 arc(23.12,39.56) RT628.1
TBT_B_TTX_DRX_N2: length 19.1
  TOP w0.229: CT365.1 15.49,56.54 arc(15.57,56.42) 15.6,56.28 15.6,56.22 arc(15.57,56.07) 15.48,55.94 DT54.1 arc(15.55,55.68) 15.6,55.45 15.6,55.19 arc(15.84,53.95) 16.54,52.9 18.28,51.16 arc(19.57,49.24) 20.02,46.97 20.02,42.25 arc(20.11,41.8) 20.37,41.41 20.51,41.27 arc(20.85,41.04) 21.25,40.96 21.51,40.96 arc(21.59,40.94) 21.66,40.89 v2(21.74,40.82)
  BOTTOM w0.229: v2(21.74,40.82) 21.82,40.91 arc(21.88,40.95) 21.95,40.96 22.07,40.96 arc(22.11,40.96) 22.14,40.95 arc(22.21,40.92) 22.28,40.87 RT630.2
TBT_B_TTX_DRX_N2_R: length 4
  BOTTOM w0.076: 23.98,40.48 24,40.46 24.1,40.46 24.19,40.37 arc(24.32,40.28) 24.47,40.25 25.05,40.25 arc(25.26,40.21) 25.43,40.1 25.47,40.06 arc(25.47,40.05) 25.48,40.05 25.63,39.9 25.63,39.9 arc(25.66,39.87) 25.68,39.85 25.74,39.79 arc(25.77,39.77) 25.81,39.76 26.03,39.76 arc(26.05,39.77) 26.08,39.78 UT1.B9
  BOTTOM w0.216: 23.59,40.87 23.98,40.48
  BOTTOM w0.229: RT630.1 23.07,40.92 arc(23.15,40.97) 23.23,40.99 23.3,40.99 arc(23.36,40.98) 23.42,40.97 arc(23.46,40.96) 23.49,40.94 23.5,40.94 arc(23.55,40.91) 23.59,40.87
TBT_B_TTX_DRX_P1: length 26.9
  BOTTOM w0.229: RT627.2 22.28,39.17 arc(22.21,39.22) 22.13,39.23 21.51,39.23 arc(20.87,39.36) 20.33,39.72 19.65,40.4 arc(19.23,41.03) 19.09,41.77 19.09,46.67 arc(18.7,48.63) 17.58,50.3 17.41,50.48 arc(15.67,51.63) 13.63,52.04 13.62,52.04 arc(13.4,52) DT43.1 arc(13.02,52) 12.8,52.04 12.79,52.04 arc(10.48,53) 9.52,55.31 9.52,57.79 arc(9.49,57.95) CT359.1
TBT_B_TTX_DRX_P1_R: length 3.9
  BOTTOM w0.076: 24.25,39.46 24.36,39.56 24.57,39.56 arc(24.65,39.55) 24.73,39.5 25.17,39.05 arc(25.26,39) 25.36,38.98 25.51,38.98 arc(25.59,38.96) 25.66,38.91 arc(25.75,38.86) 25.84,38.84 26.04,38.84 arc(26.07,38.85) 26.11,38.87 arc(26.14,38.94) 26.11,39.01 26.1,39.01 arc(26.03,39.06) 25.95,39.08 UT1.A11
  BOTTOM w0.229: 24.25,39.46 23.96,39.46 arc(23.85,39.43) 23.76,39.37 arc(23.57,39.24) 23.34,39.2 23.2,39.2 arc(23.06,39.17) RT627.1
TBT_B_TTX_DRX_P2: length 18.5
  TOP w0.229: v2(21.74,41.4) arc(21.6,41.31) 21.43,41.28 21.25,41.28 arc(20.97,41.33) 20.74,41.49 20.59,41.63 arc(20.4,41.92) 20.34,42.25 20.34,46.97 arc(19.86,49.36) 18.51,51.38 16.77,53.13 arc(16.14,54.07) 15.91,55.19 15.91,55.46 arc(15.96,55.69) DT52.1 16.05,55.91 arc(15.95,56.05) 15.92,56.23 15.92,56.28 arc(15.94,56.43) CT366.1
  BOTTOM w0.229: v2(21.74,41.4) 21.76,41.38 arc(21.86,41.31) 21.98,41.29 22.02,41.29 arc(22.2,41.32) RT629.2
TBT_B_TTX_DRX_P2_R: length 4
  BOTTOM w0.076: UT1.A9 26.01,40 arc(26.09,40.03) 26.12,40.11 arc(26.09,40.19) 26.02,40.22 25.82,40.22 arc(25.77,40.21) 25.72,40.18 25.72,40.17 arc(25.65,40.15) 25.59,40.17 25.54,40.22 arc(25.32,40.37) 25.06,40.42 24.47,40.42 arc(24.38,40.44) 24.3,40.49 24.22,40.57 24.22,40.67 24.08,40.81
  BOTTOM w0.216: 23.82,41.09 23.85,41.06 23.85,41.05 23.9,41 23.9,40.99 24.08,40.81
  BOTTOM w0.229: RT629.1 arc(23.08,41.34) 23.24,41.31 23.3,41.31 arc(23.48,41.28) 23.64,41.22 arc(23.73,41.16) 23.82,41.09
TBT_B_USB20N: length 45.9
  IN1 w0.102: v2(17.57,35.34) 17.57,35.46 17.77,35.67 18.08,35.67 18.6,35.15 18.6,34.88 19.44,34.03 19.44,32.91 20.65,31.7 25.63,31.7 27.48,33.55 34.04,33.55 34.82,34.33 45.87,34.33 46.32,33.87 46.32,33.12 46.72,32.72 49.17,32.72 49.66,33.21 49.66,33.61 50.4,34.35 51.11,34.35 52.22,33.23 53.56,33.23 54.06,33.73 54.15,33.73 v2(54.32,33.56)
  BOTTOM w0.102: v2(54.32,33.56) 54.55,33.79 54.7,33.8 54.73,33.76 54.73,33.28 54.64,33.19 54.52,33.19 UT5.G11 ; RT556.2 v2(17.57,35.34) RT558.2
TBT_B_USB20P: length 45.9
  IN1 w0.102: v2(54.32,34.22) 54.28,34.22 53.48,33.42 52.3,33.42 51.18,34.54 50.32,34.54 49.47,33.68 49.47,33.29 49.09,32.91 46.8,32.91 46.51,33.2 46.51,33.95 45.94,34.52 34.74,34.52 33.97,33.74 27.4,33.74 25.55,31.89 20.73,31.89 19.63,32.99 19.63,34.11 18.79,34.95 18.79,35.23 18.16,35.85 17.68,35.85 v2(17.57,35.97)
  BOTTOM w0.102: UT5.F11 54.87,33.14 54.92,33.2 54.92,33.89 54.82,33.99 54.7,33.99 54.55,33.99 v2(54.32,34.22) ; RT555.2 v2(17.57,35.97) RT557.2
TBT_CIO_PLUG_EVENT#: length 186.6
  TOP w0.102: UH1.BF8 173.86,39.86 173.81,39.92 173.79,39.92 173.77,39.94 173.5,39.94 173.47,39.9 173.21,39.9 172.25,40.87 172.25,41 170.87,42.38 v2(169.67,42.38)
  IN2 w0.081: v2(36.84,49.45) 36.84,49 37.21,48.63 37.21,47.48 38.47,46.22 38.47,45.07 37.75,44.34 v2(36.73,44.34) ; v2(169.67,42.38) 169.23,42.38 167.72,40.87 166.96,40.87 166.15,40.07 164.63,40.07 163.86,39.3 161.57,39.3 157.77,35.5 157.14,35.5 154.36,32.72 152.06,32.72 151.71,32.38 144.6,32.38 v2(143.85,31.62)
  IN3 w0.081: v2(36.73,44.34) 36.97,44.1 36.97,43.6 36.73,43.36 36.6,43.36 36.3,43.06 36.3,41.47 36.51,41.27 37.13,41.27 37.87,40.52 37.87,38.27 39.42,36.73 40.13,36.73 40.92,35.94 40.92,35.69 40.63,35.4 40.63,35.14 41.78,33.98 42.94,33.98 43.53,33.4 43.53,33.01 44.97,31.57 44.97,28.58 45.93,27.62 45.93,25.41 47.02,24.32 47.54,24.32 48.86,23 50.33,23 50.83,23.5 55.69,23.5 58.06,21.13 61.52,21.13 62.02,21.62 62.02,22.08 62.39,22.45 62.51,22.45 62.96,22.9 62.96,23.05 63.52,23.61 70.98,23.61 72.35,24.98 78.58,24.98 81.96,21.6 82.93,21.6 83.52,22.19 89.44,22.19 89.75,22.5 93.08,22.5 94.27,21.32 98.52,21.32 99.08,20.76 100.6,20.76 101.15,21.3 101.15,22.89 101.91,23.65 104.76,23.65 105.15,24.04 105.15,24.79 105.74,25.38 106.2,25.38 108.6,27.78 108.6,28.81 109.84,30.05 111.17,30.05 111.8,29.42 118.8,29.42 120.82,31.43 125.36,31.43 125.53,31.27 126.56,31.27 127.47,32.18 129.06,32.18 129.64,31.61 130.56,31.61 130.79,31.83 131.68,31.83 132.02,32.18 134.84,32.18 136.6,30.42 138.51,30.42 139.1,31.01 140.59,31.01 141.18,30.42 142.64,30.42 v2(143.85,31.62)
  BOTTOM w0.109: RT391.1 37.73,49.59 v1(37.59,49.72) 37.54,49.78 37.16,49.78 v2(36.84,49.45) ; UT1.AA1 35.12,44.05 35.69,44.62 36.45,44.62 v2(36.73,44.34)
TBT_FORCE_PWR: length 181
  TOP w0.102: v2(171.58,36.66) 171.59,36.66 174.72,36.66 UH1.BE15
  TOP w0.109: v2(33.26,42.19) 33.26,42.77 33.43,42.94 RT27.1 34.33,42.94 RT592.1
  IN1 w0.102: v2(42.57,36.55) 41.85,36.55 40.78,37.62 40.78,38.12 40.19,38.71 39.65,38.71 37.27,41.09 36.23,41.09 34.71,42.61 33.68,42.61 v2(33.26,42.19)
  IN2 w0.081: v2(171.58,36.66) 171.58,35.79 170.62,34.83 169.34,34.83 167.77,33.25 167.19,33.25 165.81,31.88 165.11,31.88 164.36,31.13 164.36,30.63 162.75,29.01 162.33,29.01 159.96,26.64 159.11,26.64 158.1,25.64 153.74,25.64 152.67,24.57 149.96,24.57 145.07,19.67 141.69,19.67 140.77,18.76 140.77,17.58 139.82,16.63 138.3,16.63 137.83,16.16 135.7,16.16 135.4,16.45 133.43,16.45 133.24,16.26 132.22,16.26 131.66,15.71 126.75,15.71 126.21,15.17 124.08,15.17 123.66,15.59 119.87,15.59 118.74,16.72 118.74,17.14 118.24,17.64 116.33,17.64 114.87,19.1 113.57,19.1 111.18,21.48 105.86,21.48 105.67,21.29 104.59,21.29 104.15,21.72 104.15,22.09 100.93,25.32 100.93,25.61 100.64,25.9 100.28,25.9 99.17,27.01 99.17,27.68 97.02,29.82 97.02,31.43 91.7,36.76 85.92,36.76 85.62,36.46 85.62,35.86 85.49,35.73 83.35,35.73 83.08,35.46 81.89,35.46 81.5,35.84 81.5,36.33 80.52,37.32 80.52,39.93 79.53,40.92 72.84,40.92 v2(72.67,41.09)
  IN3 w0.081: v2(72.67,41.09) 72.67,40.69 71.86,39.88 70.6,39.88 70.17,39.46 70.17,39.07 69.65,38.54 69.28,38.54 68.54,37.8 68.54,36.88 68.29,36.63 66.64,36.63 65.72,37.55 61.85,37.55 60.81,36.5 59.96,36.5 59.39,35.94 55.93,35.94 54.73,37.14 51.47,37.14 51.27,37.34 50.24,37.34 49.31,36.4 49.31,36.11 48.66,35.47 48.28,35.47 47.53,34.71 46.61,34.71 46.33,34.43 44.15,34.43 42.57,36.02 v2(42.57,36.55)
  BOTTOM w0.109: UT1.V4 v2(33.26,42.19)
TBT_I2C_SCL: length 40.4
  TOP w0.109: RT514.1 45.88,32.82 v2(45.88,33.57)
  IN2 w0.081: v2(34.89,45.55) 34.93,45.51 34.93,43.36 35.67,42.62 35.67,40.64 37.68,38.63 37.68,38.13 38.25,37.56 38.25,36.7 37.8,36.26 37.8,35.67 38.29,35.18 38.94,35.18 39.17,35.4 39.17,35.97 39.32,36.12 39.32,36.66 39.61,36.95 40.69,36.95 42.11,35.53 43.22,35.53 44.87,33.88 44.87,33.36 45.09,33.15 45.6,33.15 45.88,33.42 v2(45.88,33.57)
  IN3 w0.081: v2(55.25,28.96) 54.61,28.32 52.93,28.32 51.95,29.29 50.93,29.29 50.59,28.95 49.09,28.95 45.88,32.16 v2(45.88,33.57)
  BOTTOM w0.089: 33.97,43.89 33.97,43.44 UT1.V2
  BOTTOM w0.109: v2(34.89,45.55) 34.89,45.42 33.97,44.49 33.97,43.89 ; v2(55.25,28.96) 55.37,28.85 UT5.E2
TBT_I2C_SDA: length 40.9
  TOP w0.109: RT510.1 45.28,32.93 v2(45.28,33.55)
  IN2 w0.081: v2(34.29,45.53) 34.29,45.79 34.48,45.99 35.02,45.99 35.29,45.72 35.29,43.33 36.1,42.52 36.1,41.79 37.93,39.96 37.93,38.24 38.48,37.69 38.48,36.61 38.07,36.2 38.07,35.74 38.34,35.47 38.79,35.47 38.93,35.61 38.93,36.05 39.09,36.21 39.09,36.76 39.38,37.05 39.52,37.18 40.79,37.18 42.23,35.74 43.3,35.74 45.28,33.76 v2(45.28,33.55)
  IN3 w0.081: v2(45.28,33.55) 45.28,32.4 48.96,28.72 50.49,28.72 51.55,27.66 52.63,27.66 53.06,28.09 54.95,28.09 v2(55.84,28.98)
  BOTTOM w0.102: v2(34.29,45.53) 34.29,45.25 v1(34.03,44.99) 33.74,44.7 33.74,44.11
  BOTTOM w0.109: UT1.V1 33.74,44.11 ; UT5.D2 55.87,28.54 55.87,28.95 v2(55.84,28.98)
TBT_ID: length 11.5
  TOP w0.102: v2(166.3,29.36) 166.66,29 167.05,29 167.44,29.39 171,29.39 171.07,29.46 171.07,29.46 171.09,29.47 173.83,29.47 173.89,29.53 UH1.BF29
  BOTTOM w0.102: RH267.1 167.23,28.99 166.71,28.99 166.34,29.36 v2(166.3,29.36) 165.6,28.67 RH268.1
TBT_JTAG_TCK: length 9.3
  IN1 w0.102: v2(33.91,35.69) 33.94,35.69 34.36,35.27 34.78,35.27 35.77,36.26 37.49,36.26 38.63,35.13 v2(40,35.13)
  BOTTOM w0.109: RT6.1 39.97,34.53 v1(40.01,34.57) 40.1,34.66 40.1,35.03 v2(40,35.13) ; UT1.W19 v2(33.91,35.69)
TBT_JTAG_TDI: length 1.2
  TOP w0.109: RT8.1 33.96,34.46 33.92,34.42 v2(33.91,34.42)
  BOTTOM w0.109: UT1.W20 33.94,34.42 v2(33.91,34.42)
TBT_JTAG_TDO: length 9.1
  IN1 w0.102: v2(39.82,35.72) 37.34,38.19 36.41,38.19 35.36,37.15 35.36,36.51 35.16,36.3 35.16,36.29 v2(34.56,35.69)
  BOTTOM w0.109: RT5.1 39.25,35.72 v2(39.82,35.72) ; UT1.Y19 v2(34.56,35.69)
TBT_JTAG_TMS: length 8.6
  IN3 w0.081: v2(33.91,35.03) 34.82,34.11 34.82,33.13 35.87,32.09 36.54,32.09 v2(37.57,33.12)
  BOTTOM w0.109: UT1.Y20 34.57,35.03 v2(33.91,35.03) ; RT7.1 38.87,33.66 38.33,33.12 v2(37.57,33.12)
TBT_PCIE_RBIAS: length 6.8
  TOP w0.109: RT34.1 35.45,36.87 35.45,37.44 35.01,37.88 33.65,37.88 33.02,37.25 33.02,36.1 32.8,35.88 32.42,35.88 v2(31.97,36.33)
  BOTTOM w0.102: UT1.N16 v2(31.97,36.33)
TBT_PERST#: length 125.8
  TOP w0.109: RT621.2 123.14,13.24 RT501.2 122.51,13.06 122.32,12.88 120.59,12.88 120.36,13.1 120.36,14.39 119.72,15.03 118.19,15.03 RT612.2 118.18,15.28 117.92,15.54 v1(116.58,15.54) 115.74,15.54 115.08,16.2 v2(115.08,17.06)
  IN1 w0.102: v2(58.84,13.8) 57.63,13.8 56.75,14.68 55.68,14.68 55.45,14.44 55.05,14.44 52.44,17.06 51.73,17.06 51.43,17.36 49.46,17.36 v2(49.27,17.56)
  IN3 w0.081: v2(49.27,17.56) 48.57,18.25 48.57,20.23 46.13,22.67 46.13,24.26 45.26,25.14 45.26,25.82 44.02,27.05 44.02,27.35 43.6,27.77 43.6,29.46 43.11,29.95 40.71,29.95 40.27,29.51 38.88,29.51 v2(37.67,28.3) ; v2(58.84,13.8) 58.89,13.84 63.85,13.84 64.81,12.88 75.04,12.88 75.52,13.36 75.52,15.83 76.54,16.85 82.94,16.85 84.44,15.35 93.78,15.35 94.69,16.26 103.31,16.26 103.56,16.52 114.38,16.52 114.92,17.06 v2(115.08,17.06) ; v2(37.68,32.52) 37.97,32.8 37.97,33.28 37.35,33.9 37.35,34.17 36.87,34.65 36.25,34.65 35.54,35.35 35.54,38.75 35.54,40 35.04,40.5 35.04,42.56 34.54,43.06 33.5,43.06 32.62,42.19 v2(32.61,42.19)
  IN4 w0.102: v2(37.67,28.3) 37.77,28.2 38.36,28.2 38.78,28.62 38.78,31.35 37.68,32.44 v2(37.68,32.52)
  BOTTOM w0.109: UT1.T4 v2(32.61,42.19)
TBT_PERST#_R: length 1.5
  TOP w0.109: UT34.4 121.9,13.26 RT501.1 RT611.2
TBT_PWR_EN: length 3
  TOP w0.102: UH1.BF15 174.21,36.47 172.16,36.47 T269.1
TBT_RBIAS: length 8.3
  TOP w0.109: v1(32.79,45.85) 32.27,45.33 30.9,45.33 RT39.1 30.25,44.68 30.25,44.12 29.63,43.5 29.49,43.5 28.32,42.33 28.32,41.99 28.7,41.61 v2(28.7,41.54)
  BOTTOM w0.109: UT1.J6 29.36,41.54 v2(28.7,41.54)
TBT_RESET_N_EC: length 213.9
  TOP w0.109: v2(27.4,41.53) 27.29,41.64 RT37.1 26.11,42.27 RT11.1 25.12,42.91 v1(25,43.03) ; v2(134.71,15.54) 134.71,15.65 RE506.2
  IN2 w0.081: v2(81.34,7.96) 81.34,7.39 80.42,6.46 77.82,6.46 76.56,7.72 70.56,7.72 70.12,7.28 69.68,7.28 67.12,4.72 65.79,4.72 64.78,3.72 64.24,3.72 63.96,3.44 63.49,3.44 63.22,3.71 63.22,4.43 62.15,5.5 59.37,5.5 58.92,5.96 52.54,5.96 50.98,4.4 50.98,2.29 50.03,1.34 43.66,1.34 42.4,2.6 42.4,5.68 40.92,7.15 36.7,7.15 36.24,6.68 29.43,6.68 28.81,6.06 26.1,6.06 22.32,2.28 14.46,2.28 9.99,6.75 7.31,6.75 3.74,10.32 3.74,22.15 6.14,24.54 v2(6.34,24.54)
  IN3 w0.081: v2(134.71,15.54) 134.28,15.11 133.57,15.11 133.48,15.03 132.7,15.03 131.13,13.46 130.79,13.46 130.11,12.78 128.69,12.78 127.74,11.83 126.79,11.83 125.78,12.84 122.13,12.84 122.01,12.72 119.7,12.72 119.28,13.14 113.09,13.14 112.51,13.72 95.44,13.72 93.25,11.52 89.33,11.52 88.44,10.63 86.72,10.63 85.93,9.84 83.09,9.84 81.34,8.09 v2(81.34,7.96) ; v2(6.34,24.54) 7.72,25.92 9.95,25.92 10.26,25.61 12.65,25.61 13.49,26.45 15.61,26.45 17.76,28.61 17.76,30.37 16.6,31.53 16.6,36.31 16.8,36.51 16.8,39.93 18.86,41.99 18.86,43.65 20.03,44.82 24.25,44.82 25.39,43.68 25.39,43.01 26.86,41.53 v2(27.4,41.53)
  BOTTOM w0.109: UT1.E5 27.73,41.87 v2(27.4,41.53)
TBT_RESET_N_EC_R: length 5.3
  TOP w0.109: RE95.2 RE506.1 135.18,20.86 135.53,21.21 UE1.L8
TBT_ROM_CLK: length 10.6
  TOP w0.109: UT2.6 41.89,40.69 41.68,40.49 41.68,40.07 40.09,38.48 v2(38.63,38.48)
  IN1 w0.102: v2(34.56,36.99) 36.22,38.66 38.46,38.66 v2(38.63,38.48)
  BOTTOM w0.109: UT1.Y16 v2(34.56,36.99)
TBT_ROM_CS#: length 13.2
  TOP w0.109: v2(33.91,36.34) v1(33.35,36.34) 33.25,36.44 33.25,37.1 33.8,37.64 34.91,37.64 35.21,37.34 35.21,35.34 35.45,35.1 36.05,35.1 36.39,35.44 36.82,35.44 37.06,35.67 37.06,35.84 RT2.1 37.87,36.65 38.91,36.65 39.35,36.21 UT2.1
  BOTTOM w0.109: UT1.W18 v2(33.91,36.34)
TBT_ROM_DI: length 14.1
  TOP w0.109: v1(43.41,43.07) 43.16,42.82 UT2.5 43.16,40.86 43.02,40.72 42.29,40.72 42,40.43 42,39.95 v2(40,37.95)
  IN1 w0.102: v2(40,37.95) 37.9,37.95 37.43,38.42 36.31,38.42 35.01,37.12 35.01,36.8 v2(34.56,36.34)
  BOTTOM w0.109: UT1.Y18 v2(34.56,36.34)
TBT_ROM_DO: length 11
  TOP w0.109: v2(33.91,36.99) 34.32,37.4 34.73,37.4 34.98,37.15 34.98,35.29 35.37,34.91 35.9,34.91 36.28,34.52 v1(36.57,34.52) 37.03,34.52 RT3.1 38.64,33.78 39.18,33.24 40.22,33.24 40.62,33.64 UT2.2
  BOTTOM w0.109: UT1.W16 v2(33.91,36.99)
TBT_ROM_HOLD#: length 3.6
  TOP w0.109: v1(42.18,43.72) 41.01,43.72 40.46,43.17 40.46,43.04 RT1.1 40.45,43.01 40.62,42.84 UT2.7
TBT_ROM_WP#: length 22.2
  TOP w0.109: RT4.1 44.29,33.87 43.97,34.19 43.97,35 43.47,35.5 42.72,35.5 42.54,35.68 41.52,35.68 v2(41.13,35.29) 41.27,35.15 41.75,35.15 41.89,35 UT2.3
  IN2 w0.081: v2(41.13,35.29) 41.13,35.18 40.44,34.49 37.99,34.49 37.12,35.36 37.12,36.51 37.57,36.96 37.57,37.22 36.95,37.84 36.95,38.39 34.99,40.35 34.99,40.54 34.99,42.34 34.72,42.61 34.11,42.61 33.91,42.41 v2(33.91,42.19)
  BOTTOM w0.109: v2(41.13,35.29) 41.3,35.12 v1(41.86,35.12) ; UT1.W4 v2(33.91,42.19)
TBT_RSENSE: length 4.5
  TOP w0.109: v2(29.36,42.19) 30.42,43.25 30.42,43.93 RT39.2 31.06,44.26 31.65,44.85 v1(31.88,44.85)
  BOTTOM w0.109: UT1.J5 v2(29.36,42.19)
TBT_RTD3_WAKE#: length 232.9
  TOP w0.109: RH735.2 165.97,21.49 164.43,21.49 164.22,21.7 164.22,23.64 164.57,23.98 v2(164.57,24.88) ; v2(39.31,43.71) 38.84,44.17 RT456.1 ; v2(38.31,49.52) 38.31,49.88 38.09,50.09 RT622.1
  IN1 w0.102: v2(39.31,43.71) 39.66,44.06 40.27,44.06 40.53,44.31 40.53,49.67 40.17,50.03 38.81,50.03 v2(38.31,49.52)
  IN2 w0.081: v2(192.18,12.31) 192.18,12.52 194.29,14.63 v2(194.29,15)
  IN3 w0.081: 158.08,20.81 158.38,20.81 159.74,22.17 160.22,22.17 161.99,23.94 161.99,24.75 162.7,25.46 163.41,25.46 163.99,24.88 v2(164.57,24.88) ; 158.08,20.81 157.21,19.94 157.21,19.18 157.75,18.64 157.75,16.61 157.11,15.97 157.11,14 159.13,11.97 159.13,11.22 159.41,10.95 161.07,10.95 161.84,10.18 165.84,10.18 165.99,10.33 168.06,10.33 168.17,10.44 178,10.44 178.81,11.24 185.94,11.24 186.25,10.94 191.24,10.94 192.18,11.88 v2(192.18,12.31) ; 158.08,20.81 158.02,20.87 158.02,21.81 158.58,22.37 159.35,22.37 159.66,22.67 160.02,22.67 160.59,23.24 160.59,24.02 160.42,24.2 159.97,24.2 159.08,25.09 159.08,29.13 160.03,30.09 160.03,31.31 159.51,31.83 158.6,31.83 156.54,33.89 156.54,38.16 153.31,41.39 151,41.39 150.62,41.78 150.19,41.78 149.92,42.05 141.61,42.05 140.01,43.64 138.62,43.64 138.53,43.73 136.99,43.73 136.47,43.21 125.65,43.21 124.01,41.58 117.48,41.58 116.82,42.24 116.82,42.24 114.76,44.3 106.96,44.3 106.15,45.11 97.14,45.11 93.14,41.11 91.71,41.11 91.1,40.5 88.46,40.5 88.05,40.09 84.9,40.09 84.52,39.71 81.65,39.71 79.86,41.5 74.59,41.5 73.1,42.99 71.6,42.99 70.41,41.79 69.83,41.79 67.14,39.11 67.14,38.98 67.14,38.81 66.79,38.45 66.29,38.45 66.15,38.59 58.7,38.59 58.16,38.04 58.16,37.33 57.84,37.01 56.87,37.01 56.56,37.32 56.02,37.32 55.79,37.55 55.79,37.6 55.16,38.24 53.64,38.24 53.35,38.53 49.95,38.53 49.32,37.91 46.95,37.91 46.66,37.61 46.16,37.61 44.88,38.89 44.22,38.89 43.82,39.29 43.82,40.19 40.81,43.2 39.82,43.2 v2(39.31,43.71)
  BOTTOM w0.109: v2(194.29,15) 194.29,15.05 194.18,15.16 194.13,15.16 RH732.2
TBT_RTD3_WAKE#_GPD7: length 9.7
  TOP w0.102: UH1.BE41 174.53,23.85 174.11,23.85 174.02,23.94 173.23,23.94 172.93,23.63 169.88,23.63 169.29,23.04 v1(168.91,23.04)
  TOP w0.109: RH602.1 167.49,22.06 RH735.1 167.49,22.51 168.02,23.04 v1(168.91,23.04)
TBT_RTD3_WAKE#_R: length 6.7
  TOP w0.109: UH1.T47 189.05,20.44 189.57,19.92 190.02,19.92 190.81,19.13 v2(190.84,19.13)
  BOTTOM w0.109: RH732.1 RH731.2 192.37,16.95 192.37,17.31 v1(191.63,18.05) 190.84,18.84 v2(190.84,19.13)
TBTA_CC1: length 72.4
  TOP w0.254: v2(6.69,46.4) 6.54,46.4 6.41,46.52 JUSBC1.B5
  TOP w0.508: v2(51.79,28.07) 51.64,27.93 50.43,27.93 50.26,28.1 49.56,28.1 48.97,28.68 CT352.1
  IN1 w0.508: v2(51.79,28.07) 50.77,28.07 50.46,28.39 49.21,28.39 48.41,29.19 46.73,29.19 45.27,30.65 41.61,30.65 40.09,32.17 39.57,32.17 38.86,32.88 v2(38.67,32.88)
  IN3 w0.508: v2(38.67,32.88) 38.67,33.17 37.77,34.08 37.77,34.35 37.38,34.74 37.38,36.58 37.63,36.83 37.63,37.33 36.02,38.94 36.02,40.12 35.46,40.68 35.46,42.89 35.33,43.02 35.33,44.57 35.78,45.01 35.78,46.88 35.28,47.38 33.86,47.38 32.19,45.7 30.03,45.7 29.77,45.44 28.41,45.44 28.17,45.21 26.66,45.21 25.5,46.36 24.47,46.36 24.25,46.13 19.38,46.13 17.57,44.31 17.57,43.25 v2(16.93,42.62)
  BOTTOM w0.076: 52.25,28.78 52.62,28.78 UT5.K2 52.62,28.29 52.26,28.29 52.05,28.07
  BOTTOM w0.089: 52.05,28.07 v2(51.79,28.07) 51.79,28.32 52.25,28.78
  BOTTOM w0.254: 13.89,45.07 13.74,45.07 13.32,45.49 DT7.9 DT7.1 11.37,45.49
  BOTTOM w0.457: 7.23,46.4 v2(6.69,46.4)
  BOTTOM w0.508: 7.23,46.4 9.73,46.4 10.46,45.67 11.18,45.67 11.37,45.49 ; v2(16.93,42.62) 16.34,42.62 v1(14.99,43.96) 13.89,45.07
TBTA_CC2: length 64.4
  TOP w0.254: 13.79,47.49 DT8.5 DT8.6 11.39,47.49 ; 8.32,47.65 8.07,47.65 7.95,47.77 7.45,47.77 JUSBC1.A5
  TOP w0.381: CT354.1 54.08,29.12 v2(54.08,28.98)
  TOP w0.508: 13.79,47.49 13.89,47.58 16.17,47.58 v2(16.6,47.15) ; 11.39,47.49 v1(11.08,47.49) 10.92,47.49 10.75,47.65 8.32,47.65
  IN1 w0.508: v2(43.96,33.52) 43.96,32.4 44.92,31.44 46.21,31.44 47.82,29.82 48.73,29.82 48.87,29.68 48.87,29.63 49.48,29.02 50.38,29.02 50.75,29.39 51.88,29.39 52.85,28.41 53.57,28.41 54.08,28.91 v2(54.08,28.98)
  IN3 w0.508: v2(16.6,47.15) 19.04,47.15 19.42,46.77 23.89,46.77 24.18,47.06 25.7,47.06 26.92,45.84 27.86,45.84 28.16,46.15 28.99,46.15 31.47,48.63 33.46,48.63 33.58,48.51 35.14,48.51 36.5,47.15 36.5,45.43 37.39,44.54 37.39,42.33 39.32,40.41 39.32,37.56 39.73,37.15 40.3,37.15 41.1,36.36 41.8,35.66 41.8,34.82 42.2,34.41 43.14,34.41 43.96,33.59 v2(43.96,33.52)
  BOTTOM w0.254: UT5.H2 53.87,28.76 v2(54.08,28.98)
TBTA_DPSRC_AUX_N_C: length 12.1
  IN1 w0.102: v2(56.68,35.18) 56.85,35.35 56.85,37.83 57.57,38.56 58.37,38.56 58.52,38.71 58.52,38.97 58.38,39.11 56.75,39.11 56.73,39.09 v2(56.73,39.11)
  BOTTOM w0.102: UT5.C11 56.54,33.21 56.54,33.25 56.54,33.26 56.54,33.88 56.88,34.21 56.88,34.99 56.76,35.1 56.68,35.18 v2(56.68,35.18) ; RT388.1 RT516.1 57.36,39.45 57.2,39.29 57.2,38.66 57.1,38.56 56.85,38.56 56.73,38.67 v2(56.73,39.11)
TBTA_DPSRC_AUX_P_C: length 12.1
  IN1 w0.102: v2(57.28,35.18) 57.04,35.42 57.04,37.75 57.65,38.37 60.14,38.37 60.49,38.02 v2(60.49,37.63)
  BOTTOM w0.102: v2(60.49,37.63) 60.49,39 60.03,39.45 RT523.1 RT387.1 ; UT5.B11 56.73,33.17 56.73,33.8 57.11,34.17 57.11,35.01 v2(57.28,35.18)
TBTA_HPD: length 41.5
  TOP w0.109: v2(49.69,31.12) 49.09,31.12 RT529.2 47.48,29.52 46.67,29.52 46.37,29.81 v1(46.37,30.46) 46.37,30.74 46.92,31.28 46.92,33.12 46.71,33.32 46.71,33.79 46.92,33.99 46.92,34.71 46.75,34.88 46.19,34.88 v2(45.9,35.17)
  IN2 w0.081: v2(35,51.03) 35.41,50.63 35.96,50.63 36.1,50.49 36.1,50.16 36.33,49.93 36.95,49.93 37.24,49.63 37.24,49.03 37.9,48.38 38.81,48.38 39.74,47.45 39.74,45.64 40.48,44.9 40.48,39.09 41.02,38.55 41.02,37.53 42.4,36.16 43.47,36.16 44.78,34.85 45.71,34.85 45.9,35.05 v2(45.9,35.17)
  BOTTOM w0.076: UT5.K7 52.62,31.28 52.16,31.28
  BOTTOM w0.109: RT619.1 33.85,48.25 RT23.1 34,49.04 34,50.3 34.74,51.03 v2(35,51.03) ; 52.16,31.28 51.66,31.28 51.62,31.32 49.9,31.32 v2(49.69,31.12)
TBTA_HPD_R: length 6.5
  BOTTOM w0.089: 32.61,44.26 32.61,43.9 32.59,43.88 32.59,43.45 UT1.T2
  BOTTOM w0.109: RT641.2 34.41,47.88 RT619.2 34.56,47.73 34.56,47.49 34.41,47.34 34.08,47.34 32.48,45.73 32.48,45.72 32.48,45.71 32.48,44.8 32.61,44.68 32.61,44.26
