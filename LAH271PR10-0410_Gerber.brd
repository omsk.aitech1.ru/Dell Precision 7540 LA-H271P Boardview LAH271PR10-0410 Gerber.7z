# Allegro board LAH271PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ISH_UART0_RTS#: length 25.4
  TOP w0.109: v2(159.94,32.22) 159.7,31.98 RZ81.2 ; v2(179.88,33.96) 179.79,34.05 UH1.AR18
  IN1 w0.102: v2(179.88,33.96) 180.08,33.77 180.08,32.31 179.77,32 174.83,32 174.21,32.62 172.08,32.62 170.8,33.9 166.91,33.9 166.31,33.3 163.82,33.3 162.8,32.29 161.67,32.29 161.15,32.81 160.52,32.81 v2(159.94,32.22)
ISH_UART0_RXD: length 7.9
  TOP w0.109: RZ78.2 167.96,34.19 169.75,34.19 170.25,34.69 171.09,34.69 v1(171.17,34.78) 171.34,34.94 172.36,34.94 172.53,35.12 173.43,35.12 173.5,35.04 174.18,35.04 UH1.BE17
ISH_UART0_TXD: length 5.6
  TOP w0.109: UH1.BF17 174.11,35.47 173.69,35.89 172.83,35.89 172.08,35.14 171.1,35.14 170.84,34.89 169.96,34.89 169.7,34.63 RZ79.2
IST_TRIG: length 6.7
  TOP w0.076: v2(220.46,88.21) 220.46,88.34 UC1.E3
  BOTTOM w0.102: T3.1 217.4,85.15 v2(220.46,88.21)
ITP_PMODE_CPU: length 161.2
  TOP w0.102: UH1.AL3 181.79,42.31 181.79,43.01 181.87,43.08 181.87,45.33 181.16,46.04 181.16,46.57 180.4,47.34 180.4,47.52
  TOP w0.109: 180.4,47.52 180.4,47.93 v2(179.93,48.39) ; v2(276.96,90.83) 275.99,91.81 RC144.2
  IN3 w0.081: v2(276.96,90.83) 277.07,90.94 280.6,90.94 281.37,90.16 281.37,87.6 281.73,87.24 281.73,79.43 v2(281.27,78.98)
  BOTTOM w0.109: v2(179.93,48.39) 179.49,48.39 178.93,48.95 176.96,48.95 176.63,49.28 176.63,50.8 178.22,52.39 178.22,53.01 180.89,55.68 180.89,57.85 189.09,66.05 v1(189.09,69.46) 189.09,70.35 190.61,71.87 190.61,74.68 191.33,75.39 191.33,77.27 193.17,79.12 193.17,79.79 194.95,81.57 197.62,81.57 198.45,82.39 204.4,82.39 210.7,76.1 253.59,76.1 254.32,75.36 272.98,75.36 276.23,78.61 279.35,78.61 279.57,78.39 280.17,78.39 280.76,78.98 v2(281.27,78.98)
JDIMM1_EVENT#: length 30.3
  IN2 w0.081: v2(242.75,47.97) 244.07,49.29 244.07,66.69 241.46,69.31 v2(240.31,69.31)
  BOTTOM w0.102: RD7.1 242.45,67.61 v1(241.4,68.65) 240.74,69.31 v2(240.31,69.31) ; 242.31,46.98 242.31,47.78 242.5,47.97 v2(242.75,47.97)
  BOTTOM w0.109: JDIMM1.134 242.18,46.84 242.31,46.98
JDIMM2_EVENT#: length 41.1
  TOP w0.102: JDIMM2.134 242.18,36.81 242.33,36.66 242.33,35.38 242.43,35.27 243.5,35.27 v2(243.96,35.73)
  IN2 w0.081: v2(243.96,35.73) 243.59,36.11 243.59,45.17 241.62,47.14 241.62,67.23 240.71,68.14 v2(240.31,68.14)
  BOTTOM w0.109: v1(239.69,67.76) 240.07,68.14 v2(240.31,68.14) 240.59,68.14 240.92,67.81 240.92,66.96 RD21.1
JDIMM3_EVENT#: length 3.4
  BOTTOM w0.102: RD29.1 v1(242.19,62.09) 242.19,60.86 242.18,60.84 JDIMM3.134
JDIMM4_EVENT#: length 27.4
  TOP w0.109: v2(242.78,49.46) 242.84,49.53 242.84,50.3 242.18,50.96 JDIMM4.134
  IN2 w0.081: v2(240.29,68.73) 241,68.73 242.97,66.76 242.97,56.17 243.5,55.65 243.5,50.18 v2(242.78,49.46)
  BOTTOM w0.102: RD45.1 241.56,67.85 240.68,68.73 v2(240.29,68.73)
  BOTTOM w0.109: v1(239.69,69.09) 240.05,68.73 v2(240.29,68.73)
JTAG_CLK: length 105.7
  TOP w0.102: UE1.C8 v2(135.93,28.05)
  IN3 w0.081: v2(57.25,4.68) 56.71,5.22 56.71,11.8 58.06,13.15 63.82,13.15 64.39,12.59 75.36,12.59 76.47,13.69 79.14,13.69 79.57,14.13 83.72,14.13 84.74,15.14 93.87,15.14 94.78,16.05 103.68,16.05 103.94,16.31 115.03,16.31 116.13,17.41 118.46,17.41 120.45,19.4 121.77,19.4 122.08,19.09 122.08,18.81 122.4,18.5 125,18.5 125.7,19.2 125.7,19.31 126.29,19.91 126.83,19.91 127.14,20.22 129.54,20.22 129.9,20.58 129.9,22.2 130.51,22.82 131.25,22.82 131.53,23.11 131.53,23.4 131.77,23.63 133.14,23.63 134.77,25.27 134.77,28.23 134.98,28.44 135.71,28.44 135.93,28.21 v2(135.93,28.05)
  BOTTOM w0.109: v2(57.25,4.68) JDEG1.4 57.25,2.8 57.78,2.27 v3(58.52,2.27) 61.43,2.27 61.69,2.01 RE741.2
JTAG_RST#: length 9.3
  TOP w0.104: RE63.1 145.2,28.54 JTAG1.1 143.74,28.54 143.62,28.66 RE65.1 142.18,27.83 142.18,27.55 v1(142.03,27.41) 141.63,27
  TOP w0.109: 141.63,27 141.63,26.57 141.23,26.17 141.23,25.42 140.26,24.45 UE1.G13 ; CE30.1 145.46,28.27 RE63.1
JTAG_TDI: length 107.5
  TOP w0.102: UE1.E9 v2(136.73,26.45)
  IN3 w0.081: v2(136.73,26.45) 136.35,26.07 135.82,26.07 135.55,25.79 135.55,24.52 134.95,23.93 134.95,23.18 134.65,22.88 131.76,22.88 131.52,22.63 131.52,22.23 131.33,22.05 130.95,22.05 130.71,21.8 130.71,20.66 129.29,19.24 129.28,19.24 129.28,19.24 128.94,19.24 128.94,19.24 127.19,19.24 125.12,17.17 122.52,17.17 121.21,15.86 104.13,15.86 103.86,15.59 95.05,15.59 93.54,14.08 84.82,14.08 84.25,13.5 80.63,13.5 79.04,11.92 79.04,11.11 78.71,10.77 78.38,10.77 78.09,11.06 77.66,11.06 76.36,12.36 64.29,12.36 63.71,12.95 58.18,12.95 56.94,11.7 56.94,5.63 57.81,4.75 57.81,4.42 57.6,4.21 56.55,4.21 v2(56.08,4.69)
  BOTTOM w0.109: RE739.2 52.05,2.62 52.53,2.14 v1(55.64,2.14) 56.1,2.14 56.31,2.35 56.31,3.07 56.25,3.13 JDEG1.2 56.25,4.51 v2(56.08,4.69)
JTAG_TDO: length 119.2
  TOP w0.102: UE1.F6 v2(133.53,25.65)
  IN2 w0.081: v2(54.35,4.54) 55.26,5.44 59.09,5.44 60.22,4.31 60.86,4.31 60.99,4.44 v2(61.76,4.44)
  IN3 w0.081: v2(133.53,25.65) 133.13,26.05 132.53,26.05 132.33,26.25 132.33,26.61 132.12,26.82 130.17,26.82 129.17,25.82 128.98,25.82 126.61,23.45 124.68,23.45 124.18,22.95 122.49,22.95 122.11,22.57 116.41,22.57 115.35,21.51 115.35,20.68 114.67,20 112.22,20 111.53,19.31 102.06,19.31 100.44,17.69 94.5,17.69 93.17,19.01 90.78,19.01 89.21,20.59 84.96,20.59 83.39,19.02 79.49,19.02 78.39,20.12 77.27,20.12 75.72,21.67 73.19,21.67 72.82,21.3 64.57,21.3 64.3,21.03 63.49,21.03 62.39,19.93 60.9,19.93 59.89,18.91 58.13,18.91 55.88,16.67 54.93,16.67 54.52,16.25 54.52,10.85 52.16,8.49 52.16,6.73 v2(54.35,4.54)
  BOTTOM w0.109: v2(61.76,4.44) 62.18,4.02 RE742.2 ; JDEG1.5 57.75,4.99 57.37,5.37 55.56,5.37 54.73,4.54 v2(54.35,4.54) 54.02,4.54 v3(53.72,4.83)
JTAG_TMS: length 114.8
  TOP w0.102: UE1.C5 v2(132.73,28.05)
  IN3 w0.081: v2(132.73,28.05) 132.36,27.68 130.68,27.68 129.05,26.05 128.88,26.05 126.53,23.7 124.61,23.7 124.08,23.17 122.36,23.17 121.99,22.8 116.31,22.8 113.74,20.23 112.13,20.23 111.44,19.55 101.98,19.55 101.28,18.85 93.66,18.85 93.27,19.24 90.88,19.24 89.3,20.82 84.86,20.82 84.02,19.97 80.43,19.97 80.25,20.15 79.25,20.15 78.53,20.87 78.53,22.17 77.91,22.79 77.24,22.79 76.35,21.9 73.09,21.9 72.72,21.53 64.48,21.53 64.21,21.26 63.39,21.26 62.31,20.17 58.06,20.17 56.26,18.37 54.48,18.37 54.31,18.2 54.31,10.96 51.93,8.59 51.93,5.51 v2(52.93,4.51)
  BOTTOM w0.109: RE740.2 v1(53.44,1.76) 56.23,1.76 56.75,2.28 JDEG1.3 56.75,4.82 56.47,5.1 55.65,5.1 54.67,4.12 54.07,4.12 53.95,4.23 53.21,4.23 v2(52.93,4.51)
KB_DET#: length 181.8
  TOP w0.089: UH1.AW15 v2(177.5,36.84)
  TOP w0.109: v2(242.38,15.55) 242.38,22.65 240.53,24.49 235.02,24.49 233.05,26.46 233.05,28 231.62,29.42 220.86,29.42 219.06,27.62 v2(219.06,21.42) ; RC74.2 165.29,36.29 v1(165.81,35.77) 165.81,35.58 v2(165.55,35.32) ; v2(281.34,3.33) 282.28,2.39 285.83,2.39 292.5,9.06 292.5,10.24 293.66,11.41 293.66,11.7 293.66,11.7 JKBTP1.1
  IN1 w0.102: v2(177.5,36.84) 177.42,36.84 176.29,35.71 173.67,35.71 173.35,36.03 169.44,36.03 169.2,35.79 168.23,35.79 167.36,34.91 165.96,34.91 v2(165.55,35.32) ; v2(242.38,15.55) 242.88,15.05 243.3,15.05 243.74,14.61 247.26,14.61 247.41,14.76 254.31,14.76 255.89,13.18 255.89,11.14 255.21,10.45 255.21,7.85 256.17,6.89 257.23,6.89 261.54,2.57 273.77,2.57 274.36,1.98 280,1.98 v2(281.34,3.33)
  IN3 w0.081: v2(219.06,21.42) 217.02,23.46 213.15,23.46 210.86,25.75 208.81,25.75 205.21,29.36 201.79,29.36 197.01,34.15 197.01,36.14 195.58,37.57 195.58,39.46 194.99,40.06 194.12,40.06 193.23,40.95 193.23,41.49 192.36,42.36 179.04,42.36 177.88,41.2 177.88,40.33 178.43,39.78 178.43,38.81 178.35,38.73 178.35,37.42 177.77,36.84 v2(177.5,36.84)
LAN_ACTLED_YEL#: length 4.4
  TOP w0.109: v2(194.09,129.57) 194.58,129.09 v1(194.58,128.8) 194.8,128.57 194.99,128.57 QL1.1
  BOTTOM w0.109: v2(194.09,129.57) 193.86,129.34 UL1.26
LAN_ACTLED_YEL#_Q: length 11.6
  TOP w0.109: RL14.1 202.75,131.75 v2(202.56,131.56) v1(201.87,131.56) ; QL1.6 195.96,129.67 v2(195.68,129.95)
  IN1 w0.102: v2(195.68,129.95) 196,129.63 197.56,129.63 198.21,130.28 198.21,131.17 199.23,132.19 201.93,132.19 v2(202.56,131.56)
LAN_DISABLE#_R: length 11.4
  BOTTOM w0.109: UL1.3 186.29,126.14 185.76,125.61 185.76,123.37 185.56,123.17 185.56,122.43 184.75,121.62 184.75,121.1 185.42,120.43 RL9.1 ; v1(184.01,118.22) 184.01,119.94 184.37,120.3 RL7.2 RL9.1 ; RL9.1 RL5.2
LAN_MDIN0: length 6.3
  BOTTOM w0.109: UL1.14 187.95,131.36 187.5,131.81 187.5,133.04 v4(186.49,134.05) 185.48,135.06 185.48,135.25 RL72.1
LAN_MDIN0_L: length 9.7
  TOP w0.109: v2(180.59,139.93) 180.52,140.01 180.52,140.65 180.9,141.03 TL1.2
  BOTTOM w0.109: v2(180.59,139.93) 180.52,139.86 180.52,139.63 180.73,139.42 v1(183.16,139.42) 184.28,139.42 185.5,138.21 185.5,136.92 RL72.2
LAN_MDIN1: length 5.9
  BOTTOM w0.109: RL74.1 188.16,135.36 188.16,134.77 188.54,134.4 189.19,133.74 v4(189.19,133) 189.19,132.32 189.66,131.85 189.66,131.16 189.55,131.04 UL1.18
LAN_MDIN1_L: length 7
  TOP w0.109: v2(185.67,140.14) 185.6,140.21 185.6,140.61 185.98,140.98 TL1.6
  BOTTOM w0.109: v2(185.67,140.14) 185.64,140.14 185.6,140.1 185.6,139.85 v1(185.89,139.55) 186.52,139.55 187.13,138.94 188.1,137.97 188.1,136.89 RL74.2
LAN_MDIN2: length 5.4
  BOTTOM w0.109: UL1.21 190.75,131.5 190.8,131.56 v4(190.8,132.81) 190.8,134.02 190.6,134.22 190.6,135.27 RL76.1
LAN_MDIN2_L: length 7.4
  TOP w0.109: v2(188.19,140.14) 188.14,140.18 188.14,140.68 188.52,141.06 TL1.8
  BOTTOM w0.109: RL76.2 190.61,136.9 v1(190.61,138.77) 189.83,139.55 188.53,139.55 188.11,139.96 188.11,140.07 v2(188.19,140.14)
LAN_MDIN3: length 3.4
  BOTTOM w0.109: UL1.24 191.95,130.59 191.95,130.75 192.3,131.11 193.1,131.11 193.71,131.73 193.71,132.15 RL78.1
LAN_MDIN3_L: length 8.9
  TOP w0.109: TL1.12 193.6,140.73 193.22,140.35 193.22,139.52 v2(193.29,139.45)
  BOTTOM w0.109: v2(193.29,139.45) 193.25,139.41 193.25,138.32 193.71,137.86 v1(193.71,136.97) 193.71,134.71 193.72,133.86 RL78.2
LAN_MDIP0: length 6.3
  BOTTOM w0.109: UL1.13 187.55,131.03 186.98,131.6 v4(186.98,132.17) 186.98,132.83 184.96,134.84 184.96,135.34 RL71.1
LAN_MDIP0_L: length 9.7
  TOP w0.109: v2(179.93,139.93) 180,140.01 180,140.63 179.63,141.01 TL1.1
  BOTTOM w0.109: RL71.2 184.99,136.89 184.99,137.99 184.07,138.91 v1(181.24,138.91) 180.51,138.91 180,139.42 180,139.86 v2(179.93,139.93)
LAN_MDIP1: length 6
  BOTTOM w0.109: RL73.1 187.65,135.21 187.65,134.56 v4(188.17,134.03) 188.68,133.53 188.68,132.11 189.15,131.64 UL1.17
LAN_MDIP1_L: length 7
  TOP w0.109: TL1.5 184.71,140.96 185.08,140.58 185.08,140.21 v2(185.01,140.14)
  BOTTOM w0.109: v2(185.01,140.14) 185.08,140.07 185.08,139.63 185.68,139.04 186.31,139.04 v1(187.05,138.3) 187.59,137.76 187.59,136.93 RL73.2
LAN_MDIP2: length 5.4
  BOTTOM w0.109: UL1.20 190.35,131.49 190.29,131.55 190.29,133.8 190.08,134.01 v4(190.08,134.19) 190.08,135.29 RL75.1
LAN_MDIP2_L: length 7.4
  TOP w0.109: v2(187.53,140.14) 187.62,140.24 187.62,140.58 187.25,140.96 TL1.7
  BOTTOM w0.109: v2(187.53,140.14) 187.6,140.07 187.6,139.75 188.31,139.04 v1(188.86,139.04) 189.62,139.04 190.09,138.56 190.09,136.91 RL75.2
LAN_MDIP3: length 3.4
  BOTTOM w0.109: UL1.23 191.55,131.08 192.09,131.63 v4(192.53,131.63) 192.88,131.63 193.2,131.94 193.2,132.16 RL77.1
LAN_MDIP3_L: length 8.9
  TOP w0.109: TL1.11 192.33,140.73 192.7,140.35 192.7,139.52 v2(192.63,139.45)
  BOTTOM w0.109: v2(192.63,139.45) 192.73,139.35 192.73,138.11 193.2,137.65 v1(193.2,135.3) 193.2,134.7 193.2,134.33 193.2,133.85 RL77.2
LAN_TEST_EN: length 3.4
  BOTTOM w0.109: UL1.30 193.26,127.74 193.31,127.69 194.07,127.69 194.23,127.86 RL12.1 194.91,128.55 v1(195.16,128.81)
LAN_WAKE#: length 186.8
  TOP w0.102: UE1.L3 v2(131.13,20.85)
  TOP w0.109: v2(182.84,57.58) 182.68,57.74 182.68,60.77 v1(189.63,67.72) 190.82,68.91 v2(190.82,69.65) ; UH1.BG44 171.95,22 171.26,21.31 v2(170.9,21.31) ; v2(196.61,102.67) 193.39,105.9 188.87,105.9 185.44,109.33 182.2,109.33 v2(181.87,109)
  IN2 w0.081: v2(182.84,57.58) 182.84,57.13 176.44,50.74 176.44,48.9 175.3,47.76 175.3,46.96 174.99,46.66 174.56,46.66 173.4,45.5 173.4,43.97 173.86,43.51 173.86,42.69 172.77,41.61 171.87,41.61 170.52,40.26 170.52,40.14 170.08,39.7 v2(169.58,39.7) 169.19,39.7 168.6,39.12 168.6,38.63 167.82,37.84 167.82,37.4 167.07,36.65 166.27,36.65 165.99,36.38 163.7,36.38 162.83,35.5 160.33,35.5 158.7,33.87 158.7,33.14 155.56,30 149.45,30 147.34,27.89 143.21,27.89 141.68,26.37 141.68,25.58 141.03,24.93 139.74,24.93 138.88,24.07 136.94,24.07 136.31,23.45 136.31,23.1 136.08,22.87 135.59,22.87 135.12,22.4 135.12,21.54 134.82,21.25 131.53,21.25 v2(131.13,20.85)
  IN3 w0.081: v2(181.87,109) 182.24,109 183.4,110.16 183.4,115.22 185.25,117.07 185.25,120.33 v2(185.99,121.07) ; v2(196.61,102.67) 196.61,98.37 197.22,97.76 197.22,96.02 197.58,95.66 197.58,92.6 196.04,91.06 196.04,89.68 197.33,88.38 197.33,86.76 195.41,84.83 195.41,82.5 196.64,81.27 196.64,74.11 192.18,69.65 v2(190.82,69.65)
  IN4 w0.102: v2(169.58,39.7) 170.16,39.11 170.16,38.38 168.02,36.24 168.02,35.07 167.52,34.56 167.52,32.02 168.02,31.52 168.02,30.92 167.78,30.68 167.78,27.54 168.41,26.91 168.41,26.18 168.18,25.94 168.18,25.03 170.07,23.14 170.07,21.92 170.68,21.31 v2(170.9,21.31)
  BOTTOM w0.109: RH93.1 171.43,21.51 171.23,21.31 v2(170.9,21.31) ; RL10.1 186.29,121.37 v2(185.99,121.07)
LCD_CBL_DET#: length 127.4
  TOP w0.102: UH1.AW24 177.26,32.32 v2(177.26,32.47)
  TOP w0.109: v2(102.31,42.36) 102.31,41.89 102.59,41.61 103.56,41.61 103.8,41.85 103.8,42.59 104,42.79 JEDP1.20
  IN2 w0.081: v2(177.26,32.47) 176.62,33.1 176.07,33.1 174.45,34.71 171.57,34.71 171.01,34.15 169.57,34.15 168.05,32.63 167.56,32.63 167.43,32.5 167.43,32.07 167.97,31.53 167.97,30.79 167.59,30.41 167.59,29.28 167.09,28.77 165.03,28.77 163.26,27.01 160.65,27.01 160.06,26.41 159.2,26.41 158.2,25.41 153.87,25.41 152.75,24.29 150.01,24.29 145.13,19.41 141.76,19.41 141,18.65 141,17.48 139.94,16.42 138.42,16.42 137.92,15.93 135.48,15.93 135.17,16.24 133.51,16.24 133.32,16.05 132.3,16.05 131.73,15.48 126.82,15.48 126.3,14.96 124.28,14.96 123.98,14.66 123.28,14.66 122.56,15.38 119.75,15.38 118.51,16.62 118.51,17.04 118.15,17.41 116.23,17.41 114.78,18.86 113.51,18.86 111.12,21.25 106.67,21.25 106.5,21.08 104.47,21.08 103.95,21.61 103.95,22 v2(100.45,25.5)
  BOTTOM w0.109: v2(102.31,42.36) 101.95,42.36 v1(101.57,41.97) 100.58,40.99 99.85,40.99 99.21,40.35 99.21,39.7 98.46,38.95 97.4,38.95 95.99,37.54 95.99,36.01 95.74,35.77 95.74,34.3 96.36,33.68 96.36,31.45 97.91,29.9 97.91,28.48 98.98,27.4 98.98,25.09 99.11,24.96 99.91,24.96 v2(100.45,25.5) ; RC370.1 173.63,31.85 176.84,31.85 177.26,32.26 v2(177.26,32.47)
LCD_TST: length 56.5
  TOP w0.109: v2(127.59,18.24) 127.59,17.61 RE20.1 128.06,17.9 128.06,18.37 128.7,19.02 129.05,19.02 129.57,19.54 129.57,19.76 129.82,20.02 130.05,20.02 130.48,20.45 UE1.M2 ; JEDP1.24 106,42.59 105.77,42.36 v2(104.29,42.36)
  IN2 w0.081: v2(102.17,26.77) 102.17,26.59 103.02,25.74 108.46,25.74 109.14,25.06 114.36,25.06 117.91,21.51 118.93,21.51 119.39,21.05 120.18,21.05 120.7,20.53 122,20.53 122.32,20.21 122.32,20.2 123.01,19.51 123.01,19.51 123.05,19.47 123.48,19.47 124.07,18.89 125.23,18.89 126.28,17.83 127.26,17.83 127.59,18.16 v2(127.59,18.24)
  BOTTOM w0.109: v2(104.29,42.36) 103.66,41.72 102.3,41.72 101.72,41.14 101.72,40.07 100.45,38.8 100.45,36.5 100.81,36.14 v1(100.81,35.23) 100.81,35.01 100.45,34.65 100.45,32.35 100.55,32.25 100.55,30.96 102.17,29.35 v2(102.17,26.77)
LCD_VCC_TEST_EN: length 40.7
  TOP w0.109: DV3.2 133.14,44.83 130.18,44.83 v2(127.94,47.08) ; UE1.E1 129.52,26.05 127.3,28.27 126.26,28.27 126.05,28.47 124.38,28.47 123.01,29.84 v2(123.01,30.56) ; v2(123.89,35.92) 125.24,35.92 126.76,37.45 v1(126.76,40.2) 126.76,46.78 v2(126.53,47.01)
  IN3 w0.081: v2(126.53,47.01) 127.86,47.01 v2(127.94,47.08)
  BOTTOM w0.109: v2(123.01,30.56) 123.01,31.1 121.25,32.86 121.25,34.9 122.09,35.75 123.72,35.75 v2(123.89,35.92)
LDO_IN: length 10.2
  BOTTOM w0.254: UT7.1 28.51,22.32 CT374.1 30.18,23.37 DT62.1 30.79,23.99 DT60.1 32.73,24.71 v1(32.73,24.92) 32.4,25.25 32.4,25.73 DT63.1 32.8,27.36 DT64.1 32.78,27.35 32.35,27.35 RT543.1
LED_10_GRN#: length 11.5
  TOP w0.109: RL30.2 200.34,132.37 QL7.3 199.54,132.18 199.2,132.52 196.53,132.52 196.29,132.28 UL2.2 196.29,131 v2(196.64,130.66)
  BOTTOM w0.109: v2(196.64,130.66) v1(194.81,130.66) 194.45,130.66 193.53,129.74 UL1.25
LED_10_GRN#_Q: length 31.2
  TOP w0.109: v1(199.66,129.54) 199.2,130.01 v2(199.2,131.53) QL7.1 ; v2(220.68,141.46) 220.94,141.46 RL19.1
  IN1 w0.102: v2(220.68,141.46) 218.71,139.49 218.71,138.17 216.1,135.56 213.96,135.56 213.05,134.65 208.19,134.65 204.53,130.99 199.74,130.99 v2(199.2,131.53)
LED_100_ORG#: length 10.6
  TOP w0.109: UL2.1 195.64,131.02 196.47,130.19 v2(197.47,130.19) 197.77,130.19 RL29.2 197.86,129.19 QL1.4
  BOTTOM w0.109: v2(197.47,130.19) 197.43,130.24 v1(196.19,130.24) 196.03,130.4 195.52,130.4 194.16,129.04 193.33,129.04 193.23,128.94 UL1.27
LED_100_ORG#_Q: length 31.4
  TOP w0.109: RL20.1 221.1,139.18 v2(219.15,139.18) ; v2(197.69,128.29) 197.26,127.87 QL1.3 198.17,127.59 v1(198.36,127.4)
  IN1 w0.102: v2(197.69,128.29) 200.06,130.66 204.52,130.66 208.28,134.42 213.14,134.42 213.99,135.27 216.13,135.27 219.15,138.28 v2(219.15,139.18)
LED_MASK#: length 340.7
  TOP w0.102: v2(138.92,29.84) 138.92,29.44 UE1.A12
  TOP w0.109: v2(200.85,131.53) 200.85,131.16 200.57,130.88 QL7.2 200.15,127.57 199.22,126.64 193.25,126.64 192.61,127.28 192.61,129.62 193.51,130.52 195.8,130.52 196.61,129.71 QL1.5 196.61,128.73 196.8,128.54 196.8,128.06 196.61,127.87 QL1.2 ; v2(291.08,66.67) 291.03,66.72 282.03,66.72 279.58,69.17 279.58,69.9 277.52,71.96 265.16,71.96 264.65,71.44 264.56,71.36 246.16,71.36 241.49,66.68 239.72,66.68 236.03,70.37 213.24,70.37 202.43,81.18 199.02,81.18 197.53,79.68 197.53,77.21 196.54,76.22 196.54,74.28 195.57,73.32 195.57,66.06 v1(195.08,65.58) 194.1,64.59 v2(193.56,64.59) ; UZ10.1 314.89,42.17 315.51,42.79 315.51,44.57 v2(315.67,44.74)
  IN2 w0.081: v2(138.92,29.84) 139.11,30.03 141.98,30.03 142.39,30.44 144.33,30.44 144.45,30.31 145.4,30.31 146.46,31.38 152.04,31.38 152.47,31.81 155.21,31.81 156.15,32.75 157.34,32.75 157.89,33.29 157.89,34.03 160.72,36.86 162.61,36.86 163.49,37.75 166.75,37.75 167.73,38.73 167.73,39.22 169.1,40.58 169.87,40.58 172.22,42.92 172.22,43.63 172.71,44.12 172.71,45.82 172.82,45.92 172.82,47.53 173.76,48.48 175.05,48.48 175.62,49.06 175.62,50.89 181.63,56.9 181.63,58.07 182.61,59.05 185.48,59.05 186.66,60.22 187.15,60.22 187.96,59.4 189.53,59.4 190.06,59.93 190.06,60.82 190.61,61.37 192.32,61.37 193.56,62.61 v2(193.56,64.59) 193.56,64.74 193.05,65.25 193.05,72.49 190.77,74.76 190.77,77.26 190.13,77.9 190.13,87.21 189.24,88.1 188.21,88.1 188.07,88.24 188.07,90.8 188.22,90.96 188.22,92.05 189.55,93.37 189.55,95.84 188.25,97.15 188.25,105.04 189.4,106.2 191.16,106.2 v2(192.58,107.62) ; v2(315.67,44.74) 315.11,44.74 299.99,59.86 298.52,59.86 291.7,66.67 v2(291.08,66.67)
  IN3 w0.081: v2(192.58,107.62) 192.58,108.25 193.62,109.28 193.62,121.98 193.1,122.5 193.1,123.31 193.69,123.9 193.69,126.13 193.21,126.62 193.21,129.39 195.95,132.14 200.24,132.14 v2(200.85,131.53)
  BOTTOM w0.109: RE21.1 138.84,29.92 v2(138.92,29.84)
LG_1.2V: length 29.9
  TOP w0.109: v2(205.27,9.2) 205.93,8.53 v1(205.93,8.32)
  BOTTOM w0.762: 222.1,6.99 223.28,5.81 223.28,2.58 222.34,1.64 207.98,1.64 204.67,4.95 204.67,6.8 204.04,7.43 204.04,8.15
  vias: v2(204.85,9.61) v2(221.94,8.73) v2(221.97,8.12)
LG_+1VSP: length 9.2
  BOTTOM w0.762: 144.78,7.21 144.78,7.35 146.93,9.5 146.93,10.39 v3(148.45,11.91) 148.64,11.91 150.48,13.76 150.48,13.97
  vias: v2(144.73,6.46) v2(145.37,6.47) v2(151.47,14.05) v2(152.01,14.43)
LGATE_CHG: length 17.1
  TOP w0.109: v2(290.8,28.96) v1(290.8,28.24)
  IN3 w0.762: 290.55,28.23 290.55,22.34 294.59,18.3 299.36,18.3 299.37,18.31
  vias: v2(290.33,29.37) v2(300.53,18.41) v2(300.56,17.82)
LID_CL#: length 269.4
  TOP w0.109: UZ10.2 315.54,41.38 316,40.91 317.71,40.91 317.82,41.03 v2(318.48,41.03) 318.48,40.3 v3(317.9,39.72) ; v2(315.91,8.7) 315.91,8.77 315.57,9.11 315.46,9.11 315.17,9.4 314.81,9.76 JLED1.5 ; v2(139.23,15.38) 139.17,15.38 RE26.1
  IN1 w0.102: v2(318.48,41.03) 318.48,41.47 317.17,42.77 311.47,42.77 310.89,43.36 310.89,43.77 307.53,47.13 305.92,47.13 301.9,51.15 297.2,51.15 293.38,47.33 292.29,47.33 289.16,44.21 282.9,44.21 274.66,35.97 274.66,34.58 273.17,33.09 273.17,27.61 270.56,25 265.05,25 261.51,28.54 v2(255.69,28.54)
  IN3 w0.081: v2(206.36,5.15) 206.38,5.15 207.17,5.94 207.17,7.76 212.5,13.08 228.17,13.08 232.31,17.22 247.8,17.22 255.44,24.87 255.44,28.29 v2(255.69,28.54)
  IN4 w0.102: v2(139.23,15.38) 140.16,15.38 140.59,15.82 142.47,15.82 143.08,15.21 144.45,15.21 147.78,18.54 147.78,20.21 148.98,21.41 150.43,21.41 151.23,20.61 151.87,20.61 152.34,20.13 153.88,20.13 155.95,18.07 157.02,18.07 157.47,17.62 160.26,17.62 161.17,16.71 162.32,16.71 162.9,16.13 163.64,16.13 164.15,15.63 164.97,15.63 166.54,14.06 172.27,14.06 173.25,13.08 173.25,12.25 173.84,11.66 174.93,11.66 175.39,11.2 176.48,11.2 178.29,9.4 179.38,9.4 180.6,8.18 187.29,8.18 187.99,8.88 195.67,8.88 196.64,7.9 200.29,7.9 201.55,6.64 203.45,6.64 204.94,5.15 v2(206.36,5.15)
  BOTTOM w0.109: v2(318.48,41.03) 318.48,40.58 318.22,40.32 318.22,37.75 321.18,34.78 321.18,29.13 318,25.95 318,24.16 315.18,21.35 315.18,12.65 315.02,12.48 315.02,9.3 315.21,9.11 315.56,9.11 315.91,8.76 v2(315.91,8.7)
LID_CL#_PCH: length 1.1
  TOP w0.089: v2(177.98,26.34) 178.23,26.59 UH1.AV34
  BOTTOM w0.109: T268.1 177.81,26.16 v2(177.98,26.34)
LID_CL_SIO#: length 5.6
  TOP w0.109: v1(138.86,14.95) 138.62,14.95 137.7,15.88 RE26.2 RE25.2 137.7,16.88 137.67,16.91 CE8.1 137.67,17.92 137.52,18.07 137.52,18.95 137.93,19.36 UE1.N11
LINE1-L: length 2.9
  TOP w0.203: UA1.36 348.79,25.43 349.09,25.73
  TOP w0.254: 349.09,25.73 349.32,25.73 v1(349.43,25.85) 350.02,25.85 350.46,25.4 CA43.1
LINE1-R: length 3.4
  TOP w0.203: 349.11,25.3 348.83,25.03 UA1.35
  TOP w0.254: CA44.1 349.84,24.38 349.84,25.11 349.56,25.39 349.19,25.39 349.11,25.3
LOM_CABLE_DETECT#: length 168.9
  TOP w0.109: v2(128.2,28.88) 128.2,28.33 129.25,27.29 130.25,27.29 130.69,26.85 UE1.D2 ; v1(159.77,52.05) 160.2,51.61 v2(160.35,51.61) ; UL2.4 196.94,134.36 v2(197.08,134.5)
  IN3 w0.081: v2(160.35,51.61) 160.71,51.26 161.38,51.26 180.7,70.58 180.7,74.44 179.59,75.55 179.59,78.4 182.64,81.46 183.38,81.46 185.16,83.23 185.16,84.54 185.99,85.37 185.99,88.14 187.44,89.59 187.44,92.05 186.74,92.75 186.74,114.29 188.56,116.11 188.56,121.22 186.23,123.55 186.23,125.27 186.82,125.86 186.82,128.75 188.61,130.53 192.11,130.53 195.46,133.88 196.46,133.88 v2(197.08,134.5)
  BOTTOM w0.109: v2(128.2,28.88) 127.77,29.31 127.38,29.31 126.87,29.82 126.87,30.28 123.74,33.41 RE505.1 123.76,34.33 124.24,34.8 125.01,34.8 126,35.79 126,36.38 126.75,37.12 126.75,38.55 126.72,38.58 126.72,39.09 126.74,39.17 126.89,39.55 126.89,45.39 127.62,46.13 128.34,46.13 129.88,47.68 134.96,47.68 135.51,47.12 137.8,47.12 138.16,46.76 139.35,46.76 141.44,48.85 151.58,48.85 151.89,49.17 155.08,49.17 158.01,52.09 159.88,52.09 v2(160.35,51.61)
LPS_OFF2: length 36.2
  TOP w0.109: PR31.2 48.45,20.88 47.94,21.39 47.54,21.39 47.32,21.6 PQ4.6 v2(47.92,21.84) ; JIO1.1 65.05,6.87 65.29,7.12 v2(65.44,7.12)
  IN1 w0.102: v2(51.05,7.41) 52.03,7.41 53.7,5.73 63.91,5.73 65.29,7.12 v2(65.44,7.12)
  IN3 w0.081: v2(51.05,7.41) 51.05,7.56 50.65,7.95 50.65,11.38 49.53,12.51 49.53,14.96 50.06,15.5 50.06,18.33 48.8,19.58 48.8,20.95 v2(47.92,21.84)
  BOTTOM w0.109: v2(65.44,7.12) 65.48,7.12 66.05,7.69 v1(66.05,7.8)
LPS_OFF3: length 30.6
  TOP w0.109: JIO1.3 64.55,6.94 65.06,7.45 v2(65.06,7.87) v1(64.54,7.87)
  IN2 w0.081: v2(55.88,17.9) 57.6,17.9 58.36,18.65 59.86,18.65 60.23,18.28 60.23,18.28 61.39,17.12 61.39,16.07 64.81,12.65 66.92,12.65 67.44,12.13 67.44,9.24 66.7,8.5 66.36,8.5 65.72,7.87 v2(65.06,7.87)
  BOTTOM w0.109: PR48.2 51.18,20.95 51.37,20.76 53.44,20.76 53.62,20.58 53.62,20.35 53.9,20.07 PQ7.6 54.23,20.07 54.5,19.8 54.5,18.76 54.89,18.37 55.41,18.37 v2(55.88,17.9)
LPS_OFF_BATT: length 5
  TOP w0.109: v2(62.03,8.44) 62.69,8.44 v1(62.81,8.32) 63.05,8.08 JIO1.9
  BOTTOM w0.109: v2(62.03,8.44) 61.76,8.44 PR734.2
LPS_OFF_BATT_R: length 34.8
  IN2 w0.381: v2(35.3,8.37) 36.02,9.1 57.09,9.1 57.84,8.35 58.63,8.35 v2(58.79,8.51)
  BOTTOM w0.109: v1(61.86,15.73) 61.13,15 PQ705.2
  BOTTOM w0.381: v2(58.79,8.51) 59.53,9.25 PR733.2 PR734.1 61.13,11.11 PQ705.2 ; v2(35.3,8.37) 35.23,8.43 QT10.2
LX_1.2V: length 12.8
  BOTTOM w0.762: 206.64,8.07 207.38,7.32 207.38,5.11 209.07,3.42 215.53,3.42 216.02,3.92
  vias: v2(206.38,8.79) v2(206.47,9.44) v2(216.82,4.16) v2(217.49,4.16) v3(216.91,1.6)
LX_1.8V: length 1.3
  TOP w0.109: v1(130.05,1.88) 130.47,2.3 130.47,3.05
LX_2.5V:
  vias: v1(288.53,48.02)
LX_3V:
  vias: v1(109.39,2.62)
LX_3VR:
  vias: v2(308.8,27.59) v2(309.41,27.59) v2(312.81,27.61) v2(313.28,27.96) v3(310.61,27.28)
LX_5V:
  vias: v2(68.23,19.92) v2(68.23,19.28) v2(68.87,19.92) v2(68.87,19.28) v2(69.5,19.92) v2(69.5,19.28) v2(70.14,19.92) v2(70.14,19.28) v2(70.77,19.92) v2(70.77,19.28) v2(71.41,19.92) v2(71.41,19.28) v2(72.04,19.92) v2(72.04,19.28) v2(72.68,19.92) v2(72.68,19.28) v3(70.21,17.5)
LX_5VR:
  vias: v2(307.43,37.48) v2(308.02,37.48) v2(311.57,37.49) v2(312.06,37.88) v3(309.44,37.19)
LX_+1VSP: length 5.6
  BOTTOM w0.762: 150.04,11.16 150.04,10.95 v3(148.88,9.79) 146.71,7.62 146.71,6.9
  vias: v2(146.43,6.24) v2(147.03,6.24) v2(150.65,12.2) v2(150.99,12.67)
LX_CHG: length 9.6
  IN3 w0.762: 294.84,24.75 294.11,25.48 294.11,30.11 291.9,32.32
  BOTTOM w0.109: v2(294.7,23.78) v3(293.89,23.78)
  vias: v2(290.46,32.09) v2(291.06,32.08) v2(295.31,23.77)
LX_IO: length 0.7
  BOTTOM w0.109: 278.04,103.98 v1(278.77,103.98)
M2_SLOT3_PEDET: length 159.7
  TOP w0.089: UH1.AJ43 v2(182.08,22.74)
  IN1 w0.102: v2(75,20.77) 75,20.78 73.67,20.78 73.35,20.46 73.35,13.44 74.02,12.77 76,12.77 77.97,10.8 78.97,10.8 79.38,11.21 79.38,11.93 80.56,13.11 83.87,13.11 84.55,12.43 92.42,12.43 93.48,11.37 109.32,11.37 112.23,8.47 115.1,8.47 115.68,9.04 118.61,9.04 118.82,9.26 122.29,9.26 123.01,9.98 126.47,9.98 127.07,9.38 134.71,9.38 134.92,9.59 137.31,9.59 138.8,11.08 140.15,11.08 140.99,11.92 142.43,11.92 143.06,12.55 146.02,12.55 146.36,12.9 146.36,14.55 146.91,15.09 147.82,15.09 148.57,15.85 149.95,15.85 150.2,16.1 154.02,16.1 154.22,15.9 155.21,15.9 156.4,14.71 158.64,14.71 159.46,13.89 160.77,13.89 162.51,12.15 163.53,12.15 164.16,12.77 166.63,12.77 168.36,11.04 172.27,11.04 173.26,10.05 175.57,10.05 177.22,8.41 178.63,8.41 179.06,7.98 v2(179.17,7.98)
  BOTTOM w0.109: v2(75,20.77) 74.72,20.77 73.12,22.38 73.12,24.27 75.23,26.38 v1(75.23,27.14) 75.23,30.57 RN200.1 74.66,32.2 JNGFF3.61 ; v2(179.17,7.98) 180.15,8.96 180.15,10.43 181.33,11.61 181.33,14.25 181.66,14.58 181.66,20.48 182.18,21.01 182.18,22.63 v2(182.08,22.74)
M2_SLOT4_PEDET: length 190.4
  TOP w0.089: 181.31,19.5 181.31,19.73 181.12,19.92 181.12,20.9 UH1.AM46
  TOP w0.102: v2(179.86,13.86) 179.86,14.16 180.43,14.74 180.85,14.74 181.2,15.08 181.2,17.83 v1(181.13,17.9) 181.13,18.33 181.31,18.51 181.31,19.5
  IN2 w0.081: v2(344.49,10.24) 342.66,10.24 341.68,9.26 334.58,9.26 334.58,9.26 329.2,9.26 328.73,8.79 327.17,8.79 324.62,6.24 323.52,6.24 320.89,3.61 313.3,3.61 312.6,4.31 309.31,4.31 308.14,3.13 306.11,3.13 303.59,5.65 291.27,5.65 290.31,4.69 286.61,4.69 284.17,7.13 281.62,7.13 281.06,6.58 277.94,6.58 273.9,10.61 271.34,10.61 270.36,11.59 270,11.59 268.25,13.34 268.25,14.05 265.3,17 251.34,17 250.43,16.1 220.37,16.1 219.34,15.06 218.18,15.06 v2(217.94,15.3)
  IN3 w0.081: v2(179.86,13.86) 179.86,13.98 180.23,14.35 182,14.35 182.29,14.05 186.81,14.05 187.5,14.74 189.1,14.74 190.51,16.15 217.36,16.15 217.94,15.57 v2(217.94,15.3)
  BOTTOM w0.109: v2(344.49,10.24) 345.4,11.15 RN203.1 345.9,11.14 JNGFF4.69
M2_SLOT5_PEDET: length 141.3
  TOP w0.109: UH1.AN47 180.39,19.84 179.99,19.44 179.47,19.44 179.14,19.11 179.14,18.26 179.35,18.05 179.35,17.57 179.15,17.36 179.15,17.05 178.8,16.7 178.8,14.04 174.32,9.56 166.1,9.56 163.87,11.8 163.87,12.17 164.38,12.67 164.38,13.93 163.15,15.15 159.04,15.15 v2(158.38,15.82) ; RN208.1 v1(81.12,9.54) 81.12,9.14 v2(81.3,8.96)
  IN1 w0.102: v2(77.65,8.41) 80.76,8.41 v2(81.3,8.96)
  BOTTOM w0.109: v2(77.65,8.41) 77.65,7.75 77.05,7.15 JNGFF5.61 ; v2(81.3,8.96) 81.67,9.32 84.49,9.32 84.97,9.8 86.15,9.8 87.64,11.29 92.5,11.29 93.94,12.73 109.28,12.73 109.77,13.22 116.94,13.22 117.56,12.6 117.56,11.2 115.1,8.74 114.72,8.74 114.53,8.55 114.53,6.31 115.27,5.57 120.39,5.57 121.99,3.98 124.58,3.98 125.03,3.54 128.84,3.54 129.98,4.68 129.98,6.21 131.48,7.71 135.17,7.71 135.49,8.03 137.58,8.03 138.48,8.93 140.16,8.93 141.95,10.72 143.37,10.72 144.61,11.96 144.61,13.38 148.12,16.9 155.45,16.9 155.75,16.59 157.84,16.59 158.38,16.05 v2(158.38,15.82)
M3042_PCIE#_SATA: length 3.7
  TOP w0.109: UE1.J12 139.15,22.43 139.84,22.43 140.95,23.55 T309.1
M_BIST: length 7.2
  TOP w0.109: RZ1415.2 137.12,13.65 136.02,14.75 135.52,14.75 v1(135.45,14.82) 135.33,14.94 135.33,15.49 135.64,15.79 135.64,17.43 135.53,17.53 UE1.N8
M_BIST_R: length 6.6
  TOP w0.109: DZ12.2 134.94,11.85 135.07,11.73 CZ218.1 136.1,11.84 136.1,12.81 RZ1482.2 137,12.88 RZ1415.1 137.16,12.76 RZ1413.2 138.09,12.81 139,12.81 v1(139.05,12.76) 139.09,12.72 139.09,12.05 QZ22.2
MACO_EN: length 130.2
  TOP w0.109: UH1.AP29 179.89,29.11 v2(180.12,28.88) ; v2(170.4,97.74) 170.4,97.68 170.79,97.29 172.06,97.29 172.27,97.49 JDGFF2.F9
  IN1 w0.102: v2(181.22,59.42) 184.66,59.42 186.2,57.89 189.55,57.89 190.14,57.31 192.98,57.31 194.54,55.74 v2(194.62,55.74)
  IN2 w0.081: v2(180.12,28.88) 180.12,28.89 181.07,29.84 181.07,30.21 180.27,31.01 180.27,32.73 181.3,33.76 181.3,36.22 181.64,36.55 181.64,37.66 182.68,38.71 182.68,39.61 181.96,40.33 181.96,41.25 182.2,41.49 182.2,43.47 185.27,46.54 185.27,46.87 186.31,47.91 186.31,53.35 188.22,55.26 194.14,55.26 v2(194.62,55.74)
  IN4 w0.102: v2(177.69,97.96) 177.02,97.29 170.86,97.29 v2(170.4,97.74)
  BOTTOM w0.109: v2(181.22,59.42) 180.8,59.84 180.8,60.73 v1(181.81,61.74) 181.91,61.84 183.55,61.84 187.32,65.61 187.32,70.25 189.06,71.99 189.06,77.01 194.56,82.52 197.01,82.52 198.93,84.44 198.93,87.72 198.01,88.65 196.35,88.65 195.71,89.29 192.65,89.29 192.32,89.62 192.32,93.74 190.68,95.38 188.77,95.38 188.36,94.97 187.04,94.97 186.77,95.24 186.77,95.6 186.62,95.75 185.31,95.75 185.04,96.02 182.22,96.02 180.28,97.96 v2(177.69,97.96)
MASK_BASE_LEDS#: length 2.6
  TOP w0.109: UZ10.4 v1(316.19,44.55) 316.19,45.2 315.75,45.64 QZ7.2
MDP_CA_DET: length 25.3
  TOP w0.109: UV8.33 187.97,120.15 v2(187.92,120.11) ; v2(176.53,128.21) 176.47,128.27 JDGFF4.F2
  IN3 w0.081: v2(187.92,120.11) 187.92,121.18 185.78,123.32 185.78,125.46 186.37,126.05 186.37,126.87 185.92,127.31 185.04,127.31 184.87,127.14 184.87,125.58 184.41,125.12 181.19,125.12 177.58,128.73 176.77,128.73 176.53,128.49 v2(176.53,128.21)
  BOTTOM w0.109: RV131.2 188.43,119.6 v2(187.92,120.11) 187.92,120.22 v1(187.58,120.57)
ME_FWP: length 292.1
  TOP w0.102: UE1.G12 v2(139.13,24.85)
  TOP w0.109: v2(335.22,7.07) 335.21,7.08 335.21,8.26 334.91,8.56 334.91,9.95 334.32,10.54 334.32,11.88 333.42,12.79 333.42,14.92 332.86,15.48 332.86,15.7 332.38,16.17 331.28,16.17 330.8,16.65 330.8,19.04 331.71,19.96 331.71,21.44 331.49,21.66 331.49,23.95 332.96,25.42 332.96,25.94 333.39,26.37 334.47,26.37 335.7,27.6 337.35,27.6 337.57,27.82 SW1.1 337.57,30.44 337.14,30.88 336.26,30.88 334.76,32.38 334.76,36.21 333.1,37.88 331.76,37.88 331.41,37.52 RH100.1 ; v2(159.29,6.39) 159.19,6.29 159.19,2.21 158.2,1.22 140.25,1.22 v1(139.92,1.55) 139.73,1.74 139.73,4.8 140.12,5.2 140.12,7.7 140.67,8.24 v2(141.07,8.24)
  IN2 w0.081: v2(159.29,6.39) 159.3,6.37 165.7,6.37 166.24,6.91 169.9,6.91 172.12,4.69 176.06,4.69 178.76,1.99 193.92,1.99 193.94,1.97 203.92,1.97 205.1,3.15 205.47,3.15 206.14,2.47 211.3,2.47 212.55,3.72 212.55,5.11 213.34,5.89 214.25,5.89 214.84,6.48 214.84,8.99 215.7,9.86 218.73,9.86 220.86,11.98 227.71,11.98 228.23,11.46 236.45,11.46 238.07,9.83 251.72,9.83 252.85,10.96 265.94,10.96 266.76,10.14 266.76,7.42 269.55,4.63 271.6,4.63 274.03,2.2 282.8,2.2 283.5,2.9 291.65,2.9 292.15,3.4 299.41,3.4 300.59,2.22 310.08,2.22 310.66,2.8 312.88,2.8 313.89,1.78 326.02,1.78 331.31,7.07 v2(335.22,7.07)
  IN3 w0.081: v2(139.13,24.85) 139.87,24.85 141.22,23.51 141.22,22.52 140.87,22.18 140.77,22.18 140.08,21.48 140.08,19.77 140.35,19.5 140.35,15.06 139.5,14.21 139.5,12.65 138.9,12.04 138.9,11.48 138.23,10.82 138.23,10.31 139.12,9.42 140.3,9.42 140.73,8.98 140.73,8.58 v2(141.07,8.24)
ME_FWP_PCH: length 224.8
  TOP w0.109: v2(319.26,36.09) 319.76,36.59 330.34,36.59 331.25,35.68 RH100.2 331.41,35.17 v1(331.94,34.64) 333.57,33.01 SW1.3 ; v2(166.44,39.48) 166.65,39.27 RH328.1
  IN1 w0.102: v2(319.26,36.09) 314.81,36.09 308.74,42.16 308.74,43.51 307.99,44.27 305.09,44.27 304.5,43.68 297.29,43.68 295.76,42.15 291.66,42.15 289.54,40.03 281.63,40.03 278.44,36.85 278.44,35.3 275.41,32.28 275.41,26.18 274.53,25.29 273.38,25.29 270.62,22.53 262.97,22.53 260.11,25.39 257.02,25.39 256.4,26.01 253.47,26.01 251.53,27.95 v2(251.53,28.74)
  IN3 w0.081: v2(166.44,39.48) 166.17,39.74 165.6,39.74 164.37,40.97 164.37,43.07 165.29,43.99 165.29,44.65 167.18,46.54 167.18,47.84 173.02,53.68 174.4,53.68 177.66,56.95 188.74,56.95 188.99,57.2 192.54,57.2 194.54,55.2 195.24,55.2 199.09,51.35 199.09,49.78 202.68,46.19 202.68,43.8 204.71,41.76 204.71,40.87 206.86,38.72 206.86,38.37 207.69,37.53 208.71,37.53 209.88,36.36 210.07,36.36 212.95,33.49 214.12,33.49 214.8,32.81 219.11,32.81 222.36,29.56 228.44,29.56 229.28,30.41 230.49,30.41 231.5,29.4 236.8,29.4 237.9,28.3 251.09,28.3 v2(251.53,28.74)
ME_RESET#: length 3.1
  TOP w0.102: UC3.2 169.55,49.87 169.34,50.08 RH70.1
  TOP w0.109: v1(167.64,49.41) 168.31,50.08 RH70.1
ME_SUS_PWR_ACK_R: length 9.2
  TOP w0.102: T319.1 166.79,25.95 170.21,25.95 170.4,25.76 171.12,25.76 171.19,25.82 172.6,25.82 172.81,25.62 174.09,25.62 174.18,25.53 175.19,25.53 175.31,25.4 UH1.BC37
MEC_XTAL1: length 8.4
  TOP w0.109: YE1.1 132.52,34.67 132.52,34.54 132.51,34.54 CE28.1 132.51,34 v1(131.23,32.71) 131.23,31.98 130.43,31.18 130,31.18 129.64,30.83 129.64,30.58 129.93,30.3 UE1.A1
MEC_XTAL2: length 4
  TOP w0.109: RE290.2 132.48,33.3 133.03,33.86 133.58,33.86 CE29.1 133.77,35.42 YE1.2
MEC_XTAL2_R: length 2.8
  TOP w0.109: UE1.A3 131.53,30.63 132.48,31.57 RE290.1
MEDIACARD_IRQ#: length 195.9
  TOP w0.089: UH1.BB26 v2(176.08,30.27)
  IN2 w0.081: v2(176.08,30.27) 175.16,29.36 175.16,26.97 174.54,26.34 168.84,26.34 168.18,27 166.39,27 166.01,26.62 166.01,26.33 165.74,26.06 161.24,26.06 161.06,25.89 160.66,25.89 159.93,25.16 158.85,25.16 158.64,24.95 154.06,24.95 152.94,23.83 150.2,23.83 145.32,18.95 141.97,18.95 141.44,18.41 141.44,16.6 139.43,14.59 138.45,14.59 137.56,15.47 136.84,15.47 135.9,14.53 135.7,14.53 135.34,14.9 133.68,14.9 133.61,14.82 132.88,14.82 131.99,13.94 128.36,13.94 128.29,14.01 126.46,14.01 126.13,14.33 124.61,14.33 124.29,14.01 121.52,14.01 120.81,14.72 118.49,14.72 117.06,16.15 113.58,16.15 112.56,17.18 112.56,18.92 110.87,20.6 110.26,20.6 109.8,20.15 103.9,20.15 103.52,20.53 101.63,20.53 101.21,20.95 101.21,23.13 100.1,24.24 99.84,24.24 98.78,25.29 98.78,26.19 98.4,26.57 98.03,26.57 97.73,26.88 v2(97.73,27.48)
  IN4 w0.102: v2(26.35,11.55) 26.35,10.77 26.65,10.47 29.21,10.47 29.68,10.94 30.93,10.94 31.6,10.27 35.07,10.27 36.9,12.09 36.9,13.16 37.7,13.97 37.7,21.35 38.64,22.29 40.68,22.29 41.73,23.34 41.73,25.45 42.69,26.41 44.09,26.41 44.25,26.57 45.29,26.57 46.52,25.34 47.87,25.34 48.13,25.6 49.42,25.6 50.79,24.24 51.93,24.24 53.81,22.36 54.55,22.36 55.07,22.88 58.87,22.88 60.46,24.48 61.87,24.48 62.4,23.95 63.7,23.95 64.27,24.52 69.88,24.52 71.32,25.96 79.19,25.96 81.27,23.88 83.58,23.88 84.59,24.89 86.75,24.89 88.09,26.23 96.48,26.23 v2(97.73,27.48)
  BOTTOM w0.109: RR211.2 26.76,10.49 26.47,10.49 26.16,10.8 26.16,11.36 v2(26.35,11.55) 26.29,11.55 26.1,11.74 26.1,12.53 25.61,13.02 UR1.48
MEM_INTERLEAVED: length 17.2
  TOP w0.089: v2(177.23,34.01) 177.01,34.01 UH1.BA20
  BOTTOM w0.102: RH371.1 163.86,37.33 RH372.1
  BOTTOM w0.109: RH372.1 163.85,37.53 164.38,38.05 165.43,38.05 167.12,36.36 169.09,36.36 169.43,36.01 v1(170.16,36.01) 170.7,36.01 171.26,35.45 172.33,35.45 172.86,34.92 173.75,34.92 174.12,34.55 175.16,34.55 175.45,34.84 176.47,34.84 176.72,34.59 176.72,34.52 v2(177.23,34.01)
MEM_SMBCLK: length 14
  TOP w0.102: v1(170.37,30.74) 170.22,30.59 167.43,30.59 166.86,31.17 165.33,31.17 164.98,30.81 164.98,30.39 RH56.2 CC320.1 163,29.31 QH4.6 ; 170.85,30.62 172.55,30.62 172.65,30.72 174.1,30.72 174.19,30.63 174.5,30.63 174.57,30.71 UH1.BE26
  TOP w0.109: 170.85,30.62 170.73,30.74 v1(170.37,30.74)
MEM_SMBDATA: length 15.2
  TOP w0.102: QH4.3 161.09,30.76 161.95,29.9 162.79,29.9 163.35,30.46 163.74,30.46 RH57.2 164.1,30.81 164.58,30.81 165.14,31.37 166.94,31.37 167.52,30.79 170,30.79 170.25,31.03 171.05,31.03 ; UH1.BF26 174.22,30.87 174.22,30.87 174.16,30.93 172.73,30.93 172.66,31.01 171.77,31.01 v1(171.68,30.91)
  TOP w0.109: v1(171.68,30.91) 171.16,30.91 171.05,31.03
MID1_CA_DET: length 5.7
  TOP w0.109: v1(72.81,29.29) 72.57,29.53 RV895.1 71.7,30.01 v2(71.97,30.28) ; UV66.52 v2(69.66,30.2)
  IN3 w0.081: v2(71.97,30.28) 71.49,29.8 70.64,29.8 70.24,30.2 v2(69.66,30.2)
MID2_CA_DET: length 5.3
  TOP w0.109: UV67.52 149.1,39.56 149.44,39.21 149.44,38.5 149.6,38.34 149.6,37.72 RV896.2 149.68,36.78 v1(149.68,35.46)
MISO: length 14.7
  IN1 w0.102: v2(14.53,20.56) 15.38,19.7 15.38,14.59 17.11,12.86 17.11,12.36 17.5,11.97 v2(17.64,11.97)
  BOTTOM w0.109: 15.33,19.53 15.33,20.35 15.12,20.56 v2(14.53,20.56) ; UR1.14 18.65,13.42 18.4,13.17 18.4,12.71 17.67,11.97 v2(17.64,11.97) 17.52,11.84 v1(17.52,11.31)
MOD_ID1: length 3.9
  BOTTOM w0.109: RT536.1 49.57,34.82 RT534.2 50.46,33.93 51.02,33.93 52.37,32.58 UT5.L10
MOD_ID2: length 13.7
  TOP w0.109: RT535.2 49.99,36.38 50.27,36.1 51.6,36.1 52.19,35.51 v2(52.19,34.84)
  IN3 w0.081: v2(52.19,34.84) 51.49,34.14 50.89,34.14 50.34,33.59 50.34,30.33 50.39,30.28 v2(50.39,30.28)
  BOTTOM w0.109: RT537.1 52.28,34.92 v2(52.19,34.84) ; UT5.L4 52.24,29.66 v1(50.9,29.66) 50.52,30.04 50.52,30.15 v2(50.39,30.28)
MODE_IO:
  vias: v1(271.08,100.86)
MOSI: length 18.3
  IN1 w0.102: v2(13.33,24.33) 14.72,22.94 14.72,21.15 15.71,20.17 15.71,14.81 17.38,13.13 17.38,12.82 v2(17.63,12.58)
  BOTTOM w0.109: UR3.5 12.79,24.87 v2(13.33,24.33) ; v2(17.63,12.58) 17.79,12.58 18.16,12.95 18.16,13.29 18.69,13.82 UR1.15
MSCLK: length 119.1
  TOP w0.102: UE1.H10 v2(137.53,23.25)
  IN2 w0.081: v2(90.66,8.03) 90.66,5.64 89.9,4.87 89.9,4.01 90.78,3.14 90.78,2.2 90.09,1.51 81.43,1.51 78.15,4.79 75.93,4.79 73.27,7.46 70.61,7.46 70.21,7.05 69.78,7.05 67.22,4.49 65.88,4.49 64.87,3.49 64.33,3.49 63.98,3.14 61.84,3.14 61.51,3.47 60.64,3.47 59.93,4.18 59.93,4.27 59.09,5.11 58.65,5.11 v2(58.33,4.79)
  IN3 w0.081: v2(137.53,23.25) 137.13,22.84 137.13,20.54 137.44,20.22 137.44,19.25 137.08,18.89 137.08,18.11 137.99,17.2 137.99,13.31 137.33,12.65 137.33,12.01 136.54,11.22 135.12,11.22 134.77,11.57 131.74,11.57 131.6,11.43 129.28,11.43 128.31,10.46 125.45,10.46 124.33,11.57 119.11,11.57 118.66,11.13 111.61,11.13 110.06,12.68 95.96,12.68 92.62,9.33 92.28,9.33 91.79,8.84 91.79,8.73 91.1,8.03 v2(90.66,8.03)
  BOTTOM w0.109: JDEG1.6 58.25,4.71 v2(58.33,4.79) 58.33,4.96 57.66,5.63 55.38,5.63 55.12,5.36 53.14,5.36 52.81,5.03 51.4,5.03 RE72.2 50.68,6.43 RE30.2
MSDATA: length 115.6
  TOP w0.102: UE1.G9 v2(135.93,24.85)
  IN2 w0.081: v2(58.95,4.68) 60.63,3 60.63,2.85 60.95,2.53 61.61,2.53 61.99,2.91 64.08,2.91 64.43,3.26 64.97,3.26 65.97,4.27 67.31,4.27 69.87,6.83 70.31,6.83 70.68,7.2 73.2,7.2 75.98,4.42 78.05,4.42 81.2,1.27 90.25,1.27 92.09,3.11 92.09,8.83 91.18,9.74 v2(91.18,10.62)
  IN3 w0.081: v2(135.93,24.85) 135.93,24.67 135.31,24.05 135.31,22.89 134.99,22.57 134.99,20.23 135.49,19.73 135.49,18.62 134.77,17.89 134.77,16.75 135.35,16.17 135.35,15.22 134.82,14.7 134.08,14.7 133.94,14.56 133.94,14.18 133.71,13.95 132.27,13.95 131.32,13 130.98,13 130.3,12.32 128.88,12.32 127.93,11.37 125.83,11.37 124.71,12.49 119.64,12.49 119.22,12.91 112.99,12.91 112.39,13.51 95.56,13.51 93.36,11.31 91.87,11.31 v2(91.18,10.62)
  BOTTOM w0.109: JDEG1.7 58.75,4.47 v2(58.95,4.68) 58.95,4.82 57.89,5.88 55.3,5.88 55.11,5.69 54.21,5.69 RE86.1 52.97,5.99 RE75.2 52.29,5.99 v3(51.83,5.53)
MUX1_CFG0: length 5.5
  TOP w0.109: RV876.1 60.05,31.37 RV879.1 60.19,31.6 60.21,31.63 60.21,31.64 60.56,31.98 60.56,32.41 60.66,32.52 v1(60.66,32.85) 60.54,32.96 60.54,33.36 61.09,33.91 UV66.28
MUX1_CFG1: length 4.7
  TOP w0.109: UV66.27 61.16,34.31 60.36,33.51 59.99,33.51 RV856.1 59.18,32.7 58.43,32.7 RV878.1
MUX1_CFG2: length 4.5
  TOP w0.109: UV66.26 60.77,34.71 RV857.1 59.92,34.78 58.68,34.78 RV877.1
MUX1_CFG3: length 5.3
  TOP w0.109: UV66.25 59.97,35.11 59.88,35.02 58.79,35.02 58.61,35.2 RV858.1 58.03,35.58 57.71,35.89 RV848.1
MUX1_CFG4: length 3.7
  TOP w0.109: UV66.46 v2(67.26,30.22)
  BOTTOM w0.109: v2(67.26,30.22) v1(67.26,29.52) 67.26,29.39 67.77,28.87 RV892.1 66.86,28.57 RV891.1
MUX1_IN1_EQ0: length 6.7
  TOP w0.109: UV66.40 64.86,30.37 65,30.23 v1(65,29.81) 65,29.45 64.87,29.33 64.66,29.33 64.17,28.83 63.76,28.83 63.29,28.37 RV881.1 62.68,27.91 62.68,26.16 RV852.1
MUX1_IN1_EQ1: length 6
  TOP w0.109: RV850.1 63.63,26.25 63.63,27.92 RV882.1 64.81,29.09 64.98,29.09 65.33,29.45 65.33,30.41 65.26,30.48 UV66.41
MUX1_IN2_EQ0: length 11.2
  TOP w0.109: RV853.1 61.88,24.23 61.58,24.53 61.22,24.53 60.58,25.17 v1(60.58,26.32) 60.58,27.75 60.72,27.89 60.72,27.97 RV883.1 61.12,28.36 61.12,28.72 61.43,29.04 63.29,29.04 63.56,29.31 63.97,29.31 64.22,29.55 64.22,30.49 64.06,30.65 UV66.38
MUX1_IN2_EQ1: length 7.5
  TOP w0.109: RV851.1 62.44,26.86 62.44,27.88 RV880.1 62.43,28.8 63.39,28.8 63.66,29.07 64.07,29.07 64.46,29.46 UV66.39
MUX2_CFG0: length 5.6
  TOP w0.109: UV67.28 140.83,42.95 140.04,42.16 140.04,41.79 139.73,41.48 RV871.1 139.25,40.44 138.5,40.44 137.69,41.25 RV887.1
MUX2_CFG1: length 4.4
  TOP w0.109: UV67.27 140.89,43.35 139.73,42.18 RV872.1 139.1,42.66 138.13,42.66 RV888.1
MUX2_CFG2: length 4.7
  TOP w0.109: RV886.1 137.44,43.42 137.63,43.61 139.29,43.61 139.76,43.13 RV873.1 140.06,43.13 140.67,43.75 UV67.26
MUX2_CFG3: length 4.4
  TOP w0.109: RV885.1 137.4,44.4 137.6,44.6 139.33,44.6 139.8,44.14 RV874.1 139.84,44.15 UV67.25
MUX2_CFG4: length 6
  TOP w0.109: UV67.46 146.7,39.43 146.48,39.21 146.48,38.67 v1(146.79,38.36) 146.98,38.36 147.64,37.7 147.75,37.7 RV894.1 147.69,36.83 147.69,36.04 RV893.1
MUX2_IN1_EQ0: length 5.1
  TOP w0.109: UV67.40 144.3,39.75 144.12,39.58 144.12,38.01 RV875.1 143.96,37.85 143.52,37.41 143.52,36.01 RV864.1
MUX2_IN1_EQ1: length 7.3
  TOP w0.109: v1(146.29,34.33) 146.08,34.33 144.85,35.56 RV865.1 145.29,36.01 145.29,37.41 RV868.1 144.74,37.88 144.4,38.22 144.4,39.51 144.7,39.81 UV67.41
MUX2_IN2_EQ0: length 6.7
  TOP w0.109: UV67.38 143.5,39.76 143.36,39.63 143.36,39.03 RV863.1 141.71,37.37 141.71,36.05 RV866.1 141.97,35.35 141.31,35.35 v1(141.18,35.21)
MUX2_IN2_EQ1: length 5.3
  TOP w0.109: UV67.39 143.9,39.73 143.76,39.6 v1(143.76,38.82) 143.76,38.54 RV884.1 142.63,37.4 142.63,36.02 RV867.1
NB_MUTE#: length 300.6
  TOP w0.102: UE1.A4 132.35,29.27 132.35,30.04 v2(132.16,30.23)
  TOP w0.109: DA8.1 337.67,21.64 RA48.1 336.88,21.76 336.88,22.95 v2(336.88,22.96) 336.95,23.03 338.03,23.03 338.18,23.17 v1(338.91,23.17)
  IN2 w0.081: v2(205.3,2.58) 205.91,1.97 213.02,1.97 215.16,4.11 215.16,8.98 215.8,9.62 218.79,9.62 220.93,11.76 227.61,11.76 228.14,11.23 236.33,11.23 237.95,9.61 251.82,9.61 252.95,10.73 265.85,10.73 266.53,10.05 266.53,7.32 269.43,4.42 271.49,4.42 273.98,1.93 283.09,1.93 283.68,2.52 292.04,2.52 292.18,2.38 292.84,2.38 293.03,2.57 299.48,2.57 300.08,1.97 310.17,1.97 310.79,2.59 312.79,2.59 313.81,1.57 326.1,1.57 330.93,6.39 335.72,6.39 335.8,6.31 335.8,6.19 v2(335.59,5.98)
  IN3 w0.081: v2(335.59,5.98) 335.9,6.29 335.9,9.41 340.41,13.91 340.41,21.66 339.01,23.06 336.99,23.06 v2(336.88,22.96)
  IN4 w0.102: v2(132.16,30.23) 130.59,30.23 129.49,29.13 129.01,29.13 128.59,29.56 126.08,29.56 124.65,28.12 124.65,26.86 124.17,26.38 123.28,26.38 122.4,27.26 121.06,27.26 119.64,25.83 118.2,25.83 117.56,25.19 117.56,20.67 117.23,20.34 117.23,19.15 117.71,18.67 117.71,18.24 118.94,17.01 118.94,15.99 125.56,9.37 128.57,9.37 130.61,7.33 134.94,7.33 135.46,7.85 138.46,7.85 138.95,7.36 145.59,7.36 147.88,9.65 155.74,9.65 156.38,10.29 157.63,10.29 160.98,6.94 164.81,6.94 164.98,7.11 170.63,7.11 173.93,3.81 175.59,3.81 176.12,3.29 176.12,2.67 176.67,2.11 187.95,2.11 188.91,3.08 192.38,3.08 193.08,2.37 205.08,2.37 v2(205.3,2.58)
NGFF_CONFIG_0: length 186.1
  TOP w0.109: v2(284.08,1.92) 283.68,1.51 266.02,1.51 265.71,1.82 259.27,1.82 v2(259.21,1.77) ; UE1.N9 136.76,19.22 136.76,14.67 137.06,14.37 137.94,14.37 138.18,14.13 138.37,14.13 138.57,13.94 139.33,13.94 RE734.1 140.47,13.72 141.25,13.72 141.31,13.66 144.44,13.66 144.73,13.94 v1(145.96,13.94) 146.46,13.94 v2(146.78,14.26)
  IN1 w0.102: v2(146.78,14.26) 146.87,14.16 147.99,14.16 148.79,13.37 149.69,13.37 151.44,15.12 153.68,15.12 155.17,13.63 156.52,13.63 156.96,13.19 158.87,13.19 159.1,12.96 159.54,12.96 162.24,10.27 166.45,10.27 166.59,10.13 171.89,10.13 173.05,8.98 174.5,8.98 175.24,8.24 176.1,8.24 177.89,6.45 179.98,6.45 180.66,5.77 186.72,5.77 190.28,9.33 199.18,9.33 203.07,13.22 203.87,13.22 204.78,14.13 210.35,14.13 211.05,13.43 218.35,13.43 219.56,14.64 230.39,14.64 230.95,14.07 242.86,14.07 243.45,13.48 248.64,13.48 249,13.85 253.69,13.85 254.94,12.6 254.94,11.47 254.3,10.83 254.3,7.46 255.85,5.91 256.74,5.91 257.37,5.28 257.37,3.61 v2(259.21,1.77)
  BOTTOM w0.109: JNGFF2.13 294.5,3.24 294.42,3.31 294.25,3.31 294.05,3.12 294.05,2.71 293.73,2.39 293.17,2.39 292.14,1.36 284.63,1.36 v2(284.08,1.92)
NGFF_CONFIG_1: length 198.6
  TOP w0.109: UE1.M10 137.53,20.05 137.53,19.39 137.26,19.13 137.26,15.59 137.37,15.48 137.71,15.48 138.69,14.51 139.18,14.51 RE732.1 140.5,15.82 142.69,15.82 143.12,15.4 143.73,15.4 144.17,14.96 146.22,14.96 146.5,15.23 v1(147.42,15.23) 147.83,15.23 148.3,14.76 148.73,14.76 149.16,15.2 v2(149.21,15.2)
  IN1 w0.102: v2(149.21,15.2) 149.95,15.2 150.39,15.64 153.83,15.64 154.03,15.44 155.02,15.44 156.38,14.08 156.71,14.08 157.15,13.65 159.06,13.65 159.28,13.42 159.73,13.42 162.33,10.83 162.82,10.83 163.6,11.61 164.66,11.61 165.09,12.04 166.61,12.04 168.06,10.59 172.08,10.59 173.07,9.6 175.38,9.6 177.03,7.95 178.3,7.95 179.27,6.98 186.98,6.98 190.12,10.12 196.27,10.12 196.73,10.57 198.53,10.57 199.39,11.43 199.39,13.08 200.91,14.59 210.54,14.59 211.22,13.9 218.18,13.9 219.37,15.09 230.58,15.09 231.08,14.59 242.99,14.59 243.64,13.94 248.22,13.94 248.59,14.3 253.91,14.3 255.44,12.77 255.44,11.32 254.76,10.64 254.76,7.65 256.01,6.4 257.04,6.4 261.94,1.5 281.01,1.5 282.06,2.56 285.07,2.56 286.1,1.52 291.78,1.52 292.58,2.32 293.54,2.32 v2(293.92,1.95)
  BOTTOM w0.109: v2(293.92,1.95) 293.92,1.62 294.31,1.22 306.15,1.22 306.5,1.58 JNGFF2.61
NGFF_CONFIG_2: length 207.6
  TOP w0.109: v2(147.28,14.58) 147.14,14.72 144.77,14.72 v1(144.28,14.23) 143.94,13.89 141.41,13.89 141.34,13.96 140.5,13.96 RE733.1 139.77,14.22 138.64,14.22 137.61,15.25 137.27,15.25 137.02,15.49 137.02,19.2 137.13,19.3 UE1.N10
  IN1 w0.102: v2(147.28,14.58) 147.47,14.77 149.85,14.77 150.49,15.41 153.74,15.41 153.94,15.21 154.92,15.21 156.28,13.86 156.62,13.86 157.05,13.42 158.96,13.42 159.19,13.19 159.64,13.19 162.26,10.57 162.89,10.57 163.7,11.38 164.37,11.38 164.99,10.76 166.29,10.76 166.69,10.36 171.99,10.36 172.98,9.37 175.29,9.37 176.94,7.72 178.2,7.72 179.17,6.75 187.24,6.75 190.05,9.55 199.08,9.55 202.98,13.45 203.72,13.45 204.63,14.36 210.44,14.36 211.13,13.68 218.27,13.68 219.47,14.87 230.48,14.87 231.05,14.3 242.96,14.3 243.55,13.71 248.42,13.71 248.78,14.08 253.79,14.08 255.18,12.68 255.18,11.39 254.53,10.74 254.53,7.56 255.91,6.17 256.95,6.17 261.84,1.27 281.1,1.27 282.16,2.33 284.97,2.33 286.02,1.28 292.66,1.28 v2(293.29,1.91)
  IN2 w0.081: v2(312.85,1.91) 312.38,2.38 310.87,2.38 310.26,1.76 295.28,1.76 294.69,2.35 293.73,2.35 v2(293.29,1.91)
  BOTTOM w0.109: v2(312.85,1.91) 312.35,1.4 308.26,1.4 308,1.66 JNGFF2.67
NGFF_CONFIG_3: length 213
  TOP w0.102: UE1.F4 v2(131.93,25.65)
  TOP w0.109: RE735.1 144.51,13.07 145,13.56 146.75,13.56 146.85,13.66 v2(146.88,13.66) 147.03,13.66 147.9,14.53 148.82,14.53 149.06,14.76 149.35,14.76 150.47,15.87 150.47,20.13 v1(150.6,20.27) 150.9,20.57 150.9,21.13 v2(149.99,22.04) ; v2(258.68,1.52) 258.92,1.28 284.23,1.28 v2(284.84,1.88)
  IN1 w0.102: v2(258.68,1.52) 257.09,3.11 257.09,5.25 256.65,5.68 255.72,5.68 254.07,7.33 254.07,10.93 254.67,11.52 254.67,12.55 253.6,13.62 249.5,13.62 249.14,13.26 243.28,13.26 242.69,13.85 231.19,13.85 230.99,13.65 218.89,13.65 218.44,13.19 210.96,13.19 210.25,13.9 205.79,13.9 204.88,12.99 203.17,12.99 199.27,9.1 190.47,9.1 186.91,5.54 180.57,5.54 179.89,6.22 177.79,6.22 176.54,7.47 173.13,7.47 170.72,9.88 166.52,9.88 166.36,10.04 162.14,10.04 159.45,12.74 159,12.74 158.77,12.96 156.86,12.96 156.43,13.4 155.08,13.4 153.58,14.89 151.54,14.89 149.55,12.91 148.42,12.91 147.94,13.39 147.15,13.39 v2(146.88,13.66)
  IN4 w0.102: v2(131.93,25.65) 131.93,25.42 131.52,25 131.52,24.6 131.37,24.45 130.86,24.45 130.37,23.95 130.37,23.72 128.75,22.1 128.22,22.1 127.93,21.81 127.93,20.84 128.21,20.56 128.83,20.56 130.26,19.13 130.26,18.63 131.07,17.81 131.16,17.81 131.3,17.67 132.63,17.67 133.86,16.45 138.6,16.45 138.78,16.62 139.86,16.62 140.16,16.32 143.74,16.32 144.32,16.91 146.65,19.24 146.65,19.74 148.96,22.04 v2(149.99,22.04)
  BOTTOM w0.109: JNGFF2.1 289.5,1.71 289.41,1.62 287.32,1.62 287.11,1.84 284.89,1.84 v2(284.84,1.88)
NRB_BIT: length 13.5
  TOP w0.102: RH331.2 162.99,26.51 v1(164.11,27.63) 164.83,28.35 165.33,28.35 165.45,28.47 167.03,28.47 167.6,29.03 171.14,29.03 171.21,29.1 171.22,29.1 171.24,29.12 174.42,29.12 174.44,29.1 174.62,29.1 174.69,29.03 UH1.BE30
OUT1_CA_DET: length 2.2
  TOP w0.109: UV8.43 v2(187.84,116.15)
  BOTTOM w0.109: v1(187.2,116.4) 187.45,116.15 v2(187.84,116.15)
  BOTTOM w0.381: v2(187.84,116.15) 187.9,116.1 RV130.2
PANEL_BKEN_EC: length 56.5
  TOP w0.102: UE1.J9 v2(136.73,22.45)
  IN3 w0.081: v2(136.73,22.45) 136.73,22.69 137.17,23.13 137.17,25 137.45,25.28 137.77,25.28 137.97,25.48 137.97,27.5 138.18,27.7 138.18,28.42 137.78,28.82 137.23,28.82 134.56,31.48 132.42,31.48 131.22,30.28 129.9,30.28 128.7,31.48 127.74,31.48 126.22,29.96 122.76,29.96 v2(122.58,30.15)
  BOTTOM w0.109: DV37.2 115.4,49.77 116.56,48.6 116.56,47.52 119.72,44.36 124.31,44.36 v1(124.55,44.12) 125.94,42.73 125.94,39.73 125.32,38.16 124.07,36.33 123.37,36.33 123.19,36.16 122.17,36.16 121.01,35 121.01,32.67 122.58,31.1 v2(122.58,30.15)
