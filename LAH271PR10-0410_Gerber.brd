# Allegro board LAH271PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_PRX_DTX_P19: length 198.4
  TOP w0.102: v2(191.02,22.43) 190.7,22.43 190.42,22.71 UH1.N42
  IN1 w0.102: v2(191.02,22.43) 190.95,22.51 190.61,22.51 190.48,22.38 190.48,22.11 190.72,21.87 191.36,21.87 191.68,22.19 191.68,23.09 192.57,23.98 193.49,23.98 196.46,21.01 204.32,21.01 205.19,20.14 205.19,18.72 206.02,17.88 216.74,17.88 217.12,18.26 231.62,18.26 232.25,17.63 239.83,17.63 240.7,18.5 254.5,18.5 257.63,15.36 259.76,15.36 262.89,12.22 262.89,7.55 265.09,5.35 272.64,5.35 274.16,6.87 280.84,6.87 281.29,7.31 283.75,7.31 285.51,5.56 286.47,5.56 287.24,4.79 289.26,4.79 290.64,6.17 294.01,6.17 296.34,3.84 300.25,3.84 301.87,5.46 302.75,5.46 304.06,4.15 309.11,4.15 309.28,4.33 313.82,4.33 314.04,4.1 315.27,4.1 315.51,3.86 324.56,3.86 325.81,5.11 325.81,7.34 326.97,8.51 332.94,8.51 333.68,9.25 338.01,9.25 338.6,9.83 340.86,9.83 341.17,10.14 343.73,10.14 344.07,9.8 345.91,9.8 346.29,10.18 348.28,10.18 348.55,9.91 348.88,9.91 349.29,9.5 350.83,9.5 351.03,9.7 351.03,10.45 351.64,11.06 353.57,11.06 354.17,10.46 354.17,10.01 355.14,9.04 358.01,9.04 358.64,9.67 358.64,10.42 358.56,10.5 v2(358.24,10.5)
  BOTTOM w0.102: v2(358.24,10.5) 358.56,10.17 358.56,9.96 358.4,9.8 JNGFF4.19
PCIE_PRX_DTX_P20: length 193.8
  TOP w0.102: v2(189.86,25.51) 189.65,25.72 UH1.R37
  IN1 w0.102: v2(189.86,25.51) 190.11,25.75 190.33,25.75 190.62,26.04 190.62,26.54 190.97,26.89 191.88,26.89 192.36,26.42 192.98,26.42 193.41,25.99 194.07,25.99 194.47,26.39 197.91,26.39 199.17,25.13 207,25.13 208.76,23.37 208.76,21.14 209.43,20.47 215.61,20.47 215.93,20.78 232.87,20.78 233.46,20.2 238.17,20.2 239,21.03 241.81,21.03 242.68,21.9 254.91,21.9 258.07,18.75 260.55,18.75 265.7,13.6 265.7,13.05 266.93,11.82 269.57,11.82 271.5,9.89 278.66,9.89 279.43,10.66 284.23,10.66 285.67,9.22 289.38,9.22 289.78,8.83 296.24,8.83 297.07,8 307.22,8 308.02,8.81 309.31,8.81 309.79,8.33 312.59,8.33 313.48,7.44 320.31,7.44 320.91,8.04 322.42,8.04 324.86,10.48 324.86,11.2 326.05,12.39 339.7,12.39 340.75,13.44 342.96,13.44 343.8,14.28 344.13,14.28 344.64,13.76 347.51,13.76 347.73,13.53 350.23,13.53 350.48,13.28 351.99,13.28 352.42,12.85 353.5,12.85 353.9,13.25 355.53,13.25 356.86,11.91 357.38,11.91 357.59,11.7 359.6,11.7 360.05,11.25 361.59,11.25 361.64,11.2 361.64,10.83 361.57,10.76 v2(361.21,10.76)
  BOTTOM w0.102: v2(361.21,10.76) 361.54,10.43 361.54,9.98 361.4,9.85 JNGFF4.7
PCIE_PRX_DTX_P21: length 142.9
  TOP w0.102: v2(188.14,22.34) 189.03,22.34 189.17,22.2 UH1.R44
  IN1 w0.102: v2(188.14,22.34) 188.14,22.48 187.98,22.64 187.59,22.64 187.52,22.58 187.52,21.33 188.1,20.75 188.1,16.77 189.47,15.4 189.47,14.96 188.42,13.91 188.42,9.65 186.46,7.69 180.03,7.69 178.83,8.89 177.44,8.89 175.7,10.63 173.59,10.63 172.67,11.55 168.53,11.55 166.81,13.27 164.7,13.27 163.22,14.76 160.18,14.76 159.75,15.19 156.61,15.19 155.42,16.38 154.42,16.38 154.22,16.59 150.01,16.59 149.75,16.33 148.37,16.33 147.64,15.6 146.7,15.6 144.14,13.04 142.86,13.04 142.23,12.4 140.79,12.4 140.33,11.94 138.98,11.94 137.11,10.07 134.72,10.07 134.51,9.86 127.27,9.86 126.67,10.46 122.75,10.46 122.46,10.17 121.5,10.17 121.23,10.43 119.29,10.43 118.39,9.53 115.48,9.53 114.98,9.02 112.35,9.02 109.51,11.87 93.7,11.87 92.36,13.21 90.75,13.21 89.78,14.18 83.3,14.18 82.81,13.69 74.73,13.69 v2(74.53,13.49)
  BOTTOM w0.102: JNGFF5.43 75.68,13.65 75.52,13.8 74.85,13.8 v2(74.53,13.49)
PCIE_PRX_DTX_P22: length 141.8
  TOP w0.102: v2(187.74,23.73) 187.86,23.85 188.08,23.85 UH1.U41
  IN1 w0.102: v2(187.74,23.73) 187.74,23.93 187.67,24 187.19,24 187.02,23.84 187.02,20.81 187.49,20.34 187.49,16.14 186.83,15.49 186.83,11.08 185.4,9.65 184.83,9.65 184.25,9.07 180.72,9.07 179.19,10.59 177.66,10.59 175.74,12.51 174.05,12.51 173.25,13.31 173.25,14.04 172.62,14.67 165.36,14.67 163.86,16.17 163.24,16.17 162.68,16.73 161.13,16.73 160.72,17.14 157.74,17.14 157.15,17.73 155.27,17.73 155.03,17.96 153.61,17.96 152.74,18.84 150.88,18.84 150.55,18.51 149.99,18.51 149.17,17.69 147.72,17.69 146.97,16.94 146.1,16.94 143.97,14.82 141.31,14.82 139.86,13.37 138.51,13.37 136.62,11.49 135.27,11.49 135.01,11.74 130.61,11.74 130.21,11.34 127.68,11.34 127.23,11.8 124.87,11.8 124.71,11.96 120.85,11.96 120.7,11.82 118.77,11.82 117.84,10.89 113.43,10.89 112.84,11.48 112.84,12.16 111.78,13.22 94.3,13.22 92.97,14.55 91.3,14.55 90.27,15.58 85.33,15.58 84.11,16.8 77.21,16.8 77.1,16.69 74.74,16.69 v2(74.53,16.49)
  BOTTOM w0.102: v2(74.53,16.49) 74.85,16.8 75.53,16.8 75.69,16.65 JNGFF5.31
PCIE_PRX_DTX_P23: length 142.2
  TOP w0.102: UH1.W44 187.21,22.33 186.5,22.33 v2(186.45,22.28)
  IN1 w0.102: v2(186.45,22.28) 186.45,22.47 186.34,22.58 186.04,22.58 185.94,22.48 185.94,21.55 185.79,21.4 185.79,20.18 186.46,19.5 186.46,19.04 186.74,18.76 186.74,18.26 186.08,17.59 186.08,16.5 185.34,15.76 185.34,13.99 186.22,13.11 186.22,12.45 185.81,12.03 182.98,12.03 182.43,12.58 178.46,12.58 176.96,14.08 176.96,14.71 174.35,17.32 173.17,17.32 172.43,18.07 170.85,18.07 170.66,18.26 170.01,18.26 168.7,16.94 166.41,16.94 163.68,19.68 163.68,20.3 163.29,20.69 161.55,20.69 160.77,19.92 160.32,19.92 160.02,20.22 157.94,20.22 157.8,20.09 155.65,20.09 154.95,20.79 153.36,20.79 152.79,21.36 148.49,21.36 146.03,18.9 144.67,18.9 144.38,18.61 141.46,18.61 140.96,18.11 140.96,17.47 139.93,16.44 139.01,16.44 138.24,15.66 137.23,15.66 136.06,14.5 135.18,14.5 134.84,14.83 132.99,14.83 132.51,15.31 131.56,15.31 131.29,15.04 127.31,15.04 127.03,15.31 126.29,15.31 126.19,15.21 125.28,15.21 124.38,14.31 119.49,14.31 119.3,14.12 113.62,14.12 111.82,15.92 106.36,15.92 105.74,15.3 100.88,15.3 100.58,15.61 94.82,15.61 93.94,16.49 92.1,16.49 90.34,18.25 90.34,18.61 88.9,20.05 84.97,20.05 84.45,19.52 82.5,19.52 81.92,20.1 78.63,20.1 78.38,19.85 74.67,19.85 74.57,19.75 74.57,19.59 v2(74.47,19.49)
  BOTTOM w0.102: v2(74.47,19.49) 74.78,19.8 75.53,19.8 75.69,19.65 JNGFF5.19
PCIE_PRX_DTX_P24: length 132.7
  TOP w0.102: v2(186.33,23.78) 186.41,23.86 186.78,23.86 UH1.Y41
  IN1 w0.102: v2(186.33,23.78) 186.12,24 185.84,24 185.74,23.9 185.74,23.06 185.41,22.74 185.41,21.98 185.1,21.67 185.1,19.77 185.68,19.19 185.68,18.22 183.38,15.92 177.72,15.92 176,17.63 176,18.23 175.43,18.8 174.47,18.8 173.86,19.41 172.89,19.41 172.05,20.25 167.59,20.25 165.8,22.04 162.64,22.04 162.25,22.43 159.78,22.43 159.67,22.31 158.33,22.31 157.95,21.94 155.71,21.94 155.48,22.17 153.99,22.17 152.81,23.35 149.03,23.35 148.5,22.81 148.04,22.81 145.47,20.24 144.12,20.24 143.84,19.96 140.88,19.96 139.68,18.75 139.21,18.75 137.52,17.06 132.31,17.06 132.06,16.81 130.51,16.81 130.11,16.41 127.9,16.41 127.64,16.67 126.67,16.67 126.45,16.89 124.9,16.89 124.49,16.48 121.92,16.48 121.3,15.87 117.08,15.87 116.76,16.19 113.82,16.19 111.91,18.09 104.83,18.09 103.37,16.64 101.44,16.64 101.13,16.95 95.38,16.95 93.37,18.96 91.89,18.96 89.44,21.4 84.54,21.4 83.97,21.97 81.98,21.97 81.64,22.31 80.45,22.31 80,22.77 76.24,22.77 76.2,22.73 75.2,22.73 v2(74.96,22.49)
  BOTTOM w0.102: v2(74.96,22.49) 75.22,22.75 75.48,22.75 75.58,22.65 JNGFF5.7
PCIE_PRX_TTX_N1: length 225.5
  TOP w0.089: UH1.G17 193.15,35.3 193.15,35.77 v2(193.1,35.82)
  IN1 w0.102: v2(35.92,30.08) 35.92,29.8 35.79,29.67 35.53,29.67 35.43,29.78 35.43,30.48 35.66,30.71 36.64,30.71 37.61,29.74 37.61,29.4 39.78,27.23 40.03,27.23 40.43,26.84 41.96,26.84 42.8,27.67 44.53,27.67 47.29,24.92 49.55,24.92 50.02,24.45 51.98,24.45 52.65,23.78 54.83,23.78 55.22,24.17 56.44,24.17 57.46,25.2 58.1,25.2 59.04,26.13 60.22,26.13 60.54,26.46 60.62,26.46 60.84,26.68 60.84,26.84 62.68,28.68 65.91,28.68 66.75,29.52 66.75,30.29 67.45,30.99 70.86,30.99 71.76,31.89 75.09,31.89 76.32,33.12 76.32,33.36 76.89,33.93 83.25,33.93 85.04,32.14 87.92,32.14 88.69,31.37 91.32,31.37 92.44,30.25 96.7,30.25 99.07,27.87 103.35,27.87 103.36,27.87 108.48,27.87 109.3,27.06 111.06,27.06 111.25,26.87 117.4,26.87 122.5,31.96 122.63,31.96 123.51,32.84 123.51,33.75 125.16,35.4 128.84,35.4 129.27,35.83 129.27,37.54 129.8,38.07 129.8,38.08 130.06,38.35 130.08,38.35 130.27,38.54 135.02,38.54 135.21,38.35 135.23,38.35 135.93,37.65 136.08,37.65 136.09,37.65 137.72,37.65 138.62,36.74 143.29,36.74 144.29,35.74 147.73,35.74 148.88,34.6 151.96,34.6 152.81,35.45 153.76,35.45 160.76,42.46 161.86,42.46 162.1,42.7 162.94,42.7 164.77,44.53 164.77,45.5 170.04,50.77 171.15,50.77 172.74,52.36 176.87,52.36 177.27,52.76 180.18,52.76 180.96,51.98 186.09,51.98 188.11,49.97 188.87,49.97 189.06,49.78 193.77,49.78 195.05,48.49 195.63,48.49 198.19,45.94 198.19,45.22 198.82,44.59 198.82,43.54 201.3,41.06 201.3,40.54 201.86,39.98 202.94,39.98 204.66,38.26 204.66,37.2 204.3,36.84 200.34,36.84 199.82,36.32 199.82,33.99 199.19,33.36 197.43,33.36 194.95,35.83 194.95,36.03 194.13,36.86 193.61,36.86 193.17,36.42 193.17,35.9 v2(193.1,35.82)
  BOTTOM w0.102: CT7.1 35.71,30.6 35.71,30.17 35.8,30.08 v2(35.92,30.08)
PCIE_PRX_TTX_N2: length 224.7
  TOP w0.094: UH1.R21 189.37,33.41 189.52,33.57 189.52,33.8 v2(189.37,33.94)
  IN1 w0.102: v2(189.37,33.94) 189.95,33.37 190.44,33.37 191.35,34.28 191.91,34.28 192.7,35.07 192.7,36.54 193.45,37.3 195.04,37.3 196.1,36.23 196.1,35.26 197.6,33.76 198.97,33.76 199.4,34.19 199.4,36.38 197.06,38.72 197.06,41.88 196.01,42.93 196.01,45.19 194.77,46.44 194.63,46.44 193.17,47.9 191.87,47.9 191.02,47.04 188,47.04 187.56,47.48 185.73,47.48 184.44,48.77 182.82,48.77 182.61,48.97 180.78,48.97 179.61,50.14 176.57,50.14 175.94,49.51 173.01,49.51 172.28,48.78 170.98,48.78 170.21,48.02 170.21,45.88 169.04,44.71 168.37,44.71 166.93,43.28 166.93,42.29 166.81,42.17 166.22,42.17 165.32,41.27 164.45,41.27 163.98,40.8 162.85,40.8 162.76,40.71 161.53,40.71 155.3,34.48 155.3,34.13 154.3,33.13 153.93,32.76 145.59,32.76 145.38,32.97 142.08,32.97 141.93,33.12 141.93,33.13 141.2,33.86 136.74,33.86 135.98,34.62 135.12,34.62 135.04,34.55 134.7,34.55 134.67,34.57 131.05,34.57 130.43,33.95 130.43,33.48 130.33,33.38 128.69,33.38 128.36,33.05 125.94,33.05 125.35,32.47 125.35,30.96 123.4,29.01 123.4,29.01 120.63,26.23 120.63,25.34 120.06,24.78 118.91,24.78 118.58,24.44 115.62,24.44 114.97,25.09 113.28,25.09 113.07,24.88 108.62,24.88 107.7,25.81 107.05,25.81 106.34,25.1 106.34,24.77 106.12,24.54 105.67,24.54 105.12,25.09 97.49,25.09 94.54,28.05 91.78,28.05 90.21,29.62 87.29,29.62 86.73,30.18 83.57,30.18 82.5,31.24 81,31.24 79.97,30.22 79.62,30.22 78.96,29.56 75.84,29.56 74.68,28.39 68.59,28.39 66.96,26.76 65.32,26.76 64.14,25.58 63.11,25.58 62.22,24.69 61.27,24.69 60.97,24.39 60.13,24.39 59.19,23.45 58.27,23.45 57.24,22.42 55.97,22.42 54.65,21.1 53.27,21.1 52.66,21.72 50.96,21.72 50.62,22.05 48.58,22.05 48.06,22.57 46.49,22.57 45.89,23.17 45.89,23.85 44.88,24.86 42.83,24.86 42.4,24.43 41.57,24.43 41.17,24.83 37.28,24.83 33.69,28.42 33.69,29.32 33.32,29.69 v2(33.32,30.38)
  BOTTOM w0.102: v2(33.32,30.38) 33.03,30.38 32.9,30.51 32.9,30.75 CT9.1
PCIE_PRX_TTX_N3: length 206.2
  TOP w0.102: UH1.K18 191.63,35.01 v2(191.48,35.16)
  IN1 w0.102: v2(191.48,35.16) 191.48,36.25 192.27,37.04 192.27,39.34 192.64,39.7 192.64,39.96 193.01,40.33 193.01,41.96 192.73,42.25 192.73,45.78 192.54,45.97 192.15,45.97 191.67,45.49 181.74,45.49 180.54,46.69 175.92,46.69 175.01,47.6 173.4,47.6 173.02,47.22 173.02,46.5 169.18,42.65 169.18,41.52 168.25,40.59 166.91,40.59 166.06,39.73 165.3,39.73 164.18,38.61 161.6,38.61 157.53,34.54 157.53,33.8 156.85,33.12 156.46,33.12 154.58,31.23 146.6,31.23 145.66,30.29 143.83,30.29 143.36,30.76 141.48,30.76 140.96,31.28 138.35,31.28 137.87,31.75 135.11,31.75 134.95,31.91 131.93,31.91 131.58,31.56 130.76,31.56 130.43,31.23 128.03,31.23 126.09,29.29 126.09,26.99 123.98,24.88 123.12,24.88 122.55,24.31 122.55,23.94 120.1,21.49 117.87,21.49 117.3,22.05 115.02,22.05 114.1,22.96 113.48,22.96 113.23,22.72 112.61,22.72 112.34,22.45 105.57,22.45 104.9,23.11 103.12,23.11 102.68,23.55 96.55,23.55 95.53,24.57 92.76,24.57 92.53,24.8 92.01,24.8 89.58,27.23 87.15,27.23 86.23,28.15 83.4,28.15 83.12,27.87 81.38,27.87 80.79,27.28 78.55,27.28 78.08,26.81 76.7,26.81 76.38,26.49 73.2,26.49 73.19,26.5 72.84,26.5 70.36,24.02 68.29,24.02 68.22,23.95 67.61,23.95 67.59,23.97 66.69,23.97 66.65,23.93 65.98,23.93 65.39,23.34 63.52,23.34 63.34,23.16 61.93,23.16 61.65,22.88 61.65,22.71 59.85,20.91 58.4,20.91 57.06,19.57 52.64,19.57 52.02,20.19 49.25,20.19 49.12,20.31 46.58,20.31 44.56,22.33 43.6,22.33 43.11,22.82 37.19,22.82 36.72,23.3 36.61,23.3 33.55,26.36 32.53,26.36 31.34,27.54 31.34,28.71 31.14,28.91 30.71,28.91 30.5,28.7 30.5,28.2 30.59,28.11 30.72,28.11 v2(30.92,28.31)
  BOTTOM w0.102: CT128.1 30.7,30.98 30.7,29.02 30.6,28.93 30.6,28.63 v2(30.92,28.31)
PCIE_PRX_TTX_N4: length 248.1
  TOP w0.094: UH1.N18 190.11,34.87 v2(190.43,35.19)
  IN1 w0.102: v2(190.43,35.19) 189.92,35.19 189.8,35.07 189.8,34.74 189.42,34.37 189.22,34.37 189.01,34.15 189.01,33.66 189.51,33.15 190.49,33.15 191.22,33.88 192.84,33.88 197.29,32.69 199.57,32.69 200.46,33.57 201.4,33.57 203.33,35.5 204.86,35.5 206,36.64 206,39.31 201.09,44.21 201.09,44.45 200.38,45.16 200.38,45.82 197.59,48.61 197.59,51.49 196.43,52.65 196.43,53.87 195.37,54.93 194.2,54.93 193.37,55.76 182.37,55.76 181.41,54.79 173.23,54.79 171.36,52.93 170.27,52.93 161.14,43.8 160.19,43.8 158.42,42.03 157.89,42.03 157.36,41.5 157.36,40.97 153.88,37.5 152.84,37.5 151.98,36.64 149.78,36.64 149.32,37.1 145.53,37.1 144.52,38.11 140.87,38.11 139.7,39.29 137.12,39.29 136.13,40.28 130.8,40.28 130.57,40.05 129.71,40.05 128.51,38.85 128.05,38.85 127.15,37.95 127.15,37.53 126.36,36.74 124.05,36.74 122.58,35.27 122.58,35.27 121.78,34.47 121.78,33.58 121.35,33.14 121.35,32.76 116.88,28.3 116.56,28.3 116.56,28.31 112.83,28.31 112.5,28.63 110.58,28.63 110.5,28.55 109.78,28.55 109.09,29.23 99.73,29.23 93.54,35.42 83.74,35.42 83.59,35.27 80.76,35.27 80.14,35.89 75.49,35.89 75.32,36.06 73.06,36.06 71.25,34.25 66.22,34.25 65.74,33.77 65.74,33.49 65.03,32.79 62.68,32.79 59.82,29.92 58.2,29.92 56.35,28.07 55.74,28.07 54.15,26.49 53.62,26.49 52.93,25.79 50.62,25.79 48.83,27.58 47.16,27.58 46.78,27.97 46.27,27.97 45.89,28.35 45.89,28.8 44.98,29.7 39.38,29.7 38.96,30.13 38.96,30.29 37.2,32.05 29.97,32.05 28.43,30.51 28.43,27.63 28.81,27.25 28.81,26.57 28.91,26.47 29.12,26.47 29.22,26.57 v2(29.22,26.76)
  BOTTOM w0.102: CT130.1 28.41,29.72 28.41,29.28 28.24,29.11 v4(28.24,28.72) 28.24,27.96 28.94,27.26 28.94,27.04 v2(29.22,26.76)
PCIE_PRX_TTX_P1: length 225.4
  TOP w0.089: v2(193.82,36.2) 193.75,36.13 UH1.F16
  IN1 w0.102: v2(35.01,30.04) 35.24,30.26 35.24,30.55 35.58,30.9 36.72,30.9 37.8,29.81 37.8,29.48 39.86,27.42 40.11,27.42 40.51,27.03 41.88,27.03 42.72,27.86 44.61,27.86 47.37,25.11 49.63,25.11 50.09,24.64 52.06,24.64 52.73,23.97 54.76,23.97 55.15,24.36 56.36,24.36 57.38,25.38 58.02,25.38 58.96,26.32 60.14,26.32 60.46,26.65 60.54,26.65 60.65,26.75 60.65,26.92 62.6,28.87 65.84,28.87 66.56,29.59 66.56,30.37 67.37,31.18 70.78,31.18 71.68,32.08 75.01,32.08 76.14,33.2 76.14,33.44 76.81,34.11 83.33,34.11 85.12,32.32 88,32.32 88.77,31.55 91.4,31.55 92.52,30.43 96.61,30.43 96.62,30.45 96.78,30.45 99.15,28.07 99.15,28.06 108.56,28.06 109.38,27.24 111.14,27.24 111.33,27.06 117.32,27.06 122.42,32.15 122.55,32.15 123.32,32.92 123.32,33.82 125.08,35.59 128.76,35.59 129.08,35.91 129.08,37.62 129.54,38.08 129.54,38.09 129.59,38.14 129.61,38.14 129.61,38.16 129.66,38.21 129.66,38.21 129.98,38.53 130,38.53 130.19,38.73 135.09,38.73 135.28,38.54 135.31,38.54 135.42,38.42 136.01,37.84 137.79,37.84 138.7,36.93 143.36,36.93 144.36,35.93 147.81,35.93 148.96,34.79 151.88,34.79 152.74,35.64 153.68,35.64 160.69,42.65 161.78,42.65 162.02,42.89 162.86,42.89 164.58,44.61 164.58,45.58 169.96,50.96 171.07,50.96 172.67,52.55 176.79,52.55 177.19,52.95 180.26,52.95 181.04,52.17 186.17,52.17 188.19,50.15 188.95,50.15 189.14,49.96 193.84,49.96 195.13,48.68 195.71,48.68 198.38,46.02 198.38,45.3 199,44.67 199,43.62 201.49,41.13 201.49,40.62 201.94,40.17 203.01,40.17 204.84,38.34 204.84,37.12 204.38,36.65 200.42,36.65 200.01,36.24 200.01,33.91 199.27,33.17 197.35,33.17 194.77,35.76 194.77,35.95 194.05,36.67 193.69,36.67 193.36,36.34 193.36,36.1 193.45,36.01 193.7,36.01 193.82,36.12 v2(193.82,36.2)
  BOTTOM w0.102: v2(35.01,30.04) 35.52,30.54 35.52,30.71 CT6.1
PCIE_PRX_TTX_P2: length 224.8
  TOP w0.094: UH1.P21 190.01,34.06 v2(190.1,34.15)
  IN1 w0.102: v2(190.1,34.15) 189.88,33.92 189.88,33.7 190.02,33.56 190.36,33.56 191.27,34.47 191.84,34.47 192.51,35.15 192.51,36.62 193.37,37.48 195.11,37.48 196.29,36.31 196.29,35.34 197.68,33.95 198.9,33.95 199.22,34.27 199.22,36.3 196.87,38.64 196.87,41.8 195.82,42.85 195.82,45.11 194.69,46.25 194.56,46.25 193.09,47.71 191.95,47.71 191.1,46.86 187.92,46.86 187.49,47.29 185.65,47.29 184.36,48.58 182.74,48.58 182.53,48.79 180.7,48.79 179.54,49.95 176.65,49.95 176.01,49.32 173.09,49.32 172.36,48.59 171.05,48.59 170.4,47.94 170.4,45.8 169.12,44.52 168.44,44.52 167.12,43.2 167.12,42.22 166.89,41.98 166.3,41.98 165.4,41.08 164.53,41.08 164.06,40.61 162.93,40.61 162.84,40.52 161.61,40.52 155.49,34.4 155.49,34.05 154.48,33.05 154.01,32.57 145.51,32.57 145.3,32.78 142,32.78 141.74,33.04 141.74,33.05 141.12,33.67 136.66,33.67 135.9,34.44 135.2,34.44 135.12,34.36 134.62,34.36 134.59,34.39 131.13,34.39 130.62,33.88 130.62,33.41 130.41,33.19 128.77,33.19 128.44,32.86 126.02,32.86 125.54,32.39 125.54,30.88 123.48,28.82 123.48,28.82 120.81,26.16 120.81,25.27 120.14,24.59 118.99,24.59 118.66,24.25 115.54,24.25 114.89,24.9 113.35,24.9 113.15,24.7 108.55,24.7 107.62,25.62 107.13,25.62 106.53,25.02 106.53,24.69 106.19,24.36 105.59,24.36 105.04,24.91 97.41,24.91 94.46,27.86 91.71,27.86 90.13,29.43 87.21,29.43 86.65,29.99 83.49,29.99 82.43,31.06 81.08,31.06 80.05,30.03 79.7,30.03 79.04,29.37 75.92,29.37 74.75,28.21 68.67,28.21 67.03,26.57 65.4,26.57 64.21,25.39 63.18,25.39 62.29,24.5 61.35,24.5 61.04,24.2 60.21,24.2 59.27,23.26 58.35,23.26 57.32,22.23 56.05,22.23 54.73,20.91 53.2,20.91 52.58,21.53 50.88,21.53 50.55,21.86 48.5,21.86 47.98,22.38 46.41,22.38 45.7,23.1 45.7,23.77 44.8,24.67 42.91,24.67 42.48,24.24 41.49,24.24 41.09,24.64 37.2,24.64 33.5,28.34 33.5,29.24 33.13,29.61 33.13,29.98 32.9,30.21 32.69,30.21 32.62,30.14 v2(32.62,29.9)
  BOTTOM w0.102: v2(32.62,29.9) 32.71,29.98 CT8.1
PCIE_PRX_TTX_P3: length 206.2
  TOP w0.102: v2(192.09,35.36) 192.36,35.09 UH1.J18
  IN1 w0.102: v2(30.08,28.34) 30.32,28.57 30.32,28.78 30.63,29.1 31.22,29.1 31.53,28.79 31.53,27.62 32.61,26.54 33.63,26.54 36.69,23.48 36.79,23.48 37.27,23.01 43.19,23.01 43.68,22.52 44.64,22.52 46.65,20.5 49.2,20.5 49.33,20.38 52.1,20.38 52.72,19.76 56.98,19.76 58.32,21.1 59.77,21.1 61.47,22.79 61.47,22.96 61.86,23.35 63.26,23.35 63.45,23.53 65.31,23.53 65.9,24.12 66.57,24.12 66.61,24.16 67.67,24.16 67.69,24.13 68.14,24.13 68.21,24.21 70.28,24.21 72.76,26.68 73.19,26.68 73.2,26.69 76.3,26.69 76.62,27 78,27 78.47,27.47 80.71,27.47 81.3,28.06 83.05,28.06 83.33,28.34 86.31,28.34 87.23,27.42 89.66,27.42 92.09,24.99 92.61,24.99 92.84,24.76 95.61,24.76 96.63,23.74 102.76,23.74 103.19,23.3 104.98,23.3 105.64,22.63 112.26,22.63 112.53,22.9 113.15,22.9 113.4,23.15 114.18,23.15 115.09,22.24 117.38,22.24 117.95,21.67 120.02,21.67 122.36,24.01 122.36,24.39 123.04,25.07 123.9,25.07 125.9,27.07 125.9,29.37 127.95,31.42 130.35,31.42 130.68,31.75 131.5,31.75 131.85,32.1 135.03,32.1 135.19,31.94 137.95,31.94 138.43,31.47 141.04,31.47 141.55,30.95 143.44,30.95 143.91,30.48 145.58,30.48 146.52,31.42 154.5,31.42 156.38,33.3 156.77,33.3 157.34,33.88 157.34,34.62 161.52,38.8 164.1,38.8 165.22,39.92 165.98,39.92 166.84,40.78 168.17,40.78 168.99,41.6 168.99,42.73 172.83,46.57 172.83,47.3 173.32,47.79 175.09,47.79 176,46.88 180.62,46.88 181.82,45.68 191.59,45.68 192.07,46.16 192.62,46.16 192.92,45.86 192.92,42.32 193.2,42.04 193.2,40.25 192.83,39.88 192.83,39.62 192.46,39.26 192.46,36.96 191.67,36.17 191.67,35.78 v2(192.09,35.36)
  BOTTOM w0.102: v2(30.08,28.34) 30.41,28.67 30.41,29.01 30.51,29.1 30.51,30.98 CT127.1
PCIE_PRX_TTX_P4: length 248.2
  TOP w0.094: v2(189.34,35.2) 189.49,35.05 189.49,34.81 UH1.R18
  IN1 w0.102: v2(28.4,26.94) 28.52,26.94 28.62,27.05 28.62,27.17 28.25,27.55 28.25,30.59 29.9,32.24 37.27,32.24 39.14,30.37 39.14,30.2 39.46,29.89 45.06,29.89 46.08,28.87 46.08,28.43 46.35,28.16 46.86,28.16 47.24,27.77 48.9,27.77 50.7,25.98 52.85,25.98 53.55,26.67 54.07,26.67 55.66,28.26 56.28,28.26 58.13,30.11 59.74,30.11 62.61,32.97 64.96,32.97 65.55,33.57 65.55,33.85 66.14,34.44 71.17,34.44 72.98,36.25 75.4,36.25 75.57,36.08 80.22,36.08 80.84,35.46 83.51,35.46 83.66,35.61 93.62,35.61 99.81,29.42 109.17,29.42 109.85,28.73 110.42,28.73 110.5,28.82 112.58,28.82 112.9,28.49 116.63,28.49 116.64,28.49 116.81,28.49 121.16,32.84 121.16,33.22 121.6,33.66 121.6,34.55 122.39,35.35 122.39,35.36 123.96,36.93 126.28,36.93 126.96,37.61 126.96,38.03 127.97,39.04 128.43,39.04 129.63,40.24 130.49,40.24 130.72,40.47 136.21,40.47 137.2,39.47 139.77,39.47 140.95,38.3 144.6,38.3 145.61,37.29 149.4,37.29 149.86,36.83 151.9,36.83 152.76,37.68 153.8,37.68 157.17,41.05 157.17,41.57 157.81,42.22 158.34,42.22 160.11,43.99 161.06,43.99 170.19,53.11 171.28,53.11 173.15,54.98 181.33,54.98 182.3,55.95 193.45,55.95 194.28,55.12 195.44,55.12 196.62,53.94 196.62,52.72 197.77,51.57 197.77,48.69 200.57,45.9 200.57,45.24 201.28,44.52 201.28,44.29 206.19,39.39 206.19,36.56 204.94,35.31 203.41,35.31 201.48,33.38 200.54,33.38 199.65,32.5 197.27,32.5 192.82,33.69 191.29,33.69 190.57,32.96 189.43,32.96 188.82,33.58 188.82,34.23 189.14,34.55 189.35,34.55 189.61,34.82 189.61,35.15 189.55,35.2 v2(189.34,35.2)
  BOTTOM w0.102: CT129.1 28.22,29.77 28.22,29.36 28.01,29.15 28.01,28.41 28.05,28.37 28.05,27.88 28.75,27.18 28.75,27.01 28.68,26.94 v2(28.4,26.94)
PCIE_PTX_C_DRX_N5: length 10.6
  BOTTOM w0.102: CL6.2 196.48,119.03 196.48,119.63 196.19,119.92 195.73,119.92 195.7,119.88 195.11,119.88 195.07,119.92 194.44,119.92 192.58,121.77 v4(191.89,121.77) 191.27,121.77 190.05,122.99 190.05,123.99 189.95,124.09 189.95,124.49 UL1.42
PCIE_PTX_C_DRX_N6: length 3.5
  BOTTOM w0.102: CR205.2 23.61,9.55 23.61,10.52 23.15,10.98 23.15,11.03 22.8,11.39 22.8,11.61 22.69,11.71 UR1.5
PCIE_PTX_C_DRX_N7: length 2.6
  BOTTOM w0.102: JNGFF1.29 325.9,9.39 325.75,9.24 325.75,8.9 325.45,8.6 325.45,8.04 CZ13.2
PCIE_PTX_C_DRX_N8: length 11.5
  TOP w0.102: v2(306.51,4.58) 306.76,4.33 306.76,4.22 306.98,4 308.4,4 308.52,3.88 308.52,3.45 CZ10.2
  BOTTOM w0.102: v2(306.51,4.58) 306.78,4.31 306.78,4.23 306.7,4.14 305.53,4.14 305.1,4.57 301.61,4.57 301.11,4.07 301.11,3.24 301,3.13 JNGFF2.39
PCIE_PTX_C_DRX_N9: length 3.8
  BOTTOM w0.102: JNGFF3.11 75.67,46.7 75.51,46.55 v4(74.2,46.55) 73.12,46.55 CN65.2
PCIE_PTX_C_DRX_N10: length 3.8
  BOTTOM w0.102: CN67.2 73.13,43.55 v4(74.21,43.55) 75.53,43.55 75.69,43.7 JNGFF3.23
PCIE_PTX_C_DRX_N11: length 2.8
  BOTTOM w0.102: CN69.2 74.18,40.55 75.52,40.55 75.67,40.7 JNGFF3.35
PCIE_PTX_C_DRX_N12: length 2.8
  BOTTOM w0.102: CN71.2 74.15,37.55 75.51,37.55 75.66,37.7 JNGFF3.47
PCIE_PTX_C_DRX_N17: length 2.8
  BOTTOM w0.102: CN186.2 351.25,11.26 v4(351.25,10.82) 351.25,9.95 351.4,9.79 JNGFF4.47
PCIE_PTX_C_DRX_N18: length 3.5
  BOTTOM w0.102: JNGFF4.35 354.4,9.77 354.25,9.93 354.25,10.48 v4(353.57,11.16) 353.34,11.39 353.34,11.71 CN184.2
PCIE_PTX_C_DRX_N19: length 3.4
  BOTTOM w0.102: CN182.2 356.48,11.67 356.48,11.46 v4(356.76,11.17) 357.25,10.69 357.25,9.98 357.4,9.83 JNGFF4.23
PCIE_PTX_C_DRX_N20: length 4.6
  BOTTOM w0.102: JNGFF4.11 360.4,9.85 360.25,10 360.25,10.48 359.54,11.18 v4(358.89,11.18) 358.36,11.18 358.27,11.27 358.27,11.71 CN180.2
PCIE_PTX_C_DRX_N21: length 3
  TOP w0.102: v2(77.62,12.76) 77.86,12.51 78.53,12.51 CN200.2
  BOTTOM w0.102: JNGFF5.47 77.07,12.65 77.22,12.5 77.44,12.5 77.62,12.67 v2(77.62,12.76)
PCIE_PTX_C_DRX_N22: length 2.9
  TOP w0.102: CN198.2 78.55,15.46 77.9,15.46 v2(77.62,15.75)
  BOTTOM w0.102: v2(77.62,15.75) 77.37,15.5 77.22,15.5 77.07,15.65 JNGFF5.35
PCIE_PTX_C_DRX_N23: length 3
  TOP w0.102: v2(77.64,18.73) 77.89,18.48 78.52,18.48 CN196.2
  BOTTOM w0.102: JNGFF5.23 77.09,18.65 77.26,18.48 77.38,18.48 77.63,18.73 v2(77.64,18.73)
PCIE_PTX_C_DRX_N24: length 3
  TOP w0.102: CN194.2 78.53,21.52 77.79,21.52 v2(77.55,21.76)
  BOTTOM w0.102: v2(77.55,21.76) 77.55,21.67 77.37,21.5 77.23,21.5 77.07,21.65 JNGFF5.11
PCIE_PTX_C_DRX_P5: length 10.6
  BOTTOM w0.102: CL5.2 196.67,119.03 196.67,119.71 196.27,120.11 v4(195.4,120.11) 194.52,120.11 192.66,121.96 192.22,121.96 192.18,122 191.58,122 191.54,121.96 191.35,121.96 190.24,123.07 190.24,124.01 190.35,124.12 UL1.41
PCIE_PTX_C_DRX_P6: length 3.5
  BOTTOM w0.102: UR1.4 23.09,11.68 22.99,11.58 22.99,11.47 v4(23.53,10.92) 23.8,10.65 23.8,9.55 CR203.2
PCIE_PTX_C_DRX_P7: length 2.6
  BOTTOM w0.102: JNGFF1.27 325.4,9.37 325.56,9.22 325.56,8.98 325.26,8.68 325.26,8.04 CZ12.2
PCIE_PTX_C_DRX_P8: length 11.5
  TOP w0.102: v2(307.15,4.58) 307.09,4.58 306.95,4.44 306.95,4.3 307.06,4.2 308.48,4.2 308.71,3.96 308.71,3.47 CZ11.2
  BOTTOM w0.102: v2(307.15,4.58) 306.97,4.4 306.97,4.15 306.78,3.95 305.45,3.95 305.02,4.38 301.69,4.38 301.3,3.99 301.3,3.32 301.41,3.22 301.41,3.2 301.5,3.1 JNGFF2.41
PCIE_PTX_C_DRX_P9: length 3.8
  BOTTOM w0.102: CN66.2 73.17,46.35 73.87,46.35 73.91,46.31 74.56,46.31 74.6,46.35 75.52,46.35 75.68,46.2 JNGFF3.13
PCIE_PTX_C_DRX_P10: length 3.8
  BOTTOM w0.102: CN68.2 73.16,43.35 73.83,43.35 73.87,43.31 74.53,43.31 74.57,43.35 75.53,43.35 75.68,43.2 JNGFF3.25
PCIE_PTX_C_DRX_P11: length 2.8
  BOTTOM w0.102: CN70.2 74.12,40.35 75.53,40.35 75.68,40.2 JNGFF3.37
PCIE_PTX_C_DRX_P12: length 2.8
  BOTTOM w0.102: JNGFF3.49 75.64,37.2 75.49,37.35 74.19,37.35 CN72.2
PCIE_PTX_C_DRX_P17: length 2.8
  BOTTOM w0.102: JNGFF4.49 350.9,9.79 351.06,9.94 351.06,10.49 351.02,10.53 351.02,11.12 351.06,11.15 351.06,11.32 CN187.2
PCIE_PTX_C_DRX_P18: length 3.6
  BOTTOM w0.102: JNGFF4.37 353.9,9.77 354.06,9.93 354.06,10.4 353.67,10.79 353.62,10.79 353.15,11.25 353.15,11.66 CN185.2
PCIE_PTX_C_DRX_P19: length 3.5
  BOTTOM w0.102: CN183.2 356.29,11.65 356.29,11.32 356.81,10.81 356.86,10.81 357.06,10.61 357.06,9.98 356.9,9.83 JNGFF4.25
PCIE_PTX_C_DRX_P20: length 4.7
  BOTTOM w0.102: JNGFF4.13 359.9,9.87 360.06,10.03 360.06,10.4 359.46,10.99 359.23,10.99 359.2,10.95 358.56,10.95 358.52,10.99 358.28,10.99 358.08,11.19 358.08,11.64 CN181.2
PCIE_PTX_C_DRX_P21: length 3
  TOP w0.102: CN201.2 78.54,12.32 77.9,12.32 v2(77.62,12.04)
  BOTTOM w0.102: v2(77.62,12.04) 77.62,12.13 77.44,12.3 77.22,12.3 77.07,12.15 JNGFF5.49
PCIE_PTX_C_DRX_P22: length 2.9
  TOP w0.102: CN199.2 78.52,15.27 77.86,15.27 v2(77.62,15.03)
  BOTTOM w0.102: v2(77.62,15.03) 77.34,15.31 77.23,15.31 77.08,15.15 JNGFF5.37
PCIE_PTX_C_DRX_P23: length 2.9
  TOP w0.102: CN197.2 78.59,18.29 77.91,18.29 v2(77.64,18.01)
  BOTTOM w0.102: v2(77.64,18.01) 77.63,18.01 77.35,18.29 77.22,18.29 77.08,18.15 JNGFF5.25
PCIE_PTX_C_DRX_P24: length 3
  TOP w0.102: CN195.2 78.57,21.33 77.84,21.33 v2(77.55,21.04)
  BOTTOM w0.102: JNGFF5.13 77.08,21.15 77.23,21.3 77.38,21.3 77.55,21.13 v2(77.55,21.04)
PCIE_PTX_C_TRX_N1: length 4.8
  BOTTOM w0.076: 34.9,32.94 34.44,33.4 34.44,33.71 UT1.Y22
  BOTTOM w0.102: CT3.1 37.38,31.66 37.38,31.76 37.17,31.97 36.97,31.97 36.93,31.93 36.21,31.93 35.67,32.47 35.52,32.47 35.05,32.94 34.9,32.94
PCIE_PTX_C_TRX_N2: length 3.8
  BOTTOM w0.076: UT1.T22 32.6,33.72 32.6,33.39 32.91,33.08 32.91,32.94 33.16,32.68 33.16,32.65 33.17,32.64
  BOTTOM w0.102: CT5.1 34.17,31.23 34.17,31.59 33.73,32.03 33.73,32.09 33.17,32.64
PCIE_PTX_C_TRX_N3: length 3.7
  BOTTOM w0.076: UT1.M22 30.75,33.79 30.75,33.38 31,33.14 31,32.83 31.12,32.71 31.12,32.68 31.13,32.67
  BOTTOM w0.102: 31.13,32.67 31.67,32.13 31.67,30.96 CT124.1
PCIE_PTX_C_TRX_N4: length 2.6
  BOTTOM w0.076: UT1.H22 28.92,33.7 28.92,33.21 28.99,33.14 28.99,32.88 28.98,32.86 28.98,32.84
  BOTTOM w0.102: 28.98,32.84 28.98,32.54 29.27,32.24 29.27,31.95 CT126.1
PCIE_PTX_C_TRX_P1: length 4.7
  BOTTOM w0.076: 34.94,33.13 34.92,33.13 34.82,33.23 34.82,33.3 34.9,33.38 34.9,33.69 34.84,33.75 34.75,33.75 34.66,33.66 UT1.Y23
  BOTTOM w0.102: CT2.1 37.57,31.6 37.57,31.84 37.25,32.16 v4(36.57,32.16) 36.25,32.16 35.75,32.66 35.6,32.66 35.13,33.13 34.94,33.13
PCIE_PTX_C_TRX_P2: length 3.7
  BOTTOM w0.076: UT1.T23 32.82,33.7 32.9,33.77 33,33.77 33.06,33.72 33.06,33 33.28,32.78 33.31,32.78
  BOTTOM w0.102: 33.31,32.78 v4(34.15,31.93) 34.36,31.72 34.36,31.25 CT4.1
PCIE_PTX_C_TRX_P3: length 3.7
  BOTTOM w0.076: 31.26,32.8 31.25,32.82 31.22,32.82 31.15,32.89 31.15,33.31 31.22,33.38 31.22,33.69 31.14,33.76 31.06,33.76 30.98,33.68 UT1.M23
  BOTTOM w0.102: 31.26,32.8 31.86,32.21 31.86,31.04 CT123.1
PCIE_PTX_C_TRX_P4: length 2.5
  BOTTOM w0.076: 29.17,32.84 29.17,32.86 29.15,32.88 29.15,33.15 29.38,33.38 29.38,33.62 29.31,33.69 29.21,33.69 29.14,33.62 UT1.H23
  BOTTOM w0.102: 29.17,32.84 29.17,32.62 29.46,32.32 29.46,31.9 CT125.1
PCIE_PTX_DRX_N5: length 140.4
  TOP w0.102: UH1.B21 196.04,33.55 199.01,33.55 199.29,33.82 201.54,33.82 202.26,34.54 203.25,34.54 v2(203.5,34.79)
  IN1 w0.102: v2(213.67,105.68) 213.77,105.58 213.77,105.44 207.67,99.34 207.67,90.56 204.29,87.19 200.38,87.19 198.49,85.3 198.49,83.51 191.21,76.23 191.21,74.45 186.04,69.28 186.04,59.07 186.74,58.37 192.65,58.37 194.72,56.3 195.11,56.3 195.71,55.7 196.11,55.7 197.35,54.46 197.35,52.92 198.72,51.54 198.72,48.43 201.05,46.1 201.05,45.44 201.78,44.71 201.78,44.48 206.67,39.59 206.67,36.22 204.73,34.29 204,34.29 v2(203.5,34.79)
  IN2 w0.094: v2(213.67,105.68) 213.73,105.61 214.16,105.61 214.28,105.74 214.28,112.45 211.64,115.08 203.53,115.08 201.47,117.14 200.32,117.14 198.59,115.41 198.59,114.94 197.99,114.34 v2(197.14,114.34)
  BOTTOM w0.102: CL6.1 196.47,117.76 196.47,115.01 v2(197.13,114.34)
PCIE_PTX_DRX_N6: length 231
  TOP w0.102: UH1.D21 194.84,33.14 194.84,33.04 195.04,32.84 195.4,32.84 195.8,32.84 196.12,32.52 199.14,32.52 199.64,33.02 201.56,33.02 201.68,32.9 201.68,32.58 201.59,32.49 v2(201.28,32.49)
  IN1 w0.102: v2(201.28,32.49) 201.62,32.15 201.62,31.44 197.6,27.42 193.89,27.42 193.32,27.99 192.63,27.99 192.35,28.27 189.8,28.27 188.47,26.94 186.03,26.94 185.25,26.16 185.25,24.6 185.03,24.38 185.03,23.38 184.69,23.04 184.69,22.22 184.24,21.77 184.24,18.7 182.33,16.79 178.23,16.79 177.1,17.92 177.1,18.56 176,19.66 175.13,19.66 174.5,20.28 173.41,20.28 172.28,21.41 172.28,21.91 170.9,23.29 170.22,23.29 169.92,22.99 169.92,22.1 169.29,21.48 167.81,21.48 167.23,22.05 167.23,22.29 165.93,23.59 161.75,23.59 161.45,23.29 159.87,23.29 159.5,23.66 158.76,23.66 157.82,24.59 157.05,24.59 156.09,23.63 155.58,23.63 155.01,23.06 154.31,23.06 153.17,24.2 148.65,24.2 148.13,23.68 147.7,23.68 146.87,22.85 146.03,22.85 144.37,21.19 142.52,21.19 141.44,22.27 140.42,22.27 139.87,21.72 139.87,20.18 139.31,19.62 138.11,19.62 137.34,18.85 137.02,18.85 136.72,18.55 135.96,18.55 135.93,18.58 132.61,18.58 131.72,17.69 130.15,17.69 129.73,17.27 128.31,17.27 128.04,17.55 127.18,17.55 126.98,17.75 124.49,17.75 124.09,17.35 121.34,17.35 120.74,16.75 119.55,16.75 118.48,17.82 116.16,17.82 114.94,19.04 111.17,19.04 111.11,18.98 106.15,18.98 106.09,19.04 101.97,19.04 100.76,17.83 97.07,17.83 93.35,21.55 92.26,21.55 91.55,22.27 84.96,22.27 84.05,23.19 80.81,23.19 79.65,24.35 77.7,24.35 77.4,24.05 73.81,24.05 70.76,21 68.37,21 66.7,19.33 64.48,19.33 64.31,19.5 62.21,19.5 61.36,18.65 61.36,15.2 59,12.84 55.02,12.84 53.6,14.27 53.6,15.06 52.08,16.58 51.3,16.58 51.21,16.67 49.2,16.67 49.2,16.66 48.86,16.66 48.55,16.97 45.75,16.97 38.06,9.29 34.69,9.29 32.59,7.19 30,7.19 28.65,8.54 23.96,8.54 23.62,8.2 23.62,7.78 v2(23.35,7.52)
  BOTTOM w0.102: v2(23.35,7.52) 23.61,7.78 23.61,8.27 CR205.1
PCIE_PTX_DRX_N7: length 147.5
  TOP w0.102: v2(203.56,30.9) 203.87,30.9 203.92,30.95 203.99,31.02 203.99,31.61 203.7,31.9 195.96,31.9 195.7,32.15 195.69,32.15 195.69,32.16 195.44,32.16 195.21,32.39 195.21,32.52 UH1.C23
  IN4 w0.102: v2(324.51,5.75) 324.51,5.08 323.13,3.7 315.3,3.7 315.08,3.92 313.67,3.92 312.74,4.84 311.92,4.84 311.78,4.98 308.64,4.98 307.09,4.98 306.84,4.98 305.37,6.44 301.04,6.44 300.95,6.35 295.32,6.35 294.8,6.86 290.66,6.86 290.38,6.58 285.82,6.58 284.47,7.93 283.03,7.93 282.56,8.4 281.21,8.4 280.75,8.85 278.23,8.85 276.18,10.91 270.43,10.91 269.02,12.32 267.36,12.32 263.81,15.86 253.85,15.86 246.18,23.54 233.56,23.54 232.94,22.92 226.18,22.92 225.22,23.88 214.24,23.88 211.1,27.01 208.59,27.01 205.52,30.08 204.04,30.08 203.75,30.36 203.75,30.7 v2(203.56,30.9)
  BOTTOM w0.102: v2(324.51,5.75) 324.4,5.75 324.27,5.87 324.27,6.01 324.41,6.15 325.14,6.15 v4(325.29,6.3) 325.45,6.46 325.45,6.75 CZ13.1
PCIE_PTX_DRX_N8: length 141.2
  TOP w0.102: v2(311.77,3.65) 311.58,3.47 311.58,2.53 310.78,1.72 v4(309.73,1.72) 308.76,1.72 308.56,1.92 308.56,2.14 CZ10.1 ; UH1.B24 v2(194.74,31.6)
  IN4 w0.102: v2(194.74,31.6) 194.74,31.78 194.99,32.03 195.66,32.03 199.93,27.76 199.93,27.63 201.48,26.08 202.74,26.08 203.27,25.55 206.6,25.55 207.87,24.28 210.05,24.28 214.01,20.31 232.36,20.31 233.37,19.31 246.9,19.31 252.82,13.38 260.29,13.38 262.77,10.89 262.77,8.23 264.95,6.06 271.47,6.06 273.56,8.15 275.82,8.15 277.79,6.18 281.2,6.18 281.39,5.99 283.66,5.99 285.02,4.63 285.74,4.63 286.14,4.23 289.01,4.23 289.41,4.63 291.17,4.63 291.41,4.87 293.87,4.87 294.94,3.8 300.35,3.8 301.63,5.08 303.55,5.08 305.82,2.81 311.23,2.81 311.58,3.16 311.58,3.46 v2(311.77,3.65)
PCIE_PTX_DRX_N9: length 205.9
  TOP w0.102: UH1.C34 195.11,26.88 195.69,26.88 195.89,26.88 196.41,26.88 196.51,26.78 198.8,26.78 199.43,26.15 209.05,26.15 209.5,25.7 209.5,24.81 209.34,24.66 209.16,24.66 209.04,24.78 v2(209.04,24.96)
  IN2 w0.094: v2(209.04,24.96) 209.38,24.62 209.38,23.48 208.78,22.88 208.78,18.53 206.06,15.81 200.38,15.81 198.04,13.47 197.5,13.47 197.18,13.79 195.07,13.79 193.47,12.19 193.47,11.42 191.19,9.13 188.55,9.13 187.31,7.89 179.84,7.89 179.5,7.55 178.62,7.55 178.01,8.16 175.26,8.16 174.29,7.19 173.2,7.19 170.99,9.41 162.71,9.41 160.03,12.09 159.37,12.09 158.42,13.04 156.2,13.04 155.46,13.78 155.46,14.77 154.95,15.28 151.27,15.28 150.72,14.73 150.72,13.79 149.57,12.64 149.18,12.64 147.85,11.31 145.57,11.31 144.09,9.83 141.55,9.83 140.5,8.78 140.5,8.64 139.85,7.99 135.33,7.99 135.02,7.68 127.73,7.68 127.13,8.29 125.52,8.29 125.26,8.55 124.28,8.55 122.19,6.45 117.76,6.45 116.93,7.29 114.73,7.29 109.97,12.05 100.01,12.05 92.59,19.48 91.25,19.48 90.75,19.98 90.75,20.76 88.83,22.67 88.83,24.03 87.97,24.89 87.97,25.53 86.81,26.7 86.81,27.25 85.72,28.34 83.58,28.34 83.38,28.13 81.19,28.13 80.79,27.74 80.44,27.74 80.17,27.47 79.54,27.47 79.19,27.83 79.19,28.86 77.07,30.98 77.07,31.63 77.83,32.39 77.83,33.7 76.95,34.58 76.95,36.27 75.09,38.13 74.07,38.13 72.36,39.84 71.96,39.84 71.73,39.62 71.73,39.19 71.65,39.1 v2(71.48,39.1)
  BOTTOM w0.102: CN65.1 71.86,46.52 71.28,46.52 70.83,46.07 v4(70.83,45.43) 70.83,44.03 70.77,43.97 70.77,40.45 71.48,39.74 v2(71.48,39.1)
PCIE_PTX_DRX_N10: length 194.7
  TOP w0.102: UH1.C35 195.26,26.27 195.42,26.24 195.69,26.24 195.7,26.26 195.71,26.26 195.83,26.38 197.03,26.38 197.33,26.38 198.46,26.38 199.29,25.55 206.39,25.55 208.08,23.85 209.07,23.85 210.71,22.21 210.71,21.04 209.93,20.25 206.66,20.25 205.89,19.48 205.89,19.24 v2(205.62,18.98)
  IN2 w0.094: v2(71.36,40.88) 71.42,40.88 71.59,40.71 71.59,40.53 71.88,40.24 75.41,40.24 76.28,39.37 76.28,38.38 78.04,36.62 78.04,35.22 79.83,33.44 79.83,32.79 80.96,31.66 82.49,31.66 83.36,30.79 85.91,30.79 88.86,27.84 90.67,27.84 91.49,27.01 91.49,23.45 94.03,20.91 94.03,19.71 95.15,18.59 95.15,18.58 100.53,13.2 111.7,13.2 112.84,12.07 112.84,11.45 113.86,10.43 120.23,10.43 121.46,9.2 123.17,9.2 123.68,9.7 125.74,9.7 125.94,9.5 129.36,9.5 129.68,9.17 137.83,9.17 138.29,9.63 139.94,9.63 141.33,11.02 143.59,11.02 145.05,12.48 146.61,12.48 147.73,13.61 147.73,14.03 147.99,14.29 147.99,15.32 148.29,15.63 149.97,15.63 150.73,16.39 155.5,16.39 157.15,14.74 158.35,14.74 159.48,13.62 160.7,13.62 162.41,11.91 163.04,11.91 163.58,11.37 164.66,11.37 165.13,11.84 167.07,11.84 168.22,10.69 171.38,10.69 172.13,9.94 177.04,9.94 177.61,9.37 178.56,9.37 178.86,9.07 184.22,9.07 184.74,9.59 187.26,9.59 188,10.33 190.7,10.33 191.11,10.74 191.11,12.17 193.14,14.21 193.14,14.47 194.49,15.82 197.83,15.82 200.41,18.4 204.25,18.4 205.45,19.6 205.84,19.6 205.96,19.49 205.96,19.31 v2(205.62,18.98)
  BOTTOM w0.102: v2(71.36,40.88) 71.36,43.28 71.58,43.49 71.82,43.49 CN67.1
PCIE_PTX_DRX_N11: length 186.8
  TOP w0.102: UH1.B36 195.67,25.85 195.84,25.85 195.97,25.98 198.08,25.98 199.11,24.95 v4(200.09,24.95) 204.92,24.95 207.29,22.58 208.38,22.58 208.46,22.5 208.46,22.38 v2(208.25,22.17)
  IN2 w0.094: v2(74.23,38.63) 74.45,38.86 74.72,38.86 74.82,38.96 75.35,38.96 75.62,38.69 75.62,38.17 77.39,36.41 77.39,35.04 79.14,33.28 79.14,32.63 80.71,31.06 82.21,31.06 83.08,30.19 85.67,30.19 88.62,27.24 89.46,27.24 90.86,25.85 90.86,23.24 93.36,20.74 93.36,19.43 94.48,18.31 94.48,18.3 100.25,12.53 110.18,12.53 112.4,10.31 113.02,10.31 114.36,8.97 115.05,8.97 115.48,9.4 120.12,9.4 121.05,8.47 123.4,8.47 123.96,9.02 125.46,9.02 125.66,8.82 129.03,8.82 129.77,8.08 134.44,8.08 134.82,8.46 138.25,8.46 138.74,8.95 140.11,8.95 141.48,10.33 143.92,10.33 145.38,11.79 147.6,11.79 148.57,12.76 148.57,13.98 149.17,14.58 149.88,14.58 151.04,15.74 155.18,15.74 155.95,14.97 155.95,14.11 156.51,13.55 158.59,13.55 159.38,12.76 160.13,12.76 162.97,9.92 171.18,9.92 171.84,9.26 176.5,9.26 177.1,8.65 178.43,8.65 178.71,8.38 187.06,8.38 188.31,9.63 190.98,9.63 192.93,11.58 192.93,12.33 195.16,14.57 198.03,14.57 200.06,16.6 206.16,16.6 207.76,18.19 207.76,22.38 207.87,22.49 208.09,22.49 208.25,22.33 v2(208.25,22.17)
  BOTTOM w0.102: v2(74.23,38.63) 73.36,38.63 72.34,39.65 72.34,40.38 72.58,40.63 72.91,40.63 CN69.1
PCIE_PTX_DRX_N12: length 204.1
  TOP w0.102: v2(205.5,21.47) 205.76,21.21 205.87,21.21 205.95,21.28 205.95,22.98 204.57,24.35 199.05,24.35 198.48,24.92 198.35,24.92 197.72,25.56 196.13,25.56 196.13,25.55 196.1,25.55 195.92,25.37 194.94,25.37 UH1.D38
  IN2 w0.094: v2(205.5,21.47) 205.85,21.47 205.96,21.37 205.96,20.9 206.22,20.63 206.67,20.63 207.06,21.02 207.06,24.46 208.27,25.67 210.56,25.67 211.14,25.09 211.14,19.93 206.36,15.15 200.7,15.15 198.31,12.76 197.12,12.76 196.86,13.03 196.06,13.03 191.47,8.45 188.82,8.45 187.58,7.21 180.15,7.21 179.81,6.86 179.19,6.86 178.7,6.38 177.31,6.38 176.64,7.05 175.22,7.05 174.55,6.38 172.97,6.38 170.62,8.73 160.99,8.73 158.69,11.03 158.69,11.82 158.14,12.37 155.63,12.37 154.25,10.99 151.87,10.99 151.37,10.49 148,10.49 145.44,7.93 144.28,7.93 143.6,7.25 140.74,7.25 139.77,6.28 135.88,6.28 135.15,7.01 130.36,7.01 129.64,6.3 127.89,6.3 126.6,7.58 125.31,7.58 125.05,7.32 124.03,7.32 122.57,5.86 115.21,5.86 109.7,11.36 98.13,11.36 89.88,19.62 89.88,20.6 88.16,22.32 88.16,23.69 86.36,25.48 86.36,26.28 85.52,27.12 83.84,27.12 83.42,27.54 81.61,27.54 81.14,27.06 80.75,27.06 80.38,26.7 78.76,26.7 77.69,27.77 77.69,28.17 75.64,30.23 75.64,32.24 76.32,32.93 76.32,36.05 74.89,37.49 72.74,37.49 v2(72.51,37.72)
  BOTTOM w0.102: v2(72.51,37.72) 72.74,37.49 72.86,37.49 CN71.1
PCIE_PTX_DRX_N17: length 183.9
  TOP w0.076: UH1.A42 196.14,23.11 196.09,23.05 196.09,22.83 196.16,22.75 196.81,22.75 196.91,22.86 197.31,22.86 197.33,22.87 197.35,22.87
  TOP w0.102: 197.35,22.87 202.48,22.87 204.05,21.31 v2(204.05,19.96)
  IN1 w0.102: v2(347.23,9.37) 347.31,9.37 347.6,9.08 347.6,8.85 347.45,8.71 347.1,8.71 346.68,9.13 343.79,9.13 343.54,9.37 341.81,9.37 341.58,9.15 338.97,9.15 337.82,8 337.29,8 336.95,7.66 330.29,7.66 327.99,5.36 327.99,3.54 327.35,2.91 324.72,2.91 324.44,3.19 316.25,3.19 316.25,3.19 315.23,3.19 314.99,3.43 313.78,3.43 313.54,3.19 309.53,3.19 309.24,2.9 296.33,2.9 293.73,5.5 290.92,5.5 290.1,4.68 290.1,3.99 289.89,3.78 287.28,3.78 286.2,4.87 285.25,4.87 283.92,6.19 277.12,6.19 276.16,5.23 274.45,5.23 273.87,4.65 262.58,4.65 261.24,5.99 261.24,7.04 262.21,8.01 262.21,11.91 259.45,14.67 257.31,14.67 254.17,17.81 241.04,17.81 240.18,16.96 231.93,16.96 231.29,17.59 217.53,17.59 217.13,17.19 205.07,17.19 203.62,18.65 203.62,20.15 203.7,20.23 203.78,20.23 v2(204.05,19.96)
  BOTTOM w0.102: v2(347.23,9.37) 347.42,9.56 347.42,10.12 348.71,11.4 349.02,11.4 349.48,11.85 349.53,11.85 349.81,12.13 349.81,12.18 350.5,12.87 350.56,12.93 351.11,12.93 351.34,12.7 351.34,12.5 CN186.1
PCIE_PTX_DRX_N18: length 177.7
  TOP w0.076: UH1.C42 195.06,22.91 195.03,22.93 195.03,23.09 195.14,23.2 195.82,23.2 195.98,23.36 196.6,23.36 196.68,23.28 197.32,23.28 197.34,23.26 197.35,23.26
  TOP w0.102: 197.35,23.26 197.6,23.26 197.66,23.32 200.24,23.32 200.26,23.29 200.86,23.29 200.89,23.32 202.64,23.32 203.1,22.87 203.76,22.87 203.99,23.1 v2(203.99,23.78)
  IN1 w0.102: v2(203.99,23.78) 203.71,23.78 203.59,23.91 203.59,24.17 203.69,24.28 205.27,24.28 207.54,22 207.54,21.33 209.11,19.77 215.92,19.77 216.24,20.09 232.52,20.09 233.11,19.49 238.6,19.49 239.46,20.36 242.35,20.36 243.17,21.17 254.57,21.17 257.99,17.75 260.6,17.75 264.95,13.41 264.95,12.83 266.64,11.14 269.29,11.14 271.24,9.19 278.96,9.19 279.76,9.99 280.93,9.99 281.7,9.21 284.43,9.21 285.09,8.55 289.11,8.55 289.52,8.14 295.82,8.14 296.64,7.32 303.57,7.32 304.06,6.83 306.97,6.83 307.42,6.38 312.59,6.38 312.9,6.7 314.62,6.7 314.92,6.39 315.9,6.39 316.27,6.76 320.8,6.76 321.05,6.51 321.9,6.51 325.93,10.54 332.4,10.54 333.53,11.68 339.96,11.68 340.91,12.64 347.54,12.64 347.75,12.85 348.75,12.85 348.89,12.71 348.89,12.38 348.79,12.28 348.54,12.28 v2(348.47,12.35)
  BOTTOM w0.102: v2(348.47,12.35) 348.69,12.58 348.69,12.85 349.52,13.68 352.98,13.68 353.41,13.25 353.41,12.88 CN184.1
PCIE_PTX_DRX_N19: length 184.1
  TOP w0.076: UH1.C44 195.23,22.39 195.23,22.49 195.36,22.55 195.58,22.55 195.89,22.25 197.09,22.25 197.29,22.04 197.29,22.02 197.35,21.96
  TOP w0.102: v2(202.23,22.25) 202,22.02 202,21.79 201.74,21.53 200.8,21.53 200.77,21.5 200.17,21.5 200.14,21.53 197.78,21.53 197.35,21.96
  IN1 w0.102: v2(202.23,22.25) 202.08,22.25 201.84,22 201.84,21.8 201.95,21.7 204.59,21.7 205.31,20.97 206.19,20.97 208.6,18.56 216.39,18.56 216.76,18.93 231.94,18.93 232.57,18.31 239.31,18.31 240.18,19.17 243.05,19.17 243.44,19.56 254.43,19.56 257.33,16.67 257.8,16.2 259.9,16.2 263.6,12.51 263.6,7.89 265.46,6.03 271.21,6.03 273.12,7.93 280.11,7.93 280.27,8.09 281.13,8.09 281.24,7.99 284.03,7.99 285.79,6.23 286.82,6.23 287.51,5.54 289.05,5.54 290.36,6.85 295.27,6.85 295.98,6.14 303.07,6.14 303.69,5.52 306.59,5.52 306.94,5.17 311.15,5.17 311.33,5 314.12,5 314.34,4.77 315.54,4.77 315.79,4.53 321.65,4.53 323.47,6.36 324.52,6.36 324.93,6.77 324.93,7.73 326.54,9.35 332.83,9.35 333.44,9.96 337.77,9.96 338.33,10.52 340.52,10.52 340.93,10.93 350.5,10.93 351.32,11.74 353.84,11.74 354.14,11.44 354.49,11.44 354.82,11.78 354.82,12.02 354.69,12.16 354.42,12.16 v2(354.36,12.09)
  BOTTOM w0.102: CN182.1 356.57,12.84 356.57,13.06 356.22,13.41 355.24,13.41 354.57,12.74 354.57,12.3 v2(354.36,12.09)
PCIE_PTX_DRX_N20: length 181.4
  TOP w0.102: v2(209.43,21.75) 209.43,21.91 209.62,22.1 209.78,22.1 209.85,22.02 209.85,21.17 209.63,20.95 206.51,20.95 204.67,19.12 203.52,19.12 201.7,20.94 197.93,20.94 196.96,21.91 196.35,21.91 UH1.A44
  IN1 w0.102: v2(358.65,13.48) 358.42,13.25 358.42,13.03 357.98,12.58 357.16,12.58 355.8,13.94 353.57,13.94 353.33,13.7 352.54,13.7 352.29,13.95 350.76,13.95 350.04,14.67 347.92,14.67 347.7,14.46 344.93,14.46 344.36,15.02 343.52,15.02 342.63,14.13 340.44,14.13 339.39,13.08 325.74,13.08 323.97,11.31 323.97,10.96 322.3,9.29 319.71,9.29 319.61,9.19 319.61,8.58 319.13,8.11 313.76,8.11 312.85,9.01 310.06,9.01 309.59,9.48 307.73,9.48 307.58,9.33 299.27,9.33 299.09,9.51 290.64,9.51 289.78,10.37 285.49,10.37 284.52,11.33 278.98,11.33 278.67,11.02 271.32,11.02 269.81,12.53 267.18,12.53 266.45,13.25 266.45,13.83 260.82,19.47 258.4,19.47 255.29,22.58 242.32,22.58 241.46,21.72 238.65,21.72 238.35,21.41 233.61,21.41 232.62,22.41 214.16,22.41 212.9,21.14 209.77,21.14 209.6,21.31 209.6,21.58 v2(209.43,21.75)
  BOTTOM w0.102: v2(358.65,13.48) 358.24,13.07 358.24,12.93 CN180.1
PCIE_PTX_DRX_N21: length 141.7
  TOP w0.076: UH1.G47 193.73,20.4 193.73,20.01 193.97,19.78 193.97,19.24 193.95,19.22 193.95,19.2
  TOP w0.102: CN200.1 79.85,12.48 80.19,12.48 80.81,13.11 80.81,13.16 81.22,13.57 81.27,13.57 81.9,14.19 81.9,15.28 81.66,15.52 v2(81.41,15.52) ; v2(185.5,9.11) 185.76,9.36 185.76,9.81 185.89,9.95 186.94,9.95 187.78,9.11 191.41,9.11 193.94,11.65 193.94,12.84 195.35,14.24 195.35,16.12 194.87,16.6 194.87,17.84 193.95,18.76 193.95,19.2
  IN1 w0.102: v2(185.5,9.11) 185.78,8.82 185.78,8.63 185.7,8.55 180.38,8.55 179.18,9.75 177.8,9.75 176.02,11.53 174,11.53 172.72,12.81 172.72,13.89 172.42,14.19 165.12,14.19 163.7,15.62 162.16,15.62 161.62,16.16 161.02,16.16 160.53,16.65 156.37,16.65 155.78,17.24 154.96,17.24 154.72,17.48 149.69,17.48 149.4,17.19 148.02,17.19 147.29,16.46 146.31,16.46 143.75,13.9 141.07,13.9 140.06,12.89 138.71,12.89 136.75,10.93 135.11,10.93 134.78,11.26 130.81,11.26 130.41,10.86 127.48,10.86 127.02,11.32 124.62,11.32 124.45,11.48 121.08,11.48 120.91,11.31 118.94,11.31 118.04,10.4 112.93,10.4 110.59,12.73 94.08,12.73 92.75,14.07 91.1,14.07 90.09,15.08 84.77,15.08 83.54,16.32 81.96,16.32 81.74,16.11 81.74,15.85 v2(81.41,15.52)
PCIE_PTX_DRX_N22: length 140.8
  TOP w0.076: 192.29,19.57 192.29,19.59 192.31,19.61 192.31,20.38 192.53,20.59 UH1.H47
  TOP w0.102: v2(81.28,18.28) 81.48,18.28 81.57,18.18 81.57,17.8 v4(80.95,17.17) 80.5,16.72 80.5,15.82 80.06,15.38 79.7,15.38 79.47,15.62 CN198.1 ; 192.29,19.57 192.29,19.38 192.29,19.38 192.29,18.09 193.07,17.31 193.07,14.8 192.08,13.81 192.08,13.15 190.03,11.1 188.88,11.1 186.42,13.56 183.13,13.56 182.59,13.01 182.59,12.51 182.76,12.35 182.76,11.78 182.17,11.19 182.17,9.99 v2(181.92,9.74)
  IN1 w0.102: v2(81.28,18.28) 81.58,17.97 81.58,17.76 81.81,17.53 84.7,17.53 85.95,16.27 90.53,16.27 91.58,15.22 93.29,15.22 94.62,13.9 106.56,13.9 107.23,14.56 111.39,14.56 113.12,12.82 119.17,12.82 119.48,12.51 120.39,12.51 120.59,12.72 125.32,12.72 126.14,13.54 127.36,13.54 128.15,12.76 130.68,12.76 130.85,12.93 137.11,12.93 138.23,14.04 139.58,14.04 142.36,16.82 143.5,16.82 143.94,17.26 144.86,17.26 145.21,17.61 146.67,17.61 147.51,18.46 147.99,18.46 148.76,19.23 150.28,19.23 150.56,19.51 153.03,19.51 153.57,18.97 154.32,18.97 154.47,18.82 155.13,18.82 155.55,18.4 157.47,18.4 158.06,17.81 160.99,17.81 161.41,17.4 163.01,17.4 163.4,17.01 164.56,17.01 166.22,15.34 170.59,15.34 171.14,15.9 172.42,15.9 175.13,13.2 176.02,13.2 177.93,11.28 179.45,11.28 179.95,10.78 181.69,10.78 182.15,10.33 182.15,9.97 v2(181.92,9.74)
PCIE_PTX_DRX_N23: length 139.9
  TOP w0.076: UH1.G49 193.27,19.7 193.35,19.78 193.45,19.78 193.51,19.71 193.51,18.77 193.49,18.75 193.49,18.73
  TOP w0.102: CN196.1 79.49,18.52 79.57,18.44 79.99,18.44 80.7,19.15 80.7,19.26 v2(80.46,19.51) ; v2(183.51,10.34) 183.8,10.63 183.8,10.85 184.14,11.2 185.3,11.2 185.88,10.62 187.29,10.62 188.14,9.77 191.08,9.77 v4(192.6,11.28) 193.31,12 193.31,13.17 194.73,14.59 194.73,15.82 194.27,16.27 194.27,17.66 193.49,18.44 193.49,18.73
  IN1 w0.102: v2(183.51,10.34) 183.77,10.61 183.77,10.92 183.6,11.1 182.79,11.1 182.51,11.37 180.2,11.37 179.68,11.9 178.19,11.9 176.28,13.81 175.8,13.81 175.5,14.1 175.5,14.74 174.97,15.28 174.97,15.75 174.08,16.65 172.88,16.65 172.31,17.21 170.97,17.21 169.69,15.94 166.47,15.94 164.21,18.2 163.32,18.2 163.2,18.08 161.66,18.08 161.33,18.41 158.42,18.41 157.83,19 155.79,19 154.69,20.1 152.38,20.1 151.79,20.69 151.47,20.69 151.01,20.22 150.4,20.22 150.03,19.85 148.49,19.85 147.74,19.1 147.21,19.1 146.33,18.23 144.95,18.23 144.59,17.87 143.7,17.87 143.25,17.42 142.12,17.42 139.34,14.64 137.98,14.64 136.86,13.52 130.77,13.52 130.34,13.95 127.85,13.95 127.67,14.13 125.24,14.13 124.68,13.57 119.7,13.57 119.55,13.42 113.36,13.42 111.58,15.21 106.79,15.21 106.21,14.63 100.61,14.63 100.32,14.92 94.54,14.92 93.64,15.82 91.83,15.82 90.72,16.93 86.72,16.93 84.88,18.76 80.95,18.76 80.65,19.06 80.65,19.32 v2(80.46,19.51)
PCIE_PTX_DRX_N24: length 141.5
  TOP w0.102: v2(183.19,12.77) 183.41,12.55 183.41,12.18 183.86,11.73 185.74,11.73 186.23,11.24 187.3,11.24 188.28,10.27 191.01,10.27 192.89,12.15 192.89,13.41 193.33,13.86 193.33,13.91 193.87,14.44 193.87,17.59 193.01,18.45 193.01,19.71 193.17,19.87 193.17,20.95 193.1,21.03 193.1,21.23 193.14,21.27 193.24,21.27 UH1.G46 ; v2(81.43,20.91) 81.33,21.01 81.33,21.42 81.12,21.62 79.75,21.62 CN194.1
  IN1 w0.102: v2(81.43,20.91) 81.01,21.33 81.01,21.56 81.08,21.64 81.36,21.64 81.7,21.3 83.07,21.3 83.65,20.72 89.18,20.72 91.01,18.88 91.01,18.53 92.38,17.16 94.22,17.16 95.1,16.28 100.85,16.28 101.16,15.97 105.29,15.97 105.92,16.61 112.4,16.61 113.52,15.49 116.45,15.49 116.75,15.18 121.72,15.18 122.03,15.49 124.51,15.49 124.9,15.89 125.82,15.89 125.91,15.99 127.33,15.99 127.61,15.71 130.9,15.71 131.25,16.05 133.13,16.05 133.41,16.33 137.8,16.33 139.06,17.59 139.61,17.59 140.03,18.01 140.03,18.14 141.17,19.28 144.11,19.28 144.39,19.57 145.75,19.57 148.28,22.09 148.76,22.09 149.35,22.68 151.26,22.68 151.89,22.04 153.17,22.04 153.74,21.47 155.21,21.47 155.42,21.27 159.66,21.27 160.14,21.75 160.52,21.75 160.92,21.36 165.16,21.36 166.49,20.03 166.49,19.51 167.39,18.61 169.35,18.61 170.1,19.37 171.98,19.37 172.61,18.74 172.84,18.74 173.48,18.1 174.54,18.1 179.37,13.27 182,13.27 182.26,13.53 183.52,13.53 183.67,13.39 183.67,12.8 183.59,12.72 183.24,12.72 v2(183.19,12.77)
PCIE_PTX_DRX_P5: length 140.4
  TOP w0.102: UH1.A22 196.12,33.08 196.05,33.15 196.05,33.26 196.14,33.36 199.09,33.36 199.37,33.63 201.62,33.63 202.34,34.35 203.25,34.35 v2(203.5,34.1)
  IN1 w0.102: v2(203.5,34.1) 204.81,34.1 206.86,36.14 206.86,39.67 201.97,44.55 201.97,44.78 201.24,45.51 201.24,46.18 198.91,48.51 198.91,51.62 197.53,52.99 197.53,54.53 196.18,55.88 195.79,55.88 195.19,56.49 194.8,56.49 192.73,58.56 186.81,58.56 186.23,59.15 186.23,69.2 191.4,74.37 191.4,76.15 198.68,83.43 198.68,85.22 200.46,87 204.37,87 207.85,90.49 207.85,99.26 213.94,105.34 214.01,105.34 v2(214.14,105.21)
  IN2 w0.094: v2(197.6,114.81) 197.6,114.63 197.7,114.53 197.9,114.53 198.39,115.02 198.39,115.49 200.24,117.34 201.55,117.34 203.61,115.28 211.72,115.28 214.47,112.53 214.47,105.66 214.14,105.32 v2(214.14,105.21)
  BOTTOM w0.102: CL5.1 196.66,117.74 196.66,115.09 196.94,114.81 v2(197.6,114.81)
PCIE_PTX_DRX_P6: length 230.9
  TOP w0.102: UH1.C21 195.07,33.3 195.03,33.26 195.03,33.12 195.12,33.03 195.88,33.03 196.2,32.71 199.06,32.71 199.56,33.21 v4(200.04,33.21) 201.64,33.21 201.87,32.98 201.87,32.69 v2(202.07,32.49)
  IN1 w0.102: v2(202.07,32.49) 201.8,32.22 201.8,31.36 197.67,27.23 193.81,27.23 193.24,27.8 192.55,27.8 192.27,28.08 189.88,28.08 188.55,26.75 186.11,26.75 185.44,26.08 185.44,24.52 185.22,24.3 185.22,23.3 184.88,22.96 184.88,22.14 184.43,21.7 184.43,18.62 182.41,16.6 178.16,16.6 176.91,17.84 176.91,18.48 175.92,19.47 175.05,19.47 174.43,20.1 173.33,20.1 172.09,21.33 172.09,21.83 170.82,23.11 170.3,23.11 170.11,22.91 170.11,22.03 169.37,21.29 167.73,21.29 167.04,21.97 167.04,22.21 165.85,23.4 161.82,23.4 161.53,23.1 159.79,23.1 159.43,23.47 158.68,23.47 157.75,24.4 157.13,24.4 156.17,23.44 155.66,23.44 155.09,22.87 154.24,22.87 153.09,24.02 148.73,24.02 148.21,23.49 147.78,23.49 146.95,22.66 146.11,22.66 144.45,21 142.44,21 141.36,22.08 140.5,22.08 140.06,21.64 140.06,20.1 139.39,19.43 138.19,19.43 137.42,18.66 137.1,18.66 136.8,18.36 135.88,18.36 135.85,18.39 132.69,18.39 131.8,17.5 130.22,17.5 129.81,17.08 128.24,17.08 127.96,17.36 127.11,17.36 126.9,17.56 124.57,17.56 124.17,17.16 121.42,17.16 120.81,16.56 119.47,16.56 118.4,17.63 116.08,17.63 114.86,18.85 111.25,18.85 111.19,18.8 106.07,18.8 106.02,18.85 102.05,18.85 100.83,17.64 97,17.64 93.27,21.37 92.19,21.37 91.47,22.08 84.89,22.08 83.97,23 80.73,23 79.57,24.16 77.78,24.16 77.48,23.87 73.89,23.87 70.84,20.81 68.44,20.81 66.78,19.15 64.4,19.15 64.24,19.31 62.29,19.31 61.55,18.57 61.55,15.12 59.08,12.65 54.94,12.65 53.41,14.19 53.41,14.98 52,16.39 51.22,16.39 51.13,16.48 49.28,16.48 49.28,16.48 48.78,16.48 48.47,16.78 45.83,16.78 38.14,9.1 34.76,9.1 32.67,7 29.92,7 28.58,8.35 24.03,8.35 23.8,8.12 23.8,7.78 v2(24.06,7.52)
  BOTTOM w0.102: CR203.1 23.8,8.27 23.8,7.78 v2(24.06,7.52)
