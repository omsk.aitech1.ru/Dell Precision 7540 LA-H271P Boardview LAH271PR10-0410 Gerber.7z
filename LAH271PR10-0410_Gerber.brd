# Allegro board LAH271PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D57: length 75
  TOP w0.076: v2(224.43,84.59) 224.4,84.61 224.4,85.55 225.05,86.19 225.05,86.46 225.58,87 225.58,87.21 225.75,87.37 UC1.M1
  TOP w0.152: JDIMM2.232 215.68,38.37 214.33,39.72 v2(214.23,39.72)
  IN4 w0.076: 222.58,84.21 223.33,84.21 223.78,84.66 224.35,84.66 v2(224.43,84.59)
  IN4 w0.14: v2(214.23,39.72) 213.84,40.11 213.84,40.53 214.02,40.71 214.02,42.26 208.3,47.99 208.3,50.22 207.84,50.68 207.62,50.68 207.43,50.49 207.43,50.31 207.66,50.09 207.66,49.87 207.48,49.7 207.29,49.7 206.79,50.2 206.79,51.73 204.88,53.64 204.88,63.52 205.63,64.28 205.63,77.11 212.74,84.21 222.58,84.21
  BOTTOM w0.152: JDIMM1.233 215.39,37.74 215.39,38.72 214.74,39.36 214.74,39.54 214.56,39.72 v2(214.23,39.72)
DDR_A_D58: length 81.5
  TOP w0.076: UC1.L4 224.79,89.54 v2(224.57,89.32)
  TOP w0.152: v2(208.81,39.71) 209.04,39.94 209.71,39.94 211.18,38.48 JDIMM2.250
  IN4 w0.14: v2(224.57,89.32) 224.27,89.32 223.11,88.16 221.66,88.16 221.12,88.7 220.33,88.7 220.03,88.4 219.21,88.4 218.38,87.57 211.01,87.57 201.51,78.07 201.51,73.27 202.45,72.33 202.45,71.74 202.31,71.6 201.79,71.6 201.64,71.45 201.64,71.19 201.78,71.05 202.3,71.05 202.44,70.92 202.44,70.67 202.28,70.51 201.78,70.51 201.64,70.37 201.64,70.14 201.79,69.99 202.44,69.99 202.64,69.79 202.64,67.71 201.82,66.89 201.82,52.38 203.23,50.97 203.23,48.74 208.93,43.04 208.93,41.62 209.27,41.28 209.27,40.18 v2(208.81,39.71)
  BOTTOM w0.152: v2(208.81,39.71) 210.1,39.71 211.43,38.38 JDIMM1.249
DDR_A_D59: length 79.9
  TOP w0.076: v2(224.57,88) 224.81,88.24 UC1.L2
  TOP w0.152: v2(209.74,41.38) 210.18,41.82 210.18,42.6 212.43,44.84 JDIMM2.245
  IN4 w0.14: v2(224.57,88) 224.56,88.01 223.84,88.01 223.48,87.64 218.89,87.64 218.32,87.08 211.1,87.08 201.91,77.89 201.91,74.69 202.05,74.55 202.34,74.55 202.48,74.41 202.48,74.15 202.33,74.01 202.05,74.01 201.91,73.87 201.91,73.58 203.01,72.48 203.01,65.33 202.19,64.52 202.19,52.53 203.6,51.13 203.6,48.9 209.31,43.19 209.31,41.82 v2(209.74,41.38)
  BOTTOM w0.152: JDIMM1.246 212.18,44.74 210.35,42.92 210.35,41.77 209.96,41.38 v2(209.74,41.38)
DDR_A_D60: length 83.4
  TOP w0.076: v2(226.19,86.36) 226.19,86.92 226.36,87.1 226.36,88.35 226.3,88.4 226.3,89.63 UC1.M5
  TOP w0.152: v2(212.83,41.81) 213,41.81 213.26,42.07 213.26,43.53 214.43,44.7 JDIMM2.237
  IN4 w0.076: 222.24,85.28 223.26,85.28 224.34,86.36 v2(226.19,86.36)
  IN4 w0.14: v2(212.83,41.81) 212.83,41.88 205.17,49.53 205.17,51.78 203.77,53.18 203.77,63.98 204.53,64.73 204.53,77.66 205.3,78.43 205.3,78.63 205.21,78.71 205.21,78.91 205.4,79.1 205.6,79.1 205.69,79.01 205.88,79.01 206.07,79.2 206.07,79.4 205.99,79.49 205.99,79.68 206.18,79.87 206.37,79.87 206.46,79.78 206.66,79.78 206.85,79.97 206.85,80.17 206.76,80.26 206.76,80.46 206.95,80.64 207.15,80.64 207.23,80.56 207.43,80.56 207.62,80.75 207.62,80.94 207.53,81.03 207.53,81.23 207.72,81.42 207.92,81.42 208.01,81.33 208.2,81.33 208.39,81.52 208.39,81.72 208.3,81.8 208.3,82 208.49,82.19 208.69,82.19 208.78,82.1 208.98,82.1 209.16,82.29 209.16,82.49 209.08,82.58 209.08,82.77 209.27,82.96 209.46,82.96 209.55,82.87 209.75,82.87 209.94,83.06 209.94,83.26 209.85,83.35 209.85,83.55 210.04,83.73 210.24,83.73 210.32,83.65 210.52,83.65 210.71,83.84 210.71,84.03 210.62,84.12 210.62,84.32 210.81,84.51 211.01,84.51 211.1,84.42 211.29,84.42 211.48,84.61 211.48,84.81 211.39,84.89 211.39,85.09 211.58,85.28 211.78,85.28 211.87,85.19 212.07,85.19 212.27,85.39 220.2,85.39 220.32,85.28 222.24,85.28
  BOTTOM w0.152: JDIMM1.236 214.68,45 212.83,43.15 v2(212.83,41.81)
DDR_A_D61: length 76.7
  TOP w0.076: v2(224.86,85.01) 224.86,85.63 225.34,86.1 225.34,86.44 225.79,86.89 225.79,87.13 226.03,87.37 226.03,87.96 UC1.M2
  TOP w0.152: JDIMM2.236 214.68,38.37 214.1,38.95 213.97,38.95 213.48,39.44 v2(212.88,39.44)
  IN4 w0.076: 222.55,84.58 223.37,84.58 223.8,85.01 v2(224.86,85.01)
  IN4 w0.14: v2(212.88,39.44) 213.46,40.03 213.46,40.68 213.65,40.86 213.65,42.12 207.49,48.28 207.49,48.48 207.88,48.87 207.88,49.07 207.7,49.24 207.48,49.24 207.1,48.86 206.9,48.86 206.77,49 206.77,49.19 206.91,49.34 206.91,49.54 206.72,49.73 206.53,49.73 206.38,49.58 206.18,49.58 205.91,49.85 205.91,52.09 204.51,53.49 204.51,63.67 205.27,64.43 205.27,77.3 212.54,84.58 222.55,84.58
  BOTTOM w0.152: v2(212.88,39.44) 213.74,39.44 214.43,38.76 JDIMM1.237
DDR_A_D62: length 83.6
  TOP w0.076: v2(224.56,89.92) 224.84,90.19 UC1.L5
  TOP w0.152: v2(208.8,40.94) 209.64,40.94 210.13,40.46 210.13,40.01 211.33,38.81 211.74,38.81 212.18,38.37 JDIMM2.246
  IN4 w0.076: v2(224.56,89.92) 222.91,89.92 222.65,89.65
  IN4 w0.14: v2(208.8,40.94) 208.54,41.21 208.54,42.91 202.86,48.59 202.86,50.82 201.43,52.25 201.43,67.14 202.25,67.95 202.25,68.22 202.07,68.4 201.09,68.4 200.93,68.56 200.93,68.81 201.07,68.95 202.1,68.95 202.25,69.1 202.25,69.35 202.11,69.49 201.26,69.49 201.08,69.66 201.08,78.3 210.87,88.09 218.08,88.09 219.34,89.35 222.34,89.35 222.65,89.65
  BOTTOM w0.152: JDIMM1.245 212.43,38.37 209.86,40.94 v2(208.8,40.94)
DDR_A_D63: length 78.4
  TOP w0.076: UC1.L1 224.93,87.59 224.63,87.29 v2(224.6,87.29)
  TOP w0.152: v2(209.76,42.67) 209.76,43.17 211.43,44.84 JDIMM2.249
  IN4 w0.14: v2(209.76,42.67) 209.76,43.25 203.97,49.05 203.97,51.28 202.56,52.68 202.56,64.37 203.38,65.18 203.38,77.51 203.24,77.65 203,77.65 202.83,77.48 202.83,75.51 202.69,75.37 202.4,75.37 202.29,75.49 202.29,77.67 211.2,86.59 218.46,86.59 219.16,87.29 223.87,87.29 223.96,87.38 224.51,87.38 v2(224.6,87.29)
  BOTTOM w0.152: v2(209.76,42.67) 209.58,42.85 209.58,43.16 211.18,44.76 JDIMM1.250
DDR_A_DQS0: length 75.7
  TOP w0.076: UC1.BP5 258.15,90.22 258.54,90.22 258.74,90.22 258.87,90.09 260.06,90.09 260.3,89.85 260.43,89.85 260.7,89.57 260.7,89.45 260.86,89.3 v2(260.86,88.77)
  TOP w0.152: JDIMM2.13 272.43,44.29 273.02,43.69 273.02,41.28 273.32,40.99 273.56,40.99 v2(273.68,40.87)
  IN4 w0.076: v2(260.86,88.77) 260.75,88.87 260.75,89.03 260.88,89.15 261.01,89.15 261.66,88.51 261.66,88.19 262.3,87.55 262.89,87.55 263.16,87.82 263.58,87.82 263.63,87.78 263.65,87.78
  IN4 w0.14: v2(273.68,40.87) 273.33,41.22 273.16,41.22 272.89,41.49 272.89,44.66 278.02,49.78 278.02,61.04 275.73,63.33 275.73,76.69 264.64,87.78 263.65,87.78
  BOTTOM w0.152: JDIMM1.13 272.43,38.42 272.59,38.59 272.65,38.59 272.84,38.78 272.84,39.31 273.4,39.87 274.09,39.87 274.39,40.17 274.39,40.96 274.07,41.28 273.8,41.28 273.68,41.16 v2(273.68,40.87)
DDR_A_DQS1: length 70.9
  TOP w0.076: UC1.BK3 255.43,88.6 255.43,88.09 255.11,87.78 255.11,87.43 255.24,87.17 256.93,85.67 258.85,84.31 259.12,84.2 259.4,84.2 259.51,84.31 v2(259.78,84.31)
  TOP w0.152: JDIMM2.34 267.18,38.53 267.76,39.11 268.02,39.11 269.27,40.36 269.27,41.82 269.12,41.96 268.97,41.96 268.86,41.85 v2(268.86,41.62)
  IN4 w0.076: 262.88,83.13 262.87,83.14 262.87,83.2 262.36,83.72 262.15,83.72 261.12,83.72 260.08,84.75 259.92,84.75 259.67,84.51 259.67,84.42 v2(259.78,84.31)
  IN4 w0.14: 262.88,83.13 263.09,82.92 263.09,82.92 269.52,76.49 269.52,66.36 270.21,65.67 270.21,64.32 270.47,64.06 270.47,63.54 270.21,63.29 270.21,59.87 268.4,58.06 268.4,54.09 269.2,53.29 269.2,52.81 268.79,52.41 268.79,51.47 269.23,51.04 269.23,50.49 268.75,50 268.75,46.76 267.99,46 267.99,42.15 268.28,41.87 268.61,41.87 v2(268.86,41.62)
  BOTTOM w0.152: v2(268.86,41.62) 268.72,41.75 268.16,41.75 267.73,42.19 267.73,42.75 268.14,43.16 268.14,43.69 267.95,43.89 267.53,43.89 267.18,44.24 JDIMM1.34
DDR_A_DQS2: length 69
  TOP w0.076: UC1.BF3 252.79,88.76 252.79,88.55 252.96,88.38 252.96,87.47 252.7,87.21 252.7,86.31 255.91,83.1 257.24,83.1 257.36,83.21 v2(257.78,83.21)
  TOP w0.152: v2(263.66,42.73) 263.66,42.55 263.85,42.36 264.34,42.36 264.59,42.61 264.59,43.14 263.7,44.03 263.22,44.03 262.43,44.83 262.18,44.83 261.93,45.08 JDIMM2.55
  IN4 w0.076: v2(257.78,83.21) 257.78,83.35 257.64,83.49 257.55,83.49 257.31,83.26 257.31,83.04 258.1,82.25 258.79,82.25 260.03,81.01 260.03,80.16 260.37,79.83 260.43,79.83 260.44,79.81
  IN4 w0.14: v2(263.66,42.73) 263.37,42.43 263.24,42.43 263.14,42.53 263.14,43.59 263.25,43.7 263.25,45.28 262.26,46.28 262.26,51.68 262.91,52.34 262.91,53.05 262.26,53.71 262.26,54.26 262.91,54.91 262.91,58.63 264.47,60.19 264.47,69.26 263.76,69.97 263.76,76.5 260.44,79.81
  BOTTOM w0.152: v2(263.66,42.73) 263.56,42.62 263.28,42.62 262.95,42.28 262.95,40.87 261.68,39.6 261.68,38.91 261.93,38.67 JDIMM1.55
DDR_A_DQS3: length 67
  TOP w0.076: UC1.BC3 250.27,88.77 250.45,88.6 250.45,85.29 251.72,84.02 252.05,84.02 252.13,84.09 v2(252.43,84.09)
  TOP w0.152: JDIMM2.76 256.68,39 257.07,39.39 258.16,39.39 258.3,39.53 258.3,39.74 257.81,40.24 257.81,41.4 258.19,41.78 258.43,41.78 v2(258.56,41.91)
  IN4 w0.076: v2(252.43,84.09) 252.43,84.35 252.34,84.44 252.22,84.44 252.05,84.27 252.05,83.95 256.09,79.91 256.09,79.61 256.14,79.57 256.14,79.55
  IN4 w0.14: v2(258.56,41.91) 258.24,41.58 258.03,41.58 257.81,41.8 257.81,43.96 256.31,45.47 256.31,52.89 257.13,53.71 257.13,58.75 258.57,60.19 258.57,75.67 256.14,78.1 256.14,79.55
  BOTTOM w0.152: JDIMM1.76 256.68,45.05 256.86,44.86 257.12,44.86 257.92,44.06 258.11,44.06 258.97,43.2 258.97,41.76 258.79,41.58 258.66,41.58 258.56,41.67 v2(258.56,41.91)
DDR_A_DQS4: length 73.1
  TOP w0.076: UC1.AB3 233.08,88.89 233,88.8 233,87.4 232.83,87.23 232.83,83.1 232.96,82.97 v2(233.28,82.97)
  TOP w0.152: v2(227.39,42.21) 227.53,42.06 227.53,41.85 227.67,41.71 227.85,41.71 228.04,41.9 228.04,42.73 227.72,43.04 227.72,43.81 228.21,44.31 228.79,44.31 229.15,44.67 229.15,44.87 228.93,45.09 JDIMM2.179
  IN4 w0.076: 228.87,78.24 228.88,78.26 228.95,78.26 229.33,78.64 229.33,79.53 231.78,81.98 231.78,82.24 232.61,83.07 232.87,83.07 232.98,82.97 v2(233.28,82.97)
  IN4 w0.14: 228.87,78.24 223.02,72.39 220.62,72.39 218.39,70.16 218.39,65.28 219.37,64.29 219.93,64.29 220.23,64 220.23,58.88 221.28,57.82 221.28,52.74 223.9,50.12 223.9,47.15 227.91,43.13 227.91,42.11 227.73,41.93 227.55,41.93 227.39,42.09 v2(227.39,42.21)
  BOTTOM w0.152: v2(227.39,42.21) 227.23,42.05 227.02,42.05 226.72,41.75 226.72,40.12 227.35,39.49 227.54,39.49 228.03,39.01 228.53,39.01 228.93,38.61 JDIMM1.179
DDR_A_DQS5: length 77.4
  TOP w0.076: UC1.V3 230.7,88.97 230.57,88.97 230.48,88.88 230.48,86.45 229.37,85.34 229.37,83.24 229.55,83.06 229.78,83.06 v2(229.86,83.14)
  TOP w0.152: JDIMM2.200 223.68,38.49 223.95,38.76 224.15,38.76 224.46,39.07 224.46,39.4 224.21,39.65 223.97,39.65 223.59,39.27 223.19,39.27 222.79,39.67 222.79,40.07 223.35,40.62 223.35,40.86 223.23,40.98 222.93,40.98 222.79,40.84 222.79,40.7 v2(222.68,40.59)
  IN4 w0.076: v2(229.86,83.14) 229.57,83.14 229.48,83.23 228.91,83.23 224.58,78.9 223.82,78.9 223.78,78.95 223.76,78.95
  IN4 w0.14: 223.76,78.95 220.52,78.95 219.21,77.64 217.74,77.64 213.84,73.73 213.84,57.84 214.27,57.41 214.27,53.71 217.87,50.1 217.87,47.32 221.88,43.31 221.88,41.03 222.19,40.73 222.54,40.73 v2(222.68,40.59)
  BOTTOM w0.152: JDIMM1.200 223.68,45.21 221.77,43.3 221.77,41.27 222.28,40.75 222.52,40.75 v2(222.68,40.59)
DDR_A_DQS6: length 80.9
  TOP w0.076: v2(226.33,83.35) 226.16,83.35 225.89,83.61 225.89,85.1 227.97,87.18 227.97,88.68 228.17,88.89 UC1.R3
  TOP w0.152: JDIMM2.221 218.43,45.15 218.63,44.94 218.63,44.66 217.45,43.49 217.45,41.12 217.31,40.97 217,40.97 216.85,41.11 216.85,41.31 v2(216.9,41.36)
  IN4 w0.076: 223.27,82.29 223.29,82.29 223.34,82.25 224.26,82.25 225.35,83.35 v2(226.33,83.35)
  IN4 w0.14: v2(216.9,41.36) 216.9,41.21 217.05,41.05 217.28,41.05 217.38,41.15 217.38,42.22 212.4,47.2 212.4,49.41 208.97,52.85 208.97,55.74 207.21,57.49 207.21,58.61 207.52,58.92 207.52,59.75 207.33,59.94 207.33,60.48 207.52,60.66 207.52,61.37 207.21,61.68 207.21,62.56 207.96,63.31 207.96,70.57 208.54,71.14 208.54,75.58 214.75,81.8 217.27,81.8 217.76,82.29 223.27,82.29
  BOTTOM w0.152: JDIMM1.221 218.43,39.08 218.3,39.21 216.44,39.21 215.97,39.68 215.97,40.72 216.44,41.2 216.74,41.2 v2(216.9,41.36)
DDR_A_DQS7: length 81.8
  TOP w0.076: v2(223.08,85.78) 223.14,85.84 224.07,85.84 225.29,87.06 225.29,87.24 225.45,87.4 225.45,88.6 UC1.M3
  TOP w0.152: JDIMM2.242 213.18,38.38 212.81,38.74 212.31,38.74 211.45,39.6 211.36,39.6 210.64,40.32 210.64,41.37 211,41.73 211.39,41.73 v2(211.47,41.81)
  IN4 w0.076: v2(223.08,85.78) 223.42,85.78 223.53,85.9 223.53,85.98 223.05,86.46 222.21,86.46 221.66,85.91 221.09,85.91 221.05,85.86 221.04,85.86 221.03,85.87
  IN4 w0.14: v2(211.47,41.81) 211.47,41.56 211.34,41.44 211,41.44 210.65,41.79 210.65,43.4 204.7,49.35 204.7,51.58 203.29,52.99 203.29,64.12 204.08,64.92 204.08,78.42 211.54,85.87 221.03,85.87
  BOTTOM w0.152: JDIMM1.242 213.18,45.25 213.4,45.02 213.4,44.72 212.15,43.48 212.15,41.59 211.99,41.43 211.48,41.43 211.38,41.52 211.38,41.72 v2(211.47,41.81)
DDR_A_DQS8: length 71.3
  TOP w0.076: UC1.AY3 247.93,88.6 247.93,85.49 248.7,84.73 249.34,84.73 249.38,84.69 v2(249.38,84.51)
  TOP w0.132: v2(252.83,41.07) 252.65,41.26 252.4,41.26 252.05,41.6 252.05,43.97 251.43,44.6 JDIMM2.97
  IN2 w0.076: v2(249.38,84.51) 249.53,84.66 249.95,84.66 250.23,84.38 250.23,83.94 249.63,83.34 249.63,82.79 251.14,81.28 251.14,80.25 251.09,80.2
  IN2 w0.119: v2(252.83,41.07) 252.55,41.35 252.38,41.35 252.08,41.65 252.08,44.8 253.99,46.71 257.4,46.71 258.23,47.54 258.23,50.58 259.76,52.12 259.76,53.21 259.16,53.81 259.16,60.59 259.54,60.96 259.54,65.93 259.2,66.26 259.2,71.76 251.09,79.87 251.09,80.2
  BOTTOM w0.132: JDIMM1.97 251.43,38.47 251.62,38.67 251.73,38.67 252.07,39 252.51,39 253.29,39.78 253.29,41.34 253.15,41.48 252.96,41.48 252.83,41.35 v2(252.83,41.07)
DDR_A_DQS#0: length 75.6
  TOP w0.076: UC1.BR5 258.52,89.64 258.4,89.52 258.21,89.52 258.11,89.62 258.11,89.77 258.18,89.84 258.18,89.97 258.28,90.07 258.53,90.07 258.68,90.07 258.81,89.94 259.99,89.94 260.23,89.7 260.36,89.7 260.55,89.51 260.55,89.4 v2(260.38,89.22)
  TOP w0.152: v2(273.72,41.67) 273.75,41.53 273.75,41.37 273.66,41.27 273.43,41.27 273.3,41.4 273.3,43.81 272.7,44.41 272.7,45.02 272.93,45.25 JDIMM2.11
  IN4 w0.076: 263.65,88.02 263.63,88.02 263.58,87.97 263.1,87.97 262.82,87.7 262.36,87.7 261.81,88.25 261.81,88.57 261.07,89.31 260.81,89.31 260.73,89.22 v2(260.38,89.22)
  IN4 w0.14: v2(273.72,41.67) 273.51,41.46 273.26,41.46 273.13,41.59 273.13,44.56 278.26,49.68 278.26,61.14 275.97,63.43 275.97,76.79 264.74,88.02 263.65,88.02
  BOTTOM w0.152: JDIMM1.11 272.93,38.48 273.12,38.67 273.12,39.2 273.51,39.59 274.21,39.59 274.67,40.05 274.67,41.07 274.18,41.56 273.83,41.56 v2(273.72,41.67)
DDR_A_DQS#1: length 70.9
  TOP w0.076: v2(259.33,84.76) 259.42,84.76 259.48,84.7 259.48,84.49 259.34,84.35 259.15,84.35 258.92,84.45 257.03,85.79 255.36,87.26 255.27,87.46 255.27,87.71 255.58,88.03 255.58,88.78 255.69,88.89 UC1.BL3
  TOP w0.152: JDIMM2.32 267.68,38.37 268.2,38.9 269.55,40.25 269.55,41.93 269.24,42.24 269.04,42.24 v2(268.86,42.42)
  IN4 w0.076: v2(259.33,84.76) 259.71,84.76 259.86,84.91 260.15,84.91 261.18,83.87 262.09,83.87 262.42,83.87 262.98,83.31 263.04,83.31 263.05,83.3
  IN4 w0.14: 263.05,83.3 263.26,83.09 269.76,76.59 269.76,66.46 270.45,65.77 270.45,64.42 270.71,64.16 270.71,63.44 270.45,63.19 270.45,59.77 268.64,57.96 268.64,54.19 269.44,53.39 269.44,52.71 269.04,52.31 269.04,51.57 269.47,51.14 269.47,50.39 268.99,49.9 268.99,46.66 268.23,45.9 268.23,42.25 268.38,42.11 268.55,42.11 v2(268.86,42.42)
  BOTTOM w0.152: v2(268.86,42.42) 268.95,42.33 268.95,42.16 268.83,42.03 268.28,42.03 268.01,42.3 268.01,42.64 268.42,43.05 268.42,43.81 268.06,44.16 267.65,44.16 267.45,44.36 267.45,44.81 267.68,45.03 JDIMM1.32
DDR_A_DQS#2: length 68.9
  TOP w0.076: v2(257.25,83.71) 257.25,83.32 257.18,83.25 255.98,83.25 252.86,86.37 252.86,87.14 253.12,87.4 253.12,88.44 252.95,88.61 252.95,88.83 253.01,88.89 UC1.BG3
  TOP w0.152: JDIMM2.53 262.43,45.23 263.34,44.31 263.81,44.31 264.87,43.25 264.87,42.49 264.46,42.08 263.74,42.08 v2(263.66,42.01)
  IN4 w0.076: v2(257.25,83.71) 257.25,83.41 257.16,83.32 257.16,82.97 258.04,82.09 258.73,82.09 259.88,80.94 259.88,80.1 260.26,79.72 260.26,79.66 260.27,79.64
  IN4 w0.14: 260.27,79.64 263.52,76.4 263.52,69.87 264.23,69.16 264.23,60.29 262.67,58.73 262.67,55.01 262.01,54.36 262.01,53.61 262.67,52.95 262.67,52.44 262.01,51.78 262.01,46.18 263.01,45.18 263.01,43.8 262.9,43.69 262.9,42.43 263.14,42.19 263.48,42.19 v2(263.66,42.01)
  BOTTOM w0.152: JDIMM1.53 262.43,38.8 262.33,38.9 262.09,38.9 261.96,39.03 261.96,39.48 263.23,40.75 263.23,42.16 263.4,42.34 263.56,42.34 263.66,42.23 v2(263.66,42.01)
DDR_A_DQS#3: length 67
  TOP w0.076: v2(251.9,84.63) 252.12,84.41 252.12,84.3 251.99,84.17 251.79,84.17 250.6,85.35 250.6,88.81 250.68,88.89 UC1.BD3
  TOP w0.152: JDIMM2.74 257.18,38.37 256.95,38.59 256.95,38.88 257.18,39.11 258.27,39.11 258.58,39.42 258.58,39.86 258.08,40.35 258.08,41.28 258.31,41.5 258.54,41.5 258.63,41.41 258.63,41.25 v2(258.56,41.1)
  IN4 w0.076: 255.9,79.55 255.9,79.57 255.94,79.61 255.94,79.84 254.47,81.31 251.9,83.88 v2(251.9,84.63)
  IN4 w0.14: 255.9,79.55 255.9,78 258.33,75.57 258.33,60.29 256.89,58.85 256.89,53.81 256.06,52.99 256.06,45.37 257.57,43.86 257.57,41.7 257.93,41.34 258.32,41.34 v2(258.56,41.1)
  BOTTOM w0.152: v2(258.56,41.1) 258.76,41.3 258.9,41.3 259.25,41.64 259.25,43.32 258.22,44.34 258.03,44.34 257.18,45.2 JDIMM1.74
DDR_A_DQS#4: length 73.1
  TOP w0.076: UC1.AA3 232.85,88.6 232.85,87.46 232.67,87.29 232.67,83.04 232.83,82.88 v2(232.83,82.52)
  TOP w0.152: v2(227.41,41.42) 227.43,41.43 227.96,41.43 228.32,41.79 228.32,42.84 228,43.16 228,43.7 228.33,44.03 228.91,44.03 229.43,44.55 JDIMM2.177
  IN4 w0.076: v2(232.83,82.52) 232.9,82.59 232.9,82.83 232.81,82.92 232.68,82.92 231.94,82.18 231.94,81.92 229.48,79.46 229.48,78.57 229.04,78.13 229.04,78.07
  IN4 w0.14: v2(227.41,41.42) 227.68,41.69 227.83,41.69 228.16,42.01 228.16,43.23 224.14,47.25 224.14,50.22 221.53,52.84 221.53,57.92 220.47,58.98 220.47,64.1 220.03,64.54 219.47,64.54 218.63,65.38 218.63,70.06 220.72,72.15 223.12,72.15 229.04,78.07
  BOTTOM w0.152: v2(227.41,41.42) 227.5,41.5 227.5,41.66 227.38,41.77 227.14,41.77 227,41.64 227,40.24 227.47,39.77 227.66,39.77 228.15,39.29 228.65,39.29 229.43,38.51 JDIMM1.177
DDR_A_DQS#5: length 77.3
  TOP w0.076: UC1.U3 230.33,88.6 230.33,86.52 229.22,85.41 229.22,83.18 229.37,83.03 229.37,82.59 v2(229.26,82.49)
  TOP w0.152: v2(222.68,41.34) 222.76,41.26 223.34,41.26 223.63,40.98 223.63,40.51 223.1,39.97 223.1,39.76 223.3,39.55 223.48,39.55 223.86,39.93 224.33,39.93 224.74,39.52 224.74,38.95 224.18,38.38 JDIMM2.198
  IN4 w0.076: v2(229.26,82.49) 229.53,82.49 229.64,82.6 229.64,82.85 229.41,83.08 228.97,83.08 224.64,78.75 223.82,78.75 223.78,78.71 223.76,78.71
  IN4 w0.14: v2(222.68,41.34) 222.68,41.11 222.54,40.97 222.29,40.97 222.12,41.13 222.12,43.41 218.11,47.42 218.11,50.2 214.51,53.81 214.51,57.51 214.08,57.94 214.08,73.63 217.84,77.4 219.31,77.4 220.62,78.71 223.76,78.71
  BOTTOM w0.152: v2(222.68,41.34) 222.69,41.33 222.69,41.13 222.6,41.03 222.4,41.03 222.05,41.39 222.05,43.19 223.71,44.86 223.95,44.86 224.18,45.08 JDIMM1.198
DDR_A_DQS#6: length 80.9
  TOP w0.076: v2(225.88,82.9) 225.97,82.98 225.97,83.32 225.74,83.55 225.74,85.16 227.82,87.24 227.82,88.6 UC1.P3
  TOP w0.152: JDIMM2.219 218.93,44.82 218.91,44.8 218.91,44.55 217.73,43.37 217.73,41 217.42,40.68 217.01,40.68 v2(216.9,40.58)
  IN4 w0.076: v2(225.88,82.9) 225.88,83.11 225.8,83.2 225.42,83.2 224.32,82.1 223.34,82.1 223.29,82.05 223.27,82.05
  IN4 w0.14: 223.27,82.05 217.86,82.05 217.37,81.56 214.85,81.56 208.78,75.48 208.78,71.04 208.2,70.47 208.2,63.21 207.45,62.46 207.45,61.78 207.76,61.47 207.76,60.56 207.57,60.38 207.57,60.04 207.76,59.85 207.76,58.82 207.45,58.51 207.45,57.59 209.21,55.84 209.21,52.95 212.65,49.51 212.65,47.3 217.62,42.32 217.62,41.05 217.38,40.81 217.13,40.81 v2(216.9,40.58)
  BOTTOM w0.152: JDIMM1.219 218.93,38.67 218.7,38.9 218.7,39.2 218.42,39.49 216.55,39.49 216.25,39.8 216.25,40.6 216.55,40.91 216.9,40.91 217.03,40.79 217.03,40.65 216.96,40.58 v2(216.9,40.58)
DDR_A_DQS#7: length 81.8
  TOP w0.076: UC1.L3 225.13,89.01 225.29,89.01 225.4,88.9 225.4,88.79 225.3,88.7 225.3,87.47 225.14,87.3 225.14,87.12 224.01,85.99 223.68,85.99 223.59,86.08 223.59,86.29 v2(223.66,86.36)
  TOP w0.152: JDIMM2.240 213.68,38.47 213.38,38.77 213.22,38.77 212.97,39.02 212.43,39.02 211.57,39.88 211.47,39.88 210.92,40.44 210.92,41.25 211.11,41.45 211.27,41.45 211.48,41.24 v2(211.48,41.03)
  IN4 w0.076: v2(223.66,86.36) 223.37,86.36 223.11,86.61 222.15,86.61 221.59,86.06 221.09,86.06 221.04,86.11
  IN4 w0.14: 221.04,86.11 211.44,86.11 203.84,78.52 203.84,65.02 203.05,64.22 203.05,52.89 204.46,51.48 204.46,49.25 210.4,43.3 210.4,41.69 210.9,41.19 211.32,41.19 v2(211.48,41.03)
  BOTTOM w0.152: v2(211.48,41.03) 211.59,41.15 212.11,41.15 212.43,41.47 212.43,43.36 213.68,44.6 JDIMM1.240
DDR_A_DQS#8: length 71.4
  TOP w0.076: v2(249.39,85.1) 249.16,84.88 248.76,84.88 248.09,85.56 248.09,88.66 248.02,88.73 248.02,88.87 248.15,89 248.26,89 UC1.BA3
  TOP w0.132: JDIMM2.95 251.93,45.21 251.65,44.94 251.65,44.69 252.27,44.07 252.27,41.7 252.49,41.48 252.68,41.48 252.83,41.63 v2(252.83,41.93)
  IN2 w0.076: v2(249.39,85.1) 249.68,84.81 250.01,84.81 250.38,84.45 250.38,83.87 249.79,83.28 249.79,82.85 251.29,81.35 251.29,80.22 251.31,80.2
  IN2 w0.119: v2(252.83,41.93) 252.83,41.74 252.66,41.57 252.47,41.57 252.3,41.74 252.3,44.71 254.09,46.49 257.49,46.49 258.45,47.45 258.45,50.49 259.98,52.03 259.98,53.3 259.38,53.9 259.38,60.49 259.76,60.87 259.76,66.02 259.42,66.36 259.42,71.85 251.31,79.97 251.31,80.2
  BOTTOM w0.132: JDIMM1.95 251.93,38.54 252.17,38.78 252.6,38.78 253.51,39.69 253.51,41.43 253.24,41.7 252.96,41.7 252.83,41.83 v2(252.83,41.93)
DDR_A_DRAMRST#: length 37.1
  TOP w0.109: v2(249.14,35.91) 248.68,36.37 JDIMM2.108
  IN1 w0.102: v2(249.14,35.91) 248.1,36.94 248.1,46.87 246.95,48.02 v2(246.95,48.07)
  IN2 w0.081: v2(249.67,62.5) 246.49,59.32 246.49,48.49 246.9,48.07 v2(246.95,48.07)
  BOTTOM w0.102: v2(246.95,48.07) 247.67,48.07 248.68,47.06 JDIMM1.108 ; v2(249.67,62.5) CD15.1 250.05,63.3 250.15,63.21 CD48.1 RD76.2
DDR_A_MA0: length 69.4
  TOP w0.076: v2(239.09,83.21) 239.04,83.21 238.59,83.65 238.59,84.43 238.03,84.99 238.03,88.6 UC1.AH3
  TOP w0.211: v2(237.24,42.2) 237.24,42.2 236.78,41.74 236.78,40.5 237.15,40.14 237.65,40.14 239.16,38.63 239.55,38.63 239.68,38.5 JDIMM2.144
  IN4 w0.076: 237.76,78.03 237.76,78.57 238.74,79.55 238.74,81.81 238.74,81.81 238.74,82.12 238.74,82.13 238.74,82.86 v2(239.09,83.21)
  IN4 w0.188: 237.76,78.03 237.76,75.11 234.3,71.65 234.3,70.5 233.37,69.57 233.37,66.29 232.59,65.51 232.59,60.1 232.41,59.92 232.17,59.92 231.99,60.1 231.99,61.17 231.82,61.35 231.57,61.35 231.4,61.17 231.4,59.76 233.26,57.89 233.26,52.94 235.97,50.23 235.97,47.46 237.51,45.92 237.51,44.31 237.7,44.12 237.7,42.34 237.56,42.2 v2(237.24,42.2)
  BOTTOM w0.211: v2(237.24,42.2) 237.25,42.2 237.68,42.64 237.68,45.25 237.87,45.44 238.37,45.44 238.9,44.91 239.48,44.91 239.68,45.1 JDIMM1.144
DDR_A_MA1: length 71.5
  TOP w0.076: UC1.AP4 243.6,89.54 243.9,89.24 243.9,88.58 243.96,88.51 243.96,86.54 243.84,86.42 243.84,85.58 v2(244.18,85.24)
  TOP w0.211: v2(243,43.78) 242.86,43.93 242.54,43.93 242.26,43.65 242.26,42.36 242.08,42.19 241.81,42.19 241.65,42.35 241.65,43.98 242.07,44.41 242.07,44.78 242.43,45.13 JDIMM2.133
  IN4 w0.076: 243.3,78.62 243.31,78.63 243.31,84.37 v2(244.18,85.24)
  IN4 w0.188: v2(243,43.78) 243.26,44.04 243.26,50.25 241.56,51.94 241.56,52.18 241.73,52.35 241.73,52.59 241.57,52.76 241.33,52.76 241.16,52.58 240.92,52.58 240.26,53.24 240.26,58.61 239.93,58.94 239.93,61.28 239.58,61.63 239.58,65.36 240.77,66.54 240.77,69.31 243.46,72.01 243.46,72.25 243.3,72.41 243.07,72.41 240.85,70.2 240.62,70.2 240.45,70.37 240.45,70.6 242.78,72.93 242.78,77.61 242.99,77.82 242.99,78.31 243.3,78.62
  BOTTOM w0.211: v2(243,43.78) 241.83,42.61 241.83,39.95 242.29,39.49 242.29,38.85 242.43,38.71 JDIMM1.133
DDR_A_MA2: length 70.6
  TOP w0.076: v2(242.12,89.21) 242.44,89.54 UC1.AN4
  TOP w0.203: JDIMM2.132 242.68,38.6
  TOP w0.211: v2(241.69,39.48) 241.23,39.48 240.29,40.42 240.29,40.89 240.49,41.08 240.84,41.08 241.31,40.61 241.31,40.46 242.16,39.61 242.16,39.11 242.68,38.6
  IN4 w0.076: 242.85,78.82 242.91,78.88 242.91,88.42 v2(242.12,89.21)
  IN4 w0.188: v2(241.69,39.48) 241.69,39.33 241.96,39.06 241.96,38.75 242.27,38.44 242.54,38.44 242.79,38.69 242.79,38.92 242.58,39.12 242.58,46.64 242.31,46.91 242.31,49.55 242.01,49.85 242.01,50.76 239.68,53.08 239.68,58.44 239.4,58.72 239.4,61 239.01,61.4 239.01,65.65 239.8,66.44 239.8,70.7 242.25,73.15 242.25,77.72 242.55,78.02 242.55,78.52 242.85,78.82
  BOTTOM w0.211: v2(241.69,39.48) 241.42,39.74 241.42,43.63 242.68,44.89 JDIMM1.132
DDR_A_MA3: length 68.6
  TOP w0.076: UC1.AP5 243.24,90.19 242.96,89.9 242.96,89.39 243.13,89.22 243.48,89.22 243.64,89.06 243.64,88.35 243.79,88.2 243.79,87.22 243.67,87.1 243.67,85.18 v2(244.2,84.65)
  TOP w0.211: JDIMM2.131 242.93,44.5 243.47,43.95 243.47,43.06 244.07,42.47 244.07,42.26 243.89,42.09 243.49,42.09 243.08,42.5 v2(243.03,42.5)
  IN4 w0.076: 243.57,78.54 243.57,84.02 v2(244.2,84.65)
  IN4 w0.188: 243.57,78.54 243.57,78.32 243.42,78.17 243.42,77.58 243.31,77.46 243.31,76.21 243.48,76.04 243.83,76.04 244,75.87 244,75.64 243.83,75.47 243.48,75.47 243.31,75.3 243.31,75.07 243.48,74.9 243.82,74.9 243.99,74.73 243.99,74.5 243.82,74.33 243.48,74.33 243.31,74.17 243.31,73.93 243.48,73.76 243.85,73.76 244.01,73.6 244.01,73.41 243.7,73.09 243.7,72.78 244.01,72.47 244.01,71.81 241.3,69.09 241.3,68.61 241.46,68.44 241.88,68.44 242.04,68.27 242.04,68.04 241.88,67.87 241.46,67.87 241.3,67.71 241.3,66.32 240.63,65.66 240.63,65.29 240.95,64.97 240.95,64.62 240.35,64.02 240.35,63.64 240.63,63.35 240.63,62.77 240.31,62.45 240.31,62.32 240.63,61.99 240.63,58.99 241.34,58.28 241.34,55.31 241.43,55.22 241.43,53.51 242.58,52.36 242.58,52.13 242.44,51.99 242.44,51.75 242.6,51.59 242.84,51.59 243.01,51.76 243.22,51.76 243.61,51.36 243.61,42.41 243.48,42.28 243.25,42.28 v2(243.03,42.5)
  BOTTOM w0.211: v2(243.03,42.5) 242.55,42.02 242.55,41.61 242.24,41.29 242.24,40.11 242.66,39.68 242.66,39.07 242.93,38.81 JDIMM1.131
DDR_A_MA4: length 70.3
  TOP w0.076: v2(244.22,83.45) 244.01,83.45 243.79,83.67 243.79,84.76 243.46,85.09 243.46,87.2 243.63,87.37 243.63,87.96 UC1.AP2
  TOP w0.211: JDIMM2.128 243.68,38.59 243.46,38.81 242.89,38.81 242.47,39.23 242.47,39.73 241.87,40.32 241.87,41.05 242.06,41.24 242.36,41.24 242.52,41.08 242.52,40.51 v2(243.04,39.99)
  IN4 w0.076: v2(244.22,83.45) 244.62,83.05 244.62,82.1 244.37,81.85 244.37,77.07 244.52,76.92
  IN4 w0.188: 244.52,76.92 245.07,76.36 245.07,70.49 243.38,68.79 243.38,67.17 243,66.79 243,66.42 243.51,65.91 243.51,64.64 241.78,62.9 241.78,59.4 243.12,58.06 243.12,53.54 244.41,52.25 244.41,41.79 244.06,41.44 244.06,38.1 243.92,37.96 243.68,37.96 243.51,38.12 243.51,39.81 243.33,39.99 v2(243.04,39.99)
  BOTTOM w0.211: JDIMM1.128 243.68,43.08 243.47,42.88 243.47,41.74 242.61,40.87 242.61,40.42 v2(243.04,39.99)
DDR_A_MA5: length 69.7
  TOP w0.076: v2(244.23,82.86) 243.88,82.86 243.55,83.19 243.55,84.65 243.26,84.94 243.26,87.5 UC1.AP1
  TOP w0.211: JDIMM2.126 244.15,37.73 244.15,38.89 243.48,39.56 243.48,40.45 243.78,40.76 243.78,41.31 243.64,41.45 243.46,41.45 243.33,41.33 243,41.33 242.87,41.19 242.87,40.86 v2(243.03,40.7)
  IN4 w0.076: 243.95,76.66 243.85,76.77 243.85,82.48 v2(244.23,82.86)
  IN4 w0.188: v2(243.03,40.7) 243.03,41.25 243.28,41.5 243.56,41.5 244,41.94 244,51.68 241.99,53.69 241.99,55.23 242.41,55.65 242.41,55.96 241.88,56.48 241.88,58.49 241.25,59.12 241.25,63.19 241.85,63.79 241.85,64.02 241.48,64.39 241.48,64.59 241.65,64.75 242.05,64.75 242.33,64.47 242.6,64.47 242.98,64.86 242.98,65.19 242.85,65.32 241.65,65.32 241.48,65.49 241.48,65.75 241.67,65.94 242.32,65.94 242.47,66.09 242.47,66.51 242.35,66.63 241.99,66.63 241.83,66.79 241.83,67.07 242.02,67.26 242.63,67.26 242.84,67.47 242.84,68.34 242.23,68.94 242.23,69.27 242.48,69.52 242.72,69.52 242.92,69.32 243.16,69.32 243.32,69.49 243.32,69.72 243.12,69.93 243.12,70.16 243.29,70.33 243.52,70.33 243.73,70.13 243.96,70.13 244.13,70.29 244.13,70.53 243.93,70.73 243.93,70.97 244.54,71.59 244.54,76.07 243.95,76.66
  BOTTOM w0.211: v2(243.03,40.7) 243.77,41.44 243.77,42.34 244.06,42.63 244.06,44.68 244.18,44.79 JDIMM1.126
DDR_A_MA6: length 70.9
  TOP w0.076: UC1.AP3 243.07,88.6 243.07,84.62 243.16,84.53 243.16,82.81 244.14,81.83 245.19,81.83 v2(245.5,82.13)
  TOP w0.211: JDIMM2.127 243.93,44.98 243.79,44.84 243.56,44.84 243.39,44.67 243.39,44.45 243.78,44.06 243.78,43.19 244.06,42.92 244.27,42.92 244.41,43.05 244.41,43.55 244.55,43.69 244.55,43.96 244.42,44.09 244.42,44.29 244.59,44.46 245.01,44.46 245.28,44.19 245.28,43.95 v2(245.14,43.81)
  IN4 w0.076: v2(245.5,82.13) 244.62,81.25 244.62,77.56 244.7,77.48
  IN4 w0.188: 244.7,77.48 245.61,76.58 245.61,70.27 243.96,68.62 243.96,68.39 244.13,68.22 244.36,68.22 245.2,69.06 245.44,69.06 245.6,68.89 245.6,68.66 244.05,67.1 244.05,64.42 242.31,62.68 242.31,61.23 243.9,59.64 243.9,59.4 243.74,59.24 243.5,59.24 242.72,60.02 242.49,60.02 242.32,59.85 242.32,59.61 243.67,58.27 243.67,53.8 244.87,52.59 244.87,44.07 v2(245.14,43.81)
  BOTTOM w0.211: JDIMM1.127 243.93,40.56 244.11,40.74 244.11,42.15 244.4,42.45 244.4,43.47 244.74,43.81 v2(245.14,43.81)
DDR_A_MA7: length 70.3
  TOP w0.076: UC1.AN1 242.61,82.34 v1(243.85,81.09) 244.72,80.22 v2(245.4,80.22)
  TOP w0.211: v2(244.97,41.07) 244.97,41.37 244.77,41.57 244.43,41.57 244.22,41.35 244.22,39.55 245.18,38.6 JDIMM2.122
  IN4 w0.188: v2(245.4,80.22) 245.5,80.22 245.97,79.74 245.97,78.56 247.2,77.33 247.2,74.97 248.35,73.82 248.35,69 247.53,68.18 247.53,67.22 247.18,66.87 246.08,66.87 245.65,66.44 245.65,62.94 245.54,62.82 245.54,58.7 246.03,58.21 246.03,54.1 246.48,53.64 246.48,37.73 246.26,37.51 246,37.51 245.76,37.75 245.76,40.78 245.48,41.07 v2(244.97,41.07)
  BOTTOM w0.211: JDIMM1.122 245.18,44.49 245.61,44.06 245.61,42.45 244.97,41.82 v2(244.97,41.07)
DDR_A_MA8: length 69.5
  TOP w0.076: v2(245.5,80.86) 244.65,80.86 242.83,82.68 242.83,87.29 242.9,87.36 242.9,88.36 242.61,88.65 UC1.AN3
  TOP w0.211: JDIMM2.125 244.43,44.98 244.63,44.77 245.16,44.77 245.6,44.33 245.6,42.54 245.37,42.31 245.08,42.31 v2(244.97,42.42)
  IN4 w0.076: 245,77.94 245,80.36 v2(245.5,80.86)
  IN4 w0.188: 245,77.94 246.14,76.8 246.14,74.53 247.27,73.39 247.27,70.75 247.11,70.58 246.87,70.58 246.71,70.75 246.71,73.07 246.54,73.24 246.3,73.24 246.14,73.07 246.14,68.44 244.58,66.88 244.58,64.2 242.98,62.6 242.98,61.31 244.48,59.82 244.48,59.07 244.2,58.79 244.2,54.07 245.32,52.95 245.32,51.12 245.8,50.64 245.8,47.32 245.34,46.86 245.34,44.47 245.55,44.27 245.55,42.15 245.39,41.99 245.1,41.99 244.97,42.12 v2(244.97,42.42)
  BOTTOM w0.211: JDIMM1.125 244.43,40.28 244.51,40.37 244.51,41.96 v2(244.97,42.42)
DDR_A_MA9: length 71.5
  TOP w0.076: v2(244.68,89.21) 245.01,89.54 UC1.AT4
  TOP w0.211: v2(246.93,44.07) 246.67,44.07 246.51,43.92 246.51,42.09 246.35,41.93 246.1,41.93 245.91,42.12 245.91,44.48 245.43,44.97 JDIMM2.121
  IN4 w0.076: 246.54,79.88 246.37,80.04 246.37,82.41 245.03,83.76 245.03,85.56 244.23,86.36 244.23,88.76 v2(244.68,89.21)
  IN4 w0.188: v2(246.93,44.07) 247.4,44.54 247.4,45.23 247.03,45.6 247.03,46.39 247.4,46.75 247.4,49.9 247.07,50.23 247.07,53.71 246.56,54.22 246.56,58.43 246.18,58.81 246.18,66.17 246.35,66.34 246.58,66.34 246.75,66.17 246.75,62.9 246.93,62.71 247.17,62.71 247.32,62.87 247.32,66.26 248.06,67 248.06,67.96 248.88,68.78 248.88,74.04 247.73,75.19 247.73,77.55 246.54,78.75 246.54,79.88
  BOTTOM w0.211: v2(246.93,44.07) 246.22,43.36 246.22,42 245.81,41.6 245.81,39.58 245.43,39.2 JDIMM1.121
DDR_A_MA10: length 71.8
  TOP w0.076: v2(239.08,85.09) 238.61,85.56 238.61,87.94 UC1.AH2
  TOP w0.211: JDIMM2.146 237.18,38.36 237.33,38.52 237.55,38.52 238.07,38 238.38,38 238.6,38.22 238.6,38.49 237.55,39.54 237.16,39.54 236.89,39.26 236.48,39.26 v2(235.72,40.02)
  IN4 w0.076: 236.7,78.12 236.7,78.53 238.1,79.93 238.1,84.12 v2(239.08,85.09)
  IN4 w0.188: 236.7,78.12 236.7,75.55 233.24,72.09 233.24,70.94 232.31,70.01 232.31,68.83 231.53,68.05 231.53,66.43 230.34,65.24 230.34,59.31 232.2,57.44 232.2,52.5 234.4,50.3 234.4,47.53 236.45,45.48 236.45,40.55 236.56,40.43 236.56,38.43 236.39,38.25 235.95,38.25 235.72,38.48 v2(235.72,40.02)
  BOTTOM w0.211: JDIMM1.146 237.18,44.51 236.48,43.81 236.48,41.43 236.23,41.18 236.23,40.54 v2(235.72,40.02)
DDR_A_MA11: length 71
  TOP w0.076: UC1.AN2 242.32,87.95 242.32,82.05 v2(245.42,78.96)
  TOP w0.211: v2(244.98,39.83) 245.26,39.83 245.45,40.02 245.45,41.28 245.68,41.51 246,41.51 246.15,41.36 246.15,41 246.04,40.89 246.04,39.92 245.68,39.55 JDIMM2.120
  IN4 w0.188: v2(244.98,39.83) 244.98,39.69 244.86,39.56 244.62,39.56 244.46,39.72 244.46,41.21 244.8,41.55 245.71,41.55 246.02,41.87 246.02,44.49 245.81,44.71 245.81,46.52 246.14,46.85 246.14,51.04 245.84,51.34 245.84,53.47 245.5,53.82 245.5,57.99 245.01,58.48 245.01,60.04 243.92,61.12 243.92,62.79 245.11,63.98 245.11,66.66 246.67,68.22 246.67,69.88 246.83,70.05 247.07,70.05 247.24,69.88 247.24,69.19 247.39,69.03 247.63,69.03 247.81,69.21 247.81,73.61 246.67,74.75 246.67,77.02 245.42,78.27 v2(245.42,78.96)
  BOTTOM w0.211: JDIMM1.120 245.68,44.85 245.91,44.62 245.91,42.17 245.48,41.74 245.48,40.33 v2(244.98,39.83)
DDR_A_MA12: length 69.2
  TOP w0.076: UC1.AU4 246.31,89.09 246.31,87.4 246.32,87.39 246.32,86.83 246.13,86.64 v2(246.13,85.79)
  TOP w0.211: v2(246.97,42.21) 247.08,42.21 247.49,42.62 247.49,44.14 246.91,44.72 246.25,44.72 245.93,45.05 JDIMM2.119
  IN4 w0.076: v2(246.13,85.79) 245.64,85.29 245.64,84.29 246.78,83.14 246.78,81.72
  IN4 w0.188: 246.78,81.72 246.78,80.35 247.61,79.53 247.61,78.43 248.26,77.77 248.26,75.41 249.41,74.26 249.41,71.74 249.58,71.57 250.11,71.57 250.28,71.41 250.28,71.17 250.11,71 249.58,71 249.41,70.84 249.41,70.6 249.58,70.43 250.11,70.43 250.28,70.27 250.28,70.03 250.11,69.86 249.58,69.86 249.41,69.7 249.41,69.46 249.58,69.3 250.11,69.3 250.28,69.13 250.28,68.89 250.11,68.73 249.58,68.73 248.59,67.74 248.59,66.78 247.85,66.04 247.85,65.53 248.02,65.36 248.35,65.36 248.52,65.2 248.52,64.96 248.35,64.79 248.02,64.79 247.85,64.63 247.85,64.39 248.02,64.22 248.35,64.22 248.52,64.06 248.52,63.82 248.35,63.66 248.02,63.66 247.85,63.49 247.85,62.82 248.16,62.51 248.16,60.79 247.95,60.57 247.62,60.57 247.43,60.77 247.43,60.98 247.29,61.13 246.88,61.13 246.71,60.96 246.71,59.03 247.09,58.65 247.09,58.06 247.59,57.56 247.59,50.34 247.84,50.09 247.84,42.84 247.21,42.21 v2(246.97,42.21)
  BOTTOM w0.211: JDIMM1.119 245.93,38.95 246.11,39.13 246.11,41.41 246.71,42.01 246.77,42.01 v2(246.97,42.21)
DDR_A_MA13: length 73.1
  TOP w0.076: v2(236.67,83.1) 236.1,83.67 236.1,84.34 235.52,84.92 v1(235.52,85.27) 235.52,88.6 UC1.AE3
  TOP w0.211: v2(231.73,40.48) 232.5,40.48 232.71,40.27 232.71,39.92 232.54,39.75 231.92,39.75 231.68,39.51 231.68,39.22 231.88,39.02 233.06,39.02 233.29,38.8 233.98,38.8 234.18,38.6 JDIMM2.158
  IN4 w0.076: v2(236.67,83.1) 236.29,82.72 236.29,81.43 235.36,80.5 235.36,79.95 234.05,78.63 234.05,78.11
  IN4 w0.188: v2(231.73,40.48) 232,40.48 232.22,40.26 232.22,39.27 232.42,39.06 232.77,39.06 233.01,39.31 233.01,42.16 232.63,42.53 232.63,45.24 230.27,47.61 230.27,50.67 228.1,52.84 228.1,57.79 227.68,58.21 227.68,59.36 226.79,60.26 226.79,63.72 227.27,64.2 227.27,66.55 226.5,67.32 226.5,69.1 234.05,76.65 234.05,78.11
  BOTTOM w0.211: v2(231.73,40.48) 231.9,40.48 232.57,41.15 232.57,43.5 234.18,45.1 JDIMM1.158
DDR_A_MA14: length 72.3
  TOP w0.076: UC1.AG4 237.44,89.54 v2(237.14,89.84)
  TOP w0.211: v2(234.11,39.88) 234.62,40.39 234.62,42.05 235.21,42.65 235.21,44.42 235.93,45.13 JDIMM2.151
  IN4 w0.076: 235.11,78.12 235.11,78.37 237.16,80.42 237.16,84.8 237.66,85.29 237.66,87.46 236.7,88.42 236.7,89.39 v2(237.14,89.84)
  IN4 w0.188: 235.11,78.12 235.11,76.21 230.46,71.56 230.46,69.74 228.75,68.03 228.75,64.18 227.85,63.28 227.85,60.7 228.75,59.8 228.75,58.65 230.06,57.33 230.06,56.87 229.62,56.43 229.62,54 230.61,53.01 230.61,51.83 232.1,50.34 232.1,47.53 234.14,45.49 234.14,42.34 233.54,41.75 233.54,40.23 233.89,39.88 v2(234.11,39.88)
  BOTTOM w0.211: JDIMM1.151 235.93,38.6 235.21,39.32 233.62,39.32 232.86,40.08 232.86,40.49 233,40.63 233.43,40.63 233.6,40.46 233.6,40.26 233.97,39.88 v2(234.11,39.88)
DDR_A_MA15: length 72.5
  TOP w0.076: UC1.AD1 234.92,87.44 234.92,84.19 235.07,84.04 235.07,82.83 v1(235.3,82.61) 236.58,81.33 v2(236.69,81.33)
  TOP w0.211: v2(233.57,42.54) 233.18,42.15 233.18,39.61 233.67,39.12 234.22,39.12 234.68,38.66 JDIMM2.156
  IN4 w0.076: v2(236.69,81.33) 235.82,80.46 235.82,79.74 234.58,78.5 234.58,77.97
  IN4 w0.188: 234.58,77.97 234.58,76.43 229,70.85 229,70.61 229.62,69.99 229.62,69.73 229.45,69.56 229.21,69.56 228.58,70.19 228.34,70.19 228.16,70.02 228.16,69.71 228.62,69.25 228.62,69.05 228.21,68.64 228.21,68.05 228.04,67.87 227.79,67.87 227.62,68.05 227.62,68.81 227.45,68.99 227.2,68.99 227.03,68.81 227.03,67.54 227.27,67.3 227.99,67.3 228.21,67.08 228.21,64.4 227.32,63.5 227.32,60.48 228.21,59.58 228.21,58.43 229.08,57.56 229.08,53.78 229.27,53.6 229.27,53.36 228.93,53.02 228.93,52.77 229.1,52.6 229.35,52.6 229.69,52.94 229.93,52.94 230.08,52.79 230.08,51.61 230.8,50.89 230.8,47.83 231.13,47.5 231.38,47.5 233.61,45.27 233.61,44.6 233.17,44.16 233.17,42.7 233.33,42.54 v2(233.57,42.54)
  BOTTOM w0.211: v2(233.57,42.54) 233.27,42.24 233.27,41.94 233.44,41.77 233.98,41.77 234.22,42 234.22,44.51 234.68,44.97 JDIMM1.156
DDR_A_MA16: length 70.8
  TOP w0.076: UC1.AH4 238.03,89.25 237.2,89.25 v2(237.14,89.19)
  TOP w0.211: JDIMM2.152 235.68,38.77 235.02,39.42 233.96,39.42 233.59,39.79 233.59,41.09 233.74,41.23 233.93,41.23 v2(234.07,41.09)
  IN4 w0.076: 235.64,78.12 235.64,78.39 237.5,80.25 237.5,84.5 238.02,85.02 238.02,88.3 v2(237.14,89.19)
  IN4 w0.188: 235.64,78.12 235.64,75.99 230.99,71.34 230.99,69.01 230.47,68.49 230.47,66.87 230.29,66.7 230.04,66.7 229.87,66.87 229.87,67.81 229.7,67.99 229.45,67.99 229.28,67.81 229.28,63.96 228.38,63.06 228.38,60.92 229.28,60.02 229.28,58.87 230.59,57.55 230.59,56.65 230.15,56.21 230.15,54.22 231.14,53.23 231.14,52.05 232.63,50.56 232.63,47.75 234.69,45.69 234.69,42.04 234.07,41.42 v2(234.07,41.09)
  BOTTOM w0.211: JDIMM1.152 235.68,45.11 234.79,44.23 234.79,41.8 v2(234.07,41.09)
DDR_A_ODT0: length 67.1
  TOP w0.076: UC1.AD3 235.35,88.61 235.35,87.38 235.21,87.24 235.21,84.67 235.64,84.24 235.64,83.55 v2(236.68,82.51)
  TOP w0.168: JDIMM2.155 234.93,44.74 234.73,44.54 234.73,43.21 234.56,43.05 234.33,43.05 234.17,43.21 234.17,43.74 234.04,43.87 v2(233.63,43.87)
  IN2 w0.127: v2(233.63,43.87) 238.01,48.25 238.01,55.6 237.08,56.53 237.08,58.99 234.71,61.36 234.71,68.46 233.59,69.58 233.59,75.47 233.75,75.64 233.99,75.64 234.15,75.47 234.15,70.07 234.31,69.9 234.54,69.9 234.71,70.07 234.71,80.53 v2(236.68,82.51)
DDR_A_ODT1: length 67.2
  TOP w0.076: v2(236.69,85.77) 236.31,86.15 236.31,86.41 236.15,86.58 236.15,87.26 236.25,87.36 236.25,87.87 236.1,88.02 236.1,89.34 235.9,89.54 UC1.AE4
  TOP w0.168: v2(230.17,40.26) 230.92,41.01 230.92,43.61 231.95,44.64 232.89,44.64 233.43,45.17 JDIMM2.161
  IN4 w0.076: 233.39,79.8 233.92,80.32 233.92,80.46 235.25,81.79 235.25,83.74 235.58,84.08 235.58,84.94 236.42,85.77 v2(236.69,85.77)
  IN4 w0.152: 233.39,79.8 232.33,78.73 232.33,77.36 223.66,68.69 223.66,65.29 224.55,64.4 224.55,60.07 225.96,58.65 225.96,58.22 225.85,58.11 225.18,58.11 225.05,57.98 225.05,54.56 226.38,53.23 226.38,52.13 227.83,50.68 227.83,47.62 230.73,44.72 230.73,40.82 v2(230.17,40.26)
DDR_A_ODT2: length 67.9
  TOP w0.076: v2(236.65,84.29) 235.81,85.14 UC1.AE1
  IN4 w0.076: v2(236.65,84.29) 235.83,83.47 235.83,81.37 234.84,80.38 234.84,79.95 233.86,78.97
  IN4 w0.152: 233.86,78.97 233.24,78.36 233.24,76.98 224.57,68.31 224.57,66.64 224.72,66.49 224.98,66.49 225.13,66.64 225.13,68.05 225.28,68.2 225.54,68.2 225.69,68.05 225.69,66.51 225.84,66.36 226.28,66.36 226.44,66.21 226.44,65.96 226.28,65.8 225.84,65.8 225.69,65.65 225.69,65.4 225.84,65.24 226.28,65.24 226.44,65.09 226.44,64.84 226.28,64.69 225.84,64.69 225.46,64.31 225.46,60.44 226.88,59.03 226.88,57.49 226.47,57.08 226.47,54.43 227.29,53.61 227.29,52.51 229.47,50.33 229.47,47.27 231.64,45.1 231.64,43.91 232.16,43.4 232.16,42.15 v2(231.76,41.74)
  BOTTOM w0.168: v2(231.76,41.74) 231.31,41.3 231.31,40.25 232.56,39.01 233.21,39.01 233.35,38.87 234.6,38.87 234.93,38.55 JDIMM1.155
DDR_A_ODT3: length 71.3
  TOP w0.076: UC1.AD4 234.95,89.54 v2(234.62,89.21)
  IN4 w0.076: 233.07,80.13 233.23,80.28 233.28,80.28 234.85,81.85 234.85,83.85 235.02,84.02 235.02,88.82 v2(234.62,89.21)
  IN4 w0.152: 233.07,80.13 231.87,78.92 231.87,77.55 222.08,67.76 222.08,66.69 222.24,66.54 222.49,66.54 222.64,66.69 222.64,67.34 222.79,67.49 223.05,67.49 223.2,67.34 223.2,65.11 224.09,64.21 224.09,63.88 223.94,63.73 223.54,63.73 223.39,63.57 223.39,63.32 223.54,63.17 223.94,63.17 224.09,63.02 224.09,62.76 223.94,62.61 223.54,62.61 223.39,62.46 223.39,62.2 223.54,62.05 223.94,62.05 224.09,61.9 224.09,61.64 223.94,61.49 223.54,61.49 223.39,61.34 223.39,61.09 223.54,60.93 223.94,60.93 224.09,60.78 224.09,59.88 224.25,59.72 224.25,59.51 223.86,59.12 223.86,58.91 224.04,58.73 224.26,58.73 224.64,59.11 224.86,59.11 225.08,58.89 225.08,58.65 224.59,58.16 224.59,53.24 224.72,53.11 224.93,53.11 225.27,53.45 225.48,53.45 225.66,53.27 225.66,53.05 225.33,52.72 225.33,52.5 227.31,50.52 227.31,47.49 230.37,44.43 230.37,42.99 v2(230.21,42.83)
  BOTTOM w0.168: v2(230.21,42.83) 230.21,42.83 230.79,42.25 230.79,40.15 232.18,38.75 233.11,38.75 233.43,38.43 JDIMM1.161
DDR_A_PARITY: length 71
  TOP w0.076: UC1.AG3 237.86,88.61 237.86,87.4 237.7,87.24 237.7,84.89 238.18,84.41 v1(238.18,84.18) 238.18,83.44 239.03,82.6 v2(239.12,82.6)
  TOP w0.211: v2(237.24,40.76) 239.26,42.78 239.26,44.32 239.93,44.99 JDIMM2.143
  IN4 w0.076: 238.33,77.89 238.33,78.63 239.08,79.38 239.08,81.42 239.48,81.83 239.48,82.23 v2(239.12,82.6)
  IN4 w0.188: 238.33,77.89 238.33,74.9 234.83,71.4 234.83,70.28 233.9,69.35 233.9,66.07 233.12,65.29 233.12,58.79 233.9,58 233.9,54.28 234.42,53.76 234.42,52.59 236.53,50.48 236.53,47.65 238.04,46.14 238.04,44.53 238.23,44.34 238.23,39 238.02,38.79 237.5,38.79 237.24,39.05 v2(237.24,40.76)
  BOTTOM w0.211: v2(237.24,40.76) 238.79,40.76 239.06,40.5 239.06,40.24 238.42,39.6 238.42,39.02 238.64,38.8 239.69,38.8 239.93,38.56 JDIMM1.143
DDR_B_ACT#: length 60.2
  TOP w0.076: v2(244.51,93.12) UC1.AT9
  TOP w0.211: v2(248.15,54.1) 248.97,54.92 249.2,54.92 249.42,54.71 249.42,54.38 248.51,53.47 247.74,53.47 247.18,52.91 JDIMM4.114
  IN1 w0.076: v2(244.51,93.12) 244.13,92.74 244.13,91.63 244.33,91.44 244.78,91.44 245.9,90.32 245.9,86.63 247.31,85.22 247.31,83.17 250.78,79.69 250.78,77.96 251,77.74
  IN1 w0.188: v2(248.15,54.1) 248.99,54.94 248.99,57.83 252.03,60.87 252.03,62.86 253.16,63.98 253.16,64.81 254.71,66.36 254.71,66.56 255.65,67.5 255.65,73.09 251,77.74
  BOTTOM w0.211: v2(248.15,54.1) 247.72,54.52 247.72,57.88 247.18,58.42 JDIMM3.114
DDR_B_ALERT#: length 54.5
  TOP w0.076: v2(243.6,92.47) UC1.AR8
  TOP w0.211: v2(247.12,54.8) 247.35,54.57 247.35,53.51 246.68,52.84 JDIMM4.116
  IN1 w0.076: 246.8,81.46 246.8,82.3 244.89,84.2 244.89,86.42 244.27,87.05 244.27,90.64 243.22,91.69 243.22,91.95 243.39,92.13 243.39,92.27 v2(243.6,92.47)
  IN1 w0.188: v2(247.12,54.8) 247.56,55.24 247.56,56 247.73,56.17 247.73,59.87 249.08,61.21 249.08,62.54 250.15,63.61 250.15,64.46 252.82,67.14 252.82,67.34 253.76,68.28 253.76,72.31 246.8,79.28 246.8,81.46
  BOTTOM w0.211: JDIMM3.116 246.68,58.5 247.42,57.75 247.42,55.1 v2(247.12,54.8)
DDR_B_BA0: length 59.2
  TOP w0.076: v2(238.11,92.47) UC1.AH8
  TOP w0.211: v2(237.07,55.19) 236.44,54.56 236.44,53.46 236.55,53.34 236.95,53.34 237.14,53.15 237.14,52.95 236.96,52.77 236.34,52.77 236.18,52.6 JDIMM4.150
  IN1 w0.076: v2(238.11,92.47) 238.11,92.38 237.71,91.97 237.71,91.69 237.9,91.49 237.9,88.01 237.6,87.71 237.6,80.35 236.3,79.06 235.49,79.06 234.14,77.71 234.14,77.4
  IN1 w0.188: 234.14,77.4 234.14,75.61 232.71,74.18 230.72,72.19 230.72,70.63 230.9,70.45 231.14,70.45 231.32,70.63 231.32,71.92 231.49,72.09 231.74,72.09 231.91,71.92 231.91,69.11 232.29,68.74 232.29,67.64 232.6,67.32 233.01,67.32 233.19,67.14 233.19,61.42 236.97,57.64 236.97,57.24 236.67,56.94 236.67,56.5 236.97,56.2 236.97,56.02 236.83,55.89 236.58,55.89 236.44,55.74 236.44,55.38 236.71,55.11 236.98,55.11 v2(237.07,55.19)
  BOTTOM w0.211: v2(237.07,55.19) 236.48,55.78 236.48,58.5 236.18,58.81 JDIMM3.150
DDR_B_BA1: length 64.9
  TOP w0.076: v2(238.11,93.12) UC1.AH9
  TOP w0.211: v2(237.84,58.13) 238.48,58.13 238.8,58.45 238.8,60.5 238.58,60.72 238.31,60.72 238.11,60.52 238.11,59.05 237.94,58.88 237.57,58.88 237.43,59.03 JDIMM4.145
  IN1 w0.076: 235.37,77.4 235.37,77.69 236.1,78.42 236.4,78.42 238.07,80.1 238.07,87.51 238.24,87.68 238.24,91.38 238.49,91.63 238.49,92.74 v2(238.11,93.12)
  IN1 w0.188: v2(237.84,58.13) 237.84,58.34 234.78,61.39 234.78,61.8 235.27,62.29 235.27,62.55 234.9,62.93 234.43,62.93 234.26,63.1 234.26,63.35 234.43,63.52 234.83,63.52 235,63.69 235,63.94 234.83,64.11 234.43,64.11 234.26,64.29 234.26,64.53 234.43,64.71 234.65,64.71 234.82,64.88 234.82,65.13 234.65,65.3 234.43,65.3 234.26,65.48 234.26,65.72 234.43,65.9 234.61,65.9 234.78,66.07 234.78,66.35 234.33,66.8 234.33,69.19 234.16,69.36 234.16,72.74 233.99,72.92 233.74,72.92 233.57,72.74 233.57,69.55 233.39,69.38 233.15,69.38 232.97,69.55 232.97,72.94 235.37,75.33 235.37,77.4
  BOTTOM w0.211: JDIMM3.145 237.43,52.74 238.09,53.4 238.09,55.76 237.38,56.47 237.38,57.68 v2(237.84,58.13)
DDR_B_BG0: length 56.6
  TOP w0.076: v2(243.6,93.12) UC1.AR9
  TOP w0.211: v2(248.18,55.43) 247.9,55.43 247.56,55.77 247.56,56.2 247.73,56.36 247.73,58.05 246.93,58.86 JDIMM4.115
  IN1 w0.076: v2(243.6,93.12) 243.97,92.76 243.97,91.56 244.26,91.27 244.71,91.27 245.49,90.5 245.49,84.46 250.38,79.57 250.38,77.61 250.5,77.49
  IN1 w0.188: v2(248.18,55.43) 248.6,55.85 248.6,58.8 249.87,60.07 250.45,60.07 251.5,61.12 251.5,63.9 254.18,66.58 254.18,66.78 255.12,67.72 255.12,72.87 250.5,77.49
  BOTTOM w0.211: JDIMM3.115 246.93,52.7 247.81,53.59 248.23,53.59 248.61,53.97 248.61,55 v2(248.18,55.43)
DDR_B_BG1: length 61.7
  TOP w0.076: v2(243.6,91.82) UC1.AR7
  TOP w0.211: v2(248.16,56.61) 248.67,56.11 248.96,56.11 249.11,56.26 249.11,56.78 248.73,57.16 248.34,57.16 248.16,57.33 248.16,57.65 248.4,57.89 248.4,58.19 247.92,58.67 247.67,58.67 247.43,58.92 JDIMM4.113
  IN1 w0.076: v2(243.6,91.82) 243.6,91.6 244.09,91.11 244.64,91.11 245.07,90.68 245.07,87 245.21,86.87 245.21,84.32 247.62,81.91 247.62,81.71
  IN1 w0.188: v2(248.16,56.61) 248.16,59.18 249.66,60.69 250.28,60.69 250.97,61.37 250.97,61.83 250.79,62 250.45,62 250.27,62.18 250.27,62.43 250.45,62.61 250.79,62.61 250.97,62.79 250.97,64.12 253.64,66.8 253.64,67 254.58,67.94 254.58,72.65 247.65,79.59 247.65,79.84 247.83,80.02 248.08,80.02 249.45,78.65 249.7,78.65 249.88,78.83 249.88,79.08 247.62,81.34 247.62,81.71
  BOTTOM w0.211: v2(248.16,56.61) 248.32,56.61 248.91,56.02 248.91,53.84 248.13,53.06 247.88,53.06 247.43,52.6 JDIMM3.113
DDR_B_CB0: length 59.5
  TOP w0.076: v2(246.34,94.42) UC1.AW11
  TOP w0.152: JDIMM4.104 249.68,52.96 250.44,53.73 250.44,57.09 v2(249.99,57.54)
  IN2 w0.076: v2(246.34,94.42) 245.99,94.77 245.04,94.77 244.96,94.69 244.96,91.75 244.67,91.46 244.06,91.46 243.1,90.5 243.1,90.44
  IN2 w0.114: v2(249.99,57.54) 249.99,59.89 250.25,60.16 250.25,65.13 250.39,65.27 250.63,65.27 250.77,65.41 250.77,65.68 250.63,65.82 250.39,65.82 250.25,65.96 250.25,66.22 250.39,66.36 250.63,66.36 250.77,66.5 250.77,66.77 250.63,66.91 250.39,66.91 250.25,67.05 250.25,67.32 250.39,67.46 250.63,67.46 250.77,67.6 250.77,67.86 250.63,68 250.39,68 250.25,68.14 250.25,68.41 250.39,68.55 250.63,68.55 250.77,68.69 250.77,68.96 250.63,69.09 250.39,69.09 250.25,69.23 250.25,70.2 242.41,78.05 242.41,86.98 243.1,87.67 243.1,90.44
  BOTTOM w0.152: JDIMM3.104 249.68,59.22 250.14,58.75 250.14,58.57 250.05,58.48 249.82,58.48 249.64,58.3 249.64,58.08 249.77,57.95 250.32,57.95 250.77,58.4 251.01,58.4 251.2,58.21 251.2,57.51 251.01,57.33 250.62,57.33 250.41,57.54 v2(249.99,57.54)
DDR_B_CB1: length 59.6
  TOP w0.076: v2(247.26,94.42) UC1.AY11
  TOP w0.152: JDIMM4.88 253.68,52.4 255.2,53.93 255.2,56.18 v2(254.76,56.62)
  IN2 w0.076: 247.42,83.86 247.65,84.09 247.65,85.73 246.71,86.67 246.71,90.53 247.15,90.97 247.66,90.97 248.12,91.43 248.12,92.08 247.79,92.41 247.79,93.92 247.29,94.42 v2(247.26,94.42)
  IN2 w0.114: 247.42,83.86 247.11,83.56 247.11,78.33 248.1,77.35 248.32,77.35 248.5,77.52 248.5,77.72 247.98,78.23 247.98,78.43 248.17,78.62 248.37,78.62 251.17,75.82 251.17,74.23 256.62,68.78 256.62,59.88 255.3,58.56 255.3,57.16 v2(254.76,56.62)
  BOTTOM w0.152: v2(254.76,56.62) 254.67,56.53 254.34,56.53 254.09,56.78 254.09,57.3 253.94,57.45 253.48,57.45 253.3,57.64 253.3,57.96 253.47,58.13 254.13,58.13 254.28,58.28 254.28,58.51 254.11,58.68 253.86,58.68 253.68,58.86 JDIMM3.88
DDR_B_CB2: length 59.6
  TOP w0.076: v2(247.26,92.47) UC1.AY8
  TOP w0.152: JDIMM4.91 252.93,59.05 254.04,57.93 254.04,54.84 254.75,54.13 v2(254.75,54.08)
  IN2 w0.076: 246.69,84.44 247.26,85.01 247.26,85.44 246.18,86.53 246.18,90.47 247.01,91.3 247.4,91.3 247.71,91.6 247.71,91.92 247.26,92.37 v2(247.26,92.47)
  IN2 w0.114: 246.69,84.44 246.37,84.12 246.37,77.99 249.41,74.95 249.61,74.95 249.9,75.24 250.1,75.24 250.28,75.05 250.28,74.85 250,74.56 250,74.36 255.25,69.11 255.25,59.67 253.84,58.27 253.84,54.99 v2(254.75,54.08)
  BOTTOM w0.152: v2(254.75,54.08) 254.35,54.49 254.02,54.49 253.68,54.15 253.68,53.8 253.91,53.57 254.4,53.57 254.56,53.41 254.56,53.14 254.45,53.02 253.4,53.02 253.17,53.25 252.92,53.25 252.72,53.05 252.72,52.8 252.93,52.6 JDIMM3.91
DDR_B_CB3: length 59.3
  TOP w0.076: v2(246.34,92.47) UC1.AW8
  TOP w0.152: v2(251.2,55) 251.66,54.55 251.87,54.55 252.29,54.96 252.5,54.96 252.68,54.78 252.68,54.57 252.27,54.15 252.27,53.94 252.85,53.35 252.85,52.61 252.68,52.43 JDIMM4.92
  IN2 w0.076: 243.83,90.44 243.83,90.55 244.37,91.08 244.95,91.08 246.34,92.47 v2(246.34,92.47)
  IN2 w0.114: 243.83,90.44 243.83,87.36 243.21,86.74 243.21,78.29 252.66,68.84 252.66,66.35 252.52,66.21 252.25,66.21 252.11,66.35 252.11,67.8 251.97,67.93 251.73,67.93 251.57,67.78 251.57,59 251.09,58.52 251.09,57.15 250.72,56.78 250.72,55.48 v2(251.2,55)
  BOTTOM w0.152: JDIMM3.92 252.68,58.98 252.35,58.65 252.35,56.14 v2(251.2,55)
