# Allegro board LAH271PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLK_PCIE_N6: length 181.1
  TOP w0.076: 187.43,42.77 187.43,42.75 187.41,42.73 187.41,42.31 187.53,42.19 187.53,41.8 187.53,41.8 UH1.W4
  TOP w0.102: 187.43,42.77 187.43,42.96 187.8,43.33 187.8,43.94 187.17,44.57 186.73,44.57 v2(186.69,44.61)
  IN4 w0.102: v2(186.69,44.61) 186.05,44.61 185.83,44.39 185.83,42.35 186.68,41.49 186.68,36.05 187.18,35.56 188.3,35.56 188.77,35.09 188.77,32.43 189.33,31.87 190.27,31.87 190.84,31.3 190.84,30.18 191.56,29.46 195.28,29.46 198.8,25.94 199.52,25.94 202.12,23.34 202.75,23.34 203.33,22.76 205.89,22.76 207.63,21.03 211.15,21.03 213.38,18.8 231.69,18.8 232.82,17.68 246.41,17.68 251.86,12.23 251.86,11.34 253.12,10.08 253.71,10.08 256.91,6.88 258.23,6.88 260.52,4.59 274.02,4.59 274.6,4 282.04,4 282.96,3.09 285.2,3.09 285.53,2.76 292.06,2.76 292.8,3.5 294.06,3.5 294.56,3 300.67,3 301.96,4.29 303.22,4.29 305.52,1.98 311.65,1.98 312.08,2.41 313.66,2.41 314.18,1.89 323.62,1.89 326.8,5.07 328.01,5.07 329,6.06 329,7.03 v2(329.25,7.27)
  BOTTOM w0.102: v2(329.25,7.27) 328.77,7.75 328.77,9.16 328.9,9.29 JNGFF1.41
CLK_PCIE_N7: length 148.8
  TOP w0.089: UH1.W7 v2(187.89,40.06)
  IN4 w0.102: v2(187.89,40.06) 188.58,40.06 188.96,40.43 188.96,42.19 189.57,42.81 189.57,45.12 188.46,46.24 188.46,48.11 184.93,51.65 180.63,51.65 178.66,53.61 174.73,53.61 171.54,50.42 169.19,50.42 164.06,45.29 164.06,43.99 162.91,42.84 162.15,42.84 154.14,34.84 153.5,34.84 151.95,33.28 151.04,33.28 149.38,31.62 146.05,31.62 145.43,32.23 141.81,32.23 141.5,32.54 138.13,32.54 138.06,32.61 136.38,32.61 135.96,33.04 135.96,33.55 134.97,34.53 129.8,34.53 128.95,33.67 127.62,33.67 127.03,34.26 125.57,34.26 125.02,33.71 125.02,33.28 123.57,31.82 120.52,31.82 119.59,30.9 117.97,30.9 117.17,30.1 113.3,30.1 112.18,31.22 106.8,31.22 105.84,30.26 101.31,30.26 100.71,30.86 100.71,33.02 100.33,33.4 97.93,33.4 97.55,33.02 95.24,33.02 95.02,33.24 88.31,33.24 86.94,31.88 83.33,31.88 82.9,32.31 80.47,32.31 78.63,34.15 76.27,34.15 75.03,35.39 74.74,35.39 v2(74.51,35.63)
  BOTTOM w0.102: JNGFF3.53 75.62,36.2 75.46,36.05 75.23,36.05 75.03,35.85 75.03,35.48 74.88,35.33 74.62,35.33 74.51,35.44 v2(74.51,35.63)
CLK_PCIE_N8: length 207.3
  TOP w0.102: v2(185.02,37.27) 185.23,37.47 185.37,37.47 185.53,37.31 UH1.AC14
  IN4 w0.102: v2(349.97,10.33) 349.82,10.48 349.82,10.48 349.82,11.03 349.62,11.23 348.58,11.23 348.21,10.85 340.89,10.85 339.6,9.56 339.6,7.43 337.03,4.86 334.57,4.86 333.47,5.95 330.87,5.95 326.33,1.41 278.85,1.41 277.69,2.57 274.41,2.57 273.54,3.43 260.04,3.43 259.87,3.61 255.67,3.61 251.44,7.84 251.44,9.84 244.91,16.36 232.31,16.36 231.03,17.65 212.89,17.65 210.83,19.7 205.54,19.7 204.45,20.79 203.31,20.79 202.55,21.55 199.73,21.55 198.96,22.32 193.79,22.32 193.02,21.55 192.4,21.55 192.11,21.84 185.64,21.84 184.63,22.86 184.63,26.23 183.93,26.92 183.67,26.92 182.51,28.08 182.23,28.08 181.85,28.46 181.85,32.77 183.05,33.97 183.05,37.25 183.31,37.51 183.31,37.85 183.85,38.38 184.77,38.38 185.53,37.63 185.53,36.95 185.38,36.8 184.82,36.8 184.71,36.91 184.71,37.14 184.84,37.27 v2(185.02,37.27)
  BOTTOM w0.102: v2(349.97,10.33) 349.77,10.12 349.77,9.9 349.9,9.77 JNGFF4.53
CLK_PCIE_N9: length 148.3
  TOP w0.102: v2(187.25,45.09) 187.49,44.85 187.49,44.67 188.2,43.95 188.2,42.84 188.1,42.73 188.1,42.42 188.16,42.36 188.3,42.36 188.34,42.39 UH1.U2
  IN4 w0.102: v2(187.25,45.09) 187.51,45.35 187.51,45.46 187.34,45.63 181.39,45.63 179.79,47.24 178.55,47.24 177.52,48.26 173.31,48.26 172.68,48.9 169.84,48.9 165.6,44.66 165.6,43.62 165.76,43.46 165.76,42.99 164.08,41.31 162.84,41.31 153.13,31.6 151.6,31.6 150.08,30.07 141.78,30.07 140.85,31 137.81,31 137.51,30.7 136.05,30.7 134.69,32.07 133.88,32.07 133.49,32.46 132.46,32.46 131.97,31.96 130.88,31.96 130.4,32.43 130,32.43 129.34,31.77 127.4,31.77 126.92,31.29 125.62,31.29 123.97,29.64 123.35,29.64 122.98,29.27 118.61,29.27 117.72,28.38 100.31,28.38 99.39,29.3 93.76,29.3 92.36,27.9 86.66,27.9 86.43,28.14 83.77,28.14 82.82,27.19 80.44,27.19 80.22,27.41 80.22,27.9 80.15,27.96 v2(79.93,27.96)
  BOTTOM w0.102: JNGFF5.53 77.08,11.15 77.39,10.84 78.15,10.84 78.28,10.71 78.73,10.71 79.03,11 79.03,20.8 80.39,22.16 80.39,27.75 80.18,27.96 v2(79.93,27.96)
CLK_PCIE_P1: length 207.7
  TOP w0.102: UH1.AH10 v2(182.26,38.81)
  IN4 w0.102: v2(21.74,9.83) 21.97,10.06 22.32,10.06 24.56,12.3 26.11,12.3 26.44,11.97 26.95,11.97 27.2,11.73 29.94,11.73 30.76,12.55 33.25,12.55 34.53,11.27 35.21,11.27 36.28,12.34 36.28,13.47 37.08,14.27 37.08,18.85 36.75,19.18 36.75,22.11 37.58,22.94 40.37,22.94 41.12,23.7 41.12,25.16 40.59,25.69 40.59,26.21 41.09,26.71 41.82,26.71 42.95,27.84 45.35,27.84 46.65,26.54 49.67,26.54 51.09,25.12 52.79,25.12 54.13,23.78 57.99,23.78 59.55,25.34 62.5,25.34 64.14,26.99 67.44,26.99 68.6,28.15 72.06,28.15 73.64,26.57 79.45,26.57 80.05,25.97 82.75,25.97 83.73,26.95 86.29,26.95 86.57,27.23 92.68,27.23 94.06,28.6 99,28.6 99.92,27.68 110.43,27.68 111.27,26.85 116.99,26.85 117.37,26.46 119.15,26.46 120.62,27.93 122.59,27.93 123.56,28.9 124.42,28.9 126.14,30.61 127.25,30.61 127.74,31.1 130.29,31.1 130.86,30.53 131.32,30.53 132.05,31.26 132.23,31.26 132.6,31.63 133.26,31.63 133.5,31.39 134.25,31.39 135.6,30.04 137.84,30.04 138.01,30.21 139.09,30.21 139.47,29.83 141.06,29.83 141.54,29.36 141.96,29.36 142.47,28.84 145.59,28.84 145.86,29.12 147.03,29.12 147.31,28.84 149.83,28.84 151.59,30.6 153.11,30.6 155.26,32.75 156.82,32.75 157.56,33.49 157.56,35.05 163.14,40.63 165.63,40.63 167.06,42.06 167.06,43.14 166.48,43.71 166.48,44.59 170.04,48.15 171.98,48.15 172.53,47.59 175.34,47.59 176.46,46.47 176.46,46.05 180.88,41.63 180.88,39.92 181.63,39.17 181.89,39.17 v2(182.26,38.81)
  BOTTOM w0.102: UR1.7 21.89,11.21 22.24,10.86 22.24,10.33 v2(21.74,9.83)
CLK_PCIE_P2: length 141.9
  TOP w0.102: v2(183.7,36.41) 183.9,36.2 UH1.AE15
  IN4 w0.102: v2(183.7,36.41) 183.7,36.58 183.87,36.75 184.18,36.75 184.38,36.56 184.38,34.99 184.6,34.77 187.59,34.77 188.19,34.17 188.19,31.66 189.1,30.74 189.1,28.67 189.68,28.09 191.84,28.09 192.04,27.89 192.53,27.89 192.68,27.74 193.11,27.74 193.36,27.48 196.32,27.48 198.52,25.27 199.24,25.27 201.85,22.66 202.44,22.66 203.67,21.44 204.54,21.44 205.71,20.26 210.96,20.26 213.09,18.13 231.26,18.13 232.42,16.97 245.02,16.97 252.26,9.73 252.26,8.68 254.99,5.96 258.2,5.96 260.24,3.92 273.74,3.92 274.58,3.07 277.87,3.07 278.62,2.32 285.02,2.32 285.36,1.99 292.79,1.99 293.15,2.35 294.18,2.35 294.41,2.12 301.94,2.12 302.85,3.02 302.85,3.81 v2(302.93,3.9)
  BOTTOM w0.102: v2(302.93,3.9) 302.76,3.72 302.76,3.38 303,3.14 JNGFF2.47
CLK_PCIE_P3: length 117.9
  TOP w0.094: v2(183.94,40.44) UH1.AE7
  IN1 w0.102: v2(201.24,116.1) 201.29,116.04 201.29,115.66 201.15,115.52 200.91,115.52 199.57,116.86 199.57,118.43 196.05,121.95 193.63,121.95 191.19,124.39 189.56,124.39 189.01,124.94 189.01,125.4 189.15,125.55 v2(189.49,125.55)
  IN2 w0.094: v2(201.24,116.1) 201.24,115.76 201.18,115.7 199.89,115.7 199.33,115.14 199.33,114.75 197.46,112.88 197.06,112.88 195.76,111.58 195.76,109.19 195.28,108.71 195.28,106.07 194.15,104.94 194.15,102.78 193.19,101.82 193.19,97.59 192.8,97.2 192.8,93.58 193.4,92.98 193.4,91.28 196.37,88.31 196.37,87.34 197.97,85.74 197.97,82.82 199.81,80.98 199.81,79.27 201.87,77.21 201.87,68.3 201.14,67.57 201.14,65.2 201.71,64.62 201.71,62.83 199.86,60.98 199.86,59.3 200.04,59.12 200.04,58.81 198.45,57.21 198.45,54.86 197.54,53.95 197.54,52.52 197.05,52.03 195.01,52.03 192.99,50.01 192.99,47.35 193.45,46.88 193.45,43.84 192.07,42.46 185.34,42.46 184.11,41.23 184.11,40.61 v2(183.94,40.44)
  BOTTOM w0.102: UL1.44 189.15,124.83 189.06,124.92 189.06,125.11 v2(189.49,125.55)
CLK_PCIE_P4: length 193.7
  TOP w0.102: v2(185.74,48.86) 185.74,48.85 185.16,48.27 185.16,45.54 185.45,45.25 185.45,44.34 185.37,44.26 185.37,42.83 185.26,42.72 185.26,42.64 185.25,42.64 185.25,42.37 185.26,42.37 185.26,42.34 UH1.AC3 ; v2(41.51,28.05) 41.04,27.58 40.68,27.58 40.66,27.56 40.17,27.56 40.03,27.71 39.19,27.71 37.78,29.13 37.78,30.86 37.08,31.56 37.08,32.76 35.95,33.89 33.82,33.89 32.95,34.76 32.95,34.85 33.14,35.04 v2(33.26,35.04)
  IN4 w0.102: v2(185.74,48.86) 186.47,48.14 186.47,47.66 186.11,47.3 185.39,47.3 184.87,47.82 184.87,48.29 182.51,50.65 180.31,50.65 178.77,52.19 174.53,52.19 171.9,49.57 169.56,49.57 164.92,44.93 164.92,43.63 164.72,43.43 164.72,42.96 163.75,41.98 162.56,41.98 152.97,32.4 151.43,32.4 149.78,30.75 145.68,30.75 145.06,31.37 144.49,31.37 143.87,30.75 142.05,30.75 141.12,31.68 137.35,31.68 137.29,31.74 136.02,31.74 135.05,32.71 135.05,33.24 134.63,33.66 132.22,33.66 131.4,32.84 130.95,32.84 130.68,33.11 129.61,33.11 128.95,32.44 127.16,32.44 126.58,33.03 126.12,33.03 124.05,30.96 121.06,30.96 120.08,29.98 118.29,29.98 117.54,29.23 112.11,29.23 111.56,29.78 106.76,29.78 106.34,29.36 100.65,29.36 100.03,29.98 93.35,29.98 92.85,29.48 87.51,29.48 86.83,28.81 83.49,28.81 82.93,28.25 81.1,28.25 80.38,28.97 76.3,28.97 75.54,28.21 73.24,28.21 72.56,28.89 68.32,28.89 67.2,27.77 63.43,27.77 61.71,26.05 59.32,26.05 58.06,24.79 54.07,24.79 53.07,25.79 51.37,25.79 49.84,27.32 49.05,27.32 48.79,27.58 46.58,27.58 45.8,28.36 45.8,29.07 45.38,29.49 44.92,29.49 44.13,28.69 42.22,28.69 41.94,28.42 41.16,28.42 40.99,28.24 40.99,27.84 41.01,27.82 41.27,27.82 v2(41.51,28.05)
  BOTTOM w0.102: v2(33.26,35.04) 33.26,35.08 33.55,35.37 UT1.V19
CLK_PCIE_P6: length 181
  TOP w0.076: UH1.W3 187.32,41.81 187.25,41.75 187.16,41.75 187.1,41.82 187.1,42.16 187.26,42.32 187.26,42.73 187.24,42.75 187.24,42.77
  TOP w0.102: 187.24,42.77 187.24,43.04 187.61,43.4 187.61,43.87 187.09,44.38 186.98,44.38 186.69,44.08 v2(186.69,43.98)
  IN4 w0.102: v2(186.69,43.98) 186.69,44.03 186.29,44.42 186.12,44.42 186.01,44.31 186.01,42.43 186.87,41.57 186.87,36.13 187.26,35.75 188.38,35.75 188.95,35.17 188.95,32.5 189.4,32.05 190.35,32.05 191.03,31.38 191.03,30.25 191.63,29.65 195.36,29.65 198.88,26.13 199.6,26.13 202.2,23.53 202.83,23.53 203.41,22.95 205.97,22.95 207.7,21.21 211.23,21.21 213.45,18.99 231.77,18.99 232.9,17.86 246.49,17.86 252.05,12.3 252.05,11.42 253.2,10.27 253.79,10.27 256.99,7.07 258.3,7.07 260.6,4.78 274.1,4.78 274.68,4.19 282.12,4.19 283.04,3.28 285.28,3.28 285.61,2.95 291.98,2.95 292.72,3.69 294.14,3.69 294.64,3.19 300.59,3.19 301.88,4.47 303.29,4.47 305.6,2.17 311.57,2.17 312.01,2.6 313.74,2.6 314.26,2.08 323.54,2.08 326.72,5.26 327.93,5.26 328.82,6.14 328.82,7.47 328.75,7.54 328.55,7.54 v2(328.31,7.3)
  BOTTOM w0.102: JNGFF1.39 328.4,9.25 328.58,9.07 328.58,7.38 328.5,7.3 v2(328.31,7.3)
CLK_PCIE_P7: length 148.8
  TOP w0.089: UH1.W6 v2(188.08,40.8)
  IN4 w0.102: v2(188.08,40.8) 188.08,40.39 188.23,40.25 188.51,40.25 188.77,40.51 188.77,42.27 189.39,42.89 189.39,45.04 188.27,46.16 188.27,48.04 184.85,51.46 180.55,51.46 178.59,53.43 174.81,53.43 171.62,50.24 169.27,50.24 164.25,45.21 164.25,43.91 162.99,42.65 162.22,42.65 154.22,34.65 153.58,34.65 152.03,33.09 151.12,33.09 149.46,31.43 145.97,31.43 145.35,32.04 141.73,32.04 141.42,32.35 138.05,32.35 137.98,32.43 136.3,32.43 135.77,32.96 135.77,33.47 134.89,34.34 129.88,34.34 129.02,33.48 127.54,33.48 126.95,34.07 125.65,34.07 125.21,33.63 125.21,33.2 123.64,31.63 120.59,31.63 119.67,30.71 118.05,30.71 117.25,29.92 113.22,29.92 112.1,31.03 106.88,31.03 105.92,30.07 101.23,30.07 100.52,30.78 100.52,32.95 100.25,33.21 98.01,33.21 97.63,32.83 95.16,32.83 94.94,33.06 88.39,33.06 87.02,31.69 83.25,31.69 82.82,32.12 80.39,32.12 78.55,33.97 76.19,33.97 74.95,35.2 74.47,35.2 74.39,35.12 v2(74.39,34.83)
  BOTTOM w0.102: JNGFF3.55 75.62,35.7 75.47,35.85 75.31,35.85 75.22,35.77 75.22,35.4 74.96,35.14 74.7,35.14 v2(74.39,34.83)
CLK_PCIE_P8: length 207.3
  TOP w0.102: UH1.AC15 185.21,36.2 v2(185,36.42)
  IN4 w0.102: v2(349.31,10.33) 349.4,10.33 349.63,10.56 349.63,10.95 349.54,11.04 348.66,11.04 348.29,10.67 340.97,10.67 339.79,9.48 339.79,7.35 337.1,4.67 334.49,4.67 333.39,5.76 330.95,5.76 326.41,1.22 278.77,1.22 277.61,2.38 274.33,2.38 273.46,3.25 259.97,3.25 259.79,3.42 255.59,3.42 251.25,7.77 251.25,9.76 244.83,16.17 232.23,16.17 230.95,17.46 212.81,17.46 210.76,19.51 205.46,19.51 204.37,20.6 203.23,20.6 202.47,21.36 199.65,21.36 198.88,22.13 193.87,22.13 193.1,21.36 192.32,21.36 192.03,21.65 185.57,21.65 184.44,22.78 184.44,26.15 183.86,26.73 183.59,26.73 182.43,27.89 182.15,27.89 181.66,28.38 181.66,32.85 182.86,34.05 182.86,37.33 183.12,37.59 183.12,37.92 183.77,38.57 184.85,38.57 185.71,37.71 185.71,36.87 185.45,36.61 185.19,36.61 v2(185,36.42)
  BOTTOM w0.102: v2(349.31,10.33) 349.46,10.33 349.58,10.21 349.58,9.96 349.4,9.79 JNGFF4.55
CLK_PCIE_P9: length 148.3
  TOP w0.102: UH1.U3 188.57,42.31 188.57,42.72 188.56,42.73 188.56,42.74 188.4,42.9 188.4,44.03 187.68,44.74 187.68,44.85 v2(187.91,45.09)
  IN4 w0.102: v2(187.91,45.09) 187.7,45.3 187.7,45.54 187.42,45.82 181.47,45.82 179.87,47.43 178.63,47.43 177.6,48.45 173.38,48.45 172.75,49.08 169.76,49.08 165.41,44.74 165.41,43.54 165.57,43.38 165.57,43.07 164,41.5 162.76,41.5 153.05,31.79 151.53,31.79 150,30.26 141.86,30.26 140.93,31.19 137.73,31.19 137.43,30.89 136.13,30.89 134.77,32.26 133.95,32.26 133.57,32.65 132.39,32.65 131.89,32.15 130.96,32.15 130.48,32.62 129.92,32.62 129.26,31.96 127.32,31.96 126.84,31.48 125.54,31.48 123.89,29.82 123.27,29.82 122.9,29.46 118.53,29.46 117.64,28.57 100.39,28.57 99.47,29.49 93.69,29.49 92.28,28.09 86.74,28.09 86.5,28.33 83.7,28.33 82.74,27.37 80.52,27.37 80.4,27.49 80.4,27.98 v2(80.58,28.15)
  BOTTOM w0.102: v2(80.58,28.15) 80.58,22.09 79.22,20.72 79.22,10.92 78.81,10.52 78.2,10.52 78.07,10.65 JNGFF5.55
CLK_PEG_N0: length 90.6
  TOP w0.094: UH1.AJ6 182.44,40.72 182.63,40.72 v2(182.94,41.03)
  TOP w0.102: JDGFF1.H8 172.87,78.59 173.07,78.39 173.07,78.26 v2(172.87,78.05)
  IN2 w0.094: v2(195.47,85.51) 195.64,85.69 195.9,85.69 197.3,84.29 197.3,82.52 199.12,80.7 199.12,78.84 200.89,77.07 200.89,68.78 200.41,68.3 200.41,66.95 200.02,66.56 200.02,65.31 200.98,64.35 200.98,63.11 199.08,61.2 199.08,59.55 197.75,58.22 197.75,56.35 197.02,55.63 197.02,54.38 196.73,54.09 196.73,53.56 195.88,52.71 194.73,52.71 192.28,50.26 192.28,46.88 192.76,46.4 192.76,44.13 191.8,43.17 184.31,43.17 183.26,42.12 183.26,41.25 183.37,41.14 183.37,40.97 183.27,40.87 183.1,40.87 v2(182.94,41.03)
  BOTTOM w0.102: v2(172.87,78.05) 173.06,77.87 173.06,77.64 173.36,77.34 175.15,77.34 175.82,76.67 178.62,76.67 179.68,77.74 185.35,77.74 186.2,78.58 187.09,78.58 194.5,85.98 195.2,85.98 195.47,85.71 v2(195.47,85.51)
CLK_PEG_P0: length 90.7
  TOP w0.102: JDGFF1.H7 173.47,78.58 173.27,78.38 173.27,78.25 v2(173.46,78.05) ; UH1.AJ7 v2(183.21,40.41)
  IN2 w0.094: v2(195.99,86.11) 195.99,85.88 197.49,84.37 197.49,82.6 199.31,80.78 199.31,78.92 201.09,77.15 201.09,68.69 200.61,68.22 200.61,66.87 200.22,66.48 200.22,65.39 201.18,64.43 201.18,63.03 199.27,61.12 199.27,59.47 197.94,58.14 197.94,56.27 197.22,55.54 197.22,54.3 196.93,54.01 196.93,53.48 195.96,52.51 194.81,52.51 192.48,50.18 192.48,46.96 192.96,46.48 192.96,44.05 191.88,42.97 184.39,42.97 183.46,42.04 183.46,41.33 183.57,41.23 183.57,40.89 183.21,40.54 v2(183.21,40.41)
  BOTTOM w0.102: v2(173.46,78.05) 173.25,77.85 173.25,77.72 173.44,77.53 175.23,77.53 175.9,76.86 178.54,76.86 179.6,77.93 185.27,77.93 186.12,78.77 187.02,78.77 194.42,86.17 195.28,86.17 195.43,86.02 195.9,86.02 v2(195.99,86.11)
CLK_TP_SIO_I2C_DAT: length 214.3
  TOP w0.102: UE1.E10 v2(137.53,26.45)
  TOP w0.109: CZ81.1 RZ23.2 277.42,9.64 RZ346.1 277.42,10.94 274.11,14.25 268.68,14.25 268.33,13.89 268.33,12.64 268.54,12.43 269.45,12.43 269.56,12.32 269.56,12.09 269.41,11.94 267.98,11.94 267.84,12.08 267.84,12.61 267.69,12.75 267.49,12.75 267.35,12.61 267.35,12.08 267.2,11.94 265.3,11.94 265.23,12.01 265.23,12.36 265.37,12.51 266.74,12.51 266.92,12.68 266.92,12.86 266.76,13.02 266.24,13.02 266.05,13.2 266.05,13.42 266.42,13.79 v2(267.06,13.79)
  IN2 w0.081: v2(267.06,13.79) 267.06,14.27 265.24,16.09 251.71,16.09 250.27,14.64 240.87,14.64 240.25,15.26 220.64,15.26 219.39,14.01 212.99,14.01 209.96,10.97 209.96,8.7 v2(210.97,7.68)
  IN4 w0.102: v2(210.97,7.68) 210.76,7.68 209.79,6.71 209.79,6.15 208.12,4.48 205.97,4.48 205.79,4.66 194.7,4.66 193.74,5.61 192.53,5.61 192.03,5.11 178.71,5.11 178.19,5.64 175.38,5.64 173.44,7.58 173.44,8.5 172.97,8.97 166.16,8.97 165.63,9.5 161.9,9.5 160.57,10.83 160.57,11.61 159.72,12.46 159.29,12.46 158.56,13.18 156.79,13.18 155.05,14.92 153.65,14.92 152.02,16.54 148.05,16.54 146.02,14.51 146.02,13.62 146.37,13.26 146.37,12.93 145.21,11.76 141.37,11.76 140.56,10.95 139.89,10.95 139.3,11.54 130.5,11.54 129.89,12.15 128.38,12.15 128.04,12.48 128.04,13.09 127.28,13.85 127.28,15.56 124.89,17.95 124.89,21.19 125.64,21.95 126.7,21.95 126.85,22.1 126.85,22.74 127.63,23.52 127.63,25.21 128.3,25.87 129.21,25.87 130.21,26.88 130.21,26.95 130.94,27.68 132.84,27.68 133.16,27.36 133.16,26.98 133.26,26.88 136.94,26.88 137.37,26.45 v2(137.53,26.45)
CLK_TP_SIO_R: length 17
  TOP w0.109: JKBTP1.14 287.16,11.43 287.09,11.36 287.09,10.97 286.63,10.51 285.56,10.51 285.47,10.6 280.88,10.6 280.47,10.19 280.47,9.42 280.15,9.1 277.05,9.1 RZ23.1 RZ19.2 275.17,10.06 274.31,10.06 273.84,9.59 v1(273.84,9)
CLKDET#: length 3.4
  TOP w0.109: T258.1 171.52,26.67 171.79,26.4 173.79,26.4 173.87,26.47 UH1.BF35
CLKREQ_CNV: length 208.8
  TOP w0.089: v2(176.91,35.78) 176.91,35.34 UH1.BA17
  IN2 w0.081: v2(217.89,21.43) 219.8,23.34 231.25,23.34 233.14,21.45 238.27,21.45 238.87,20.85 241.86,20.85 243.51,22.51 270.19,22.51 276.01,16.69 276.01,15.6 278.81,12.8 287.63,12.8 290.42,10.01 299.44,10.01 299.87,9.58 308.74,9.58 309.49,8.83 313.33,8.83 313.89,9.38 319.4,9.38 320.73,10.71 320.73,11.54 322.65,13.46 323.25,13.46 324.39,14.59 324.39,14.86 324.77,15.24 330.75,15.24 331,14.99 332.73,14.99 v2(333.58,15.84)
  IN3 w0.081: v2(335.52,5.27) 335.52,4.87 335.44,4.79 334.37,4.79 333.34,5.82 333.34,8.38 335.94,10.99 335.94,11.5 335.16,12.29 334.7,12.29 333.58,13.4 v2(333.58,15.84) ; v2(217.89,21.43) 217.14,22.18 210.9,22.18 209.36,23.73 208.28,23.73 206.35,25.65 200.26,25.65 198.49,27.42 198.49,29.91 198.57,29.99 v2(198.57,30.15) 198.57,32 196.54,34.02 196.54,36.02 194.8,37.76 193.06,37.76 192.33,38.49 192.04,38.49 191.37,39.17 191.37,40.12 191.17,40.32 190.88,40.32 189.9,41.31 189.42,41.31 188.54,40.43 185.55,40.43 184.38,39.26 183.67,39.26 182.7,40.23 180.88,40.23 180.43,39.78 179.37,39.78 178.99,39.4 178.99,38.65 179.35,38.29 179.35,37.19 177.94,35.78 v2(176.91,35.78)
  BOTTOM w0.109: QZ18.2 338.69,4.47 338.55,4.61 337.96,4.61 337.75,4.83 RZ4.1 335.74,5.06 v2(335.52,5.27) ; v2(198.57,30.15) 197.63,31.09 RH733.1
CLKREQ_CNV_R: length 3.6
  BOTTOM w0.109: QZ18.3 339.34,4.93 v1(339.22,5.06) RZ4.2 338.33,5.54 RZ532.2 RZ376.2
CLKREQ_PCIE#1: length 192.2
  TOP w0.102: v2(164.77,26.73) 164.77,27.14 165.14,27.51 166.04,27.51 166.05,27.52 166.95,27.52 167.51,28.09 v1(167.75,28.09) 168.1,28.44 168.36,28.44 168.37,28.44 168.67,28.44 168.67,28.44 171.35,28.44 171.37,28.45 171.38,28.45 171.47,28.55 174.05,28.55 174.17,28.44 174.54,28.44 174.61,28.51 UH1.BE31
  IN2 w0.081: v2(98.32,26.98) 98.99,26.3 98.99,25.44 99.94,24.49 100.25,24.49 101.44,23.3 101.44,21.04 101.72,20.76 103.61,20.76 103.99,20.38 109.7,20.38 110.16,20.83 110.93,20.83 112.81,18.96 112.81,17.27 113.67,16.4 117.13,16.4 118.57,14.96 121,14.96 121.72,14.24 124.18,14.24 124.48,14.54 126.22,14.54 126.52,14.24 127.08,14.24 127.9,15.06 132.63,15.06 132.66,15.03 133.51,15.03 133.58,15.1 135.42,15.1 135.58,14.95 135.99,14.95 136.74,15.7 137.76,15.7 138.66,14.8 139.34,14.8 141.23,16.69 141.23,18.56 141.85,19.18 145.23,19.18 150.1,24.06 152.84,24.06 153.96,25.18 158.44,25.18 158.65,25.39 159.83,25.39 160.39,25.94 160.39,26.42 160.74,26.78 162.54,26.78 163.02,26.3 164.49,26.3 164.77,26.57 v2(164.77,26.73)
  IN4 w0.102: v2(98.32,26.98) 97.69,26.98 96.69,25.98 88.17,25.98 86.85,24.66 84.69,24.66 83.68,23.65 81.18,23.65 79.1,25.73 71.42,25.73 69.97,24.29 64.36,24.29 63.79,23.72 62.3,23.72 61.78,24.25 60.56,24.25 58.96,22.65 55.39,22.65 53.78,21.04 52.73,21.04 52.62,21.15 52.62,23.21 51.82,24.01 50.69,24.01 49.33,25.37 48.23,25.37 47.96,25.1 46.18,25.1 44.94,26.35 44.34,26.35 43.54,25.54 42.15,25.54 41.96,25.35 41.96,23.25 40.77,22.06 38.74,22.06 37.93,21.26 37.93,13.88 37.12,13.07 37.12,12 35.17,10.04 31.5,10.04 30.84,10.71 29.78,10.71 29.31,10.24 26.56,10.24 25.67,11.13 v2(25.62,11.13)
  BOTTOM w0.109: v2(164.77,26.73) 164.77,26.17 164.63,26.04 RH124.1 ; UR1.2 23.89,11.76 24.53,11.13 v2(25.62,11.13)
CLKREQ_PCIE#2: length 194.6
  TOP w0.102: UH1.AR32 v2(179.79,27.53)
  IN1 w0.102: v2(179.79,27.53) 179.79,27.28 179.47,26.96 177.96,26.96 177.52,26.52 177.08,26.52 176.76,26.2 175.95,26.2 175.77,26.38 171.94,26.38 171.62,26.69 171.62,27.57 172.13,28.08 173.54,28.08 173.81,28.35 173.81,29.55 172.18,31.18 170.73,31.18 170.32,30.76 168.45,30.76 168.06,30.38 168.06,28.5 166.77,27.21 166.1,27.21 v2(165.59,26.71)
  IN2 w0.081: v2(219.78,21.86) 231.11,21.86 233.36,19.61 242.76,19.61 244.41,21.27 268.39,21.27 270.54,19.12 270.54,18.37 272.31,16.59 273.69,16.59 274.12,16.16 274.12,15.36 278.46,11.02 284.19,11.02 285.26,9.95 286.4,9.95 287.74,8.6 296.49,8.6 296.86,8.23 301.26,8.23 v2(301.92,8.9)
  IN3 w0.081: v2(179.79,27.53) 180.48,28.22 180.48,29.42 180.23,29.67 180.23,32.86 179.53,33.56 176.08,33.56 174.88,34.76 174.88,39.27 174.6,39.55 174.6,40.92 174.95,41.27 175.85,41.27 176.98,42.39 177.8,42.39 178.21,42.8 194.91,42.8 196.24,41.47 196.24,37.66 197.44,36.46 197.44,34.3 201.54,30.2 205.92,30.2 209.53,26.59 211.2,26.59 213.5,24.3 217.34,24.3 v2(219.78,21.86)
  BOTTOM w0.109: JNGFF2.44 302.25,9.28 301.92,8.95 v2(301.92,8.9) ; RH126.1 165.59,26.14 v2(165.59,26.71)
CLKREQ_PCIE#3: length 136
  TOP w0.089: UH1.BB30 176.05,28.45 v2(176.16,28.34)
  TOP w0.109: v2(191.26,103.21) 191.14,103.21 v1(190.51,103.83)
  IN1 w0.102: v2(162.7,27.8) 162.83,27.66 166.58,27.66 167.61,28.69 167.61,30.57 168.87,31.83 172.22,31.83 175.44,28.61 175.89,28.61 v2(176.16,28.34)
  IN2 w0.081: v2(191.26,103.21) 191.06,103 191.06,96.51 191.39,96.17 191.39,89.14 191.61,88.92 191.61,87.41 193.3,85.72 193.3,82.69 196.78,79.2 196.78,66.26 196.45,65.92 196.45,62.34 196.78,62.01 196.78,61.61 196.42,61.24 196.42,60.56 194.82,58.96 194.82,57.86 193.79,56.82 192.85,56.82 191.97,55.94 187.94,55.94 185.63,53.63 185.63,50.7 184.83,49.9 184.83,49.25 182.85,47.27 182.85,46.96 182.62,46.73 182.62,44.75 180.93,43.06 180.93,41.26 181.51,40.68 181.51,38.3 180.71,37.49 180.71,36.42 180.92,36.2 180.92,34.91 180.53,34.52 179.03,34.52 178.67,34.15 178.67,33.1 178.73,33.04 178.73,30.12 178.2,29.58 176.78,29.58 176.16,28.96 v2(176.16,28.34)
  IN3 w0.081: v2(187.23,123.47) 187.23,122.92 188.79,121.36 188.79,116.02 187.11,114.33 187.11,111.36 190.45,108.02 190.45,106.97 190.82,106.6 190.82,103.65 191.26,103.21 v2(191.26,103.21)
  BOTTOM w0.102: RH127.1 163.1,27.4 v2(162.7,27.8)
  BOTTOM w0.109: v2(187.23,123.47) 187.23,123.6 187.55,123.92 UL1.48
CLKREQ_PCIE#4: length 176.2
  TOP w0.089: UH1.BA30 v2(176.79,28.46)
  TOP w0.109: v1(38.58,42.8) 38.17,42.38 RT502.1 37.59,41.73 36.75,40.89 v2(34.56,40.89)
  IN1 w0.102: v2(160.81,31.8) 162.4,30.22 163.68,30.22 165.12,31.66 165.49,31.66 166.8,32.97 170.08,32.97 170.89,32.16 172.22,32.16 175.16,29.22 176.5,29.22 176.79,28.93 v2(176.79,28.46)
  IN2 w0.081: v2(99.28,30.94) 99.28,30.13 100.81,28.59 101.83,28.59 104.23,26.19 108.65,26.19 109.26,25.59 114.52,25.59 115.88,24.23 116.67,24.23 117.15,23.76 117.15,23.5 118.02,22.62 118.73,22.62 119.21,22.14 119.21,21.88 119.58,21.51 120.32,21.51 120.82,21 122.18,21 122.77,20.4 122.77,20.39 123.2,19.97 125.3,19.97 125.65,19.62 127.99,19.62 128.39,19.22 129.93,19.22 130.2,19.49 130.96,19.49 131.19,19.25 132.48,19.25 132.71,19.49 137.12,19.49 137.76,20.14 138.23,20.14 138.76,20.67 138.76,22.85 139.95,24.05 143.06,24.05 143.39,23.71 144.63,23.71 149.86,28.93 156.11,28.93 158.98,31.8 v2(160.81,31.8)
  IN3 w0.081: v2(34.56,40.89) 34.56,40.69 35.33,39.91 35.33,38.67 35.33,35.27 36.16,34.44 36.79,34.44 37.14,34.09 37.14,33.51 v2(37.07,33.44)
  IN4 w0.102: v2(99.28,30.94) 99.28,31.5 98.95,31.83 91.61,31.83 90.64,30.85 82.84,30.85 82.41,31.28 81.08,31.28 79.85,30.05 75.46,30.05 73.43,32.08 71.58,32.08 71.22,31.72 59.97,31.72 59.23,32.47 59.23,32.64 58.84,33.03 57.05,33.03 56.96,33.12 54.03,33.12 53.98,33.07 48.49,33.07 48.22,32.8 43.81,32.8 43.08,33.52 37.24,33.52 37.15,33.44 v2(37.07,33.44)
  BOTTOM w0.102: v2(160.81,31.8) 161.17,31.45 RH128.1
  BOTTOM w0.109: UT1.Y6 v2(34.56,40.89)
CLKREQ_PCIE#6: length 167.8
  TOP w0.109: RH130.1 185.18,16.75 v2(184.18,17.75) 184.18,20.45 184.26,20.52 UH1.AE47
  IN2 w0.081: v2(329.16,11.14) 327.91,11.14 326.69,9.93 324.84,8.07 323.71,8.07 321.88,6.24 315.46,6.24 314.48,7.23 313.18,7.23 312.32,6.37 307.2,6.37 306.02,7.55 290.49,7.55 289.48,6.54 288.11,6.54 287.66,6.98 287.66,7.63 286.18,9.11 282.98,9.11 281.65,10.45 278.44,10.45 273.4,15.49 272.63,15.49 270.6,17.52 269.5,17.52 267.94,19.07 265.28,19.07 263.83,20.53 245.4,20.53 243.26,18.39 228.63,18.39 227.78,19.24 217.79,19.24 214.43,15.88 214.43,15.55 v2(213.95,15.08)
  IN4 w0.102: v2(184.18,17.75) 184.4,17.96 187.24,17.96 188.21,16.99 190.67,16.99 192.58,18.89 198.73,18.89 201.21,16.41 208.8,16.41 210.73,14.48 213.35,14.48 v2(213.95,15.08)
  BOTTOM w0.109: v2(329.16,11.14) 329.54,11.14 329.9,10.78 JNGFF1.45
CLKREQ_PCIE#7: length 222.1
  TOP w0.109: RH131.1 186.63,17 186.5,17.13 v2(186.5,17.41) 185.69,18.22 185.69,18.9 185.48,19.11 UH1.AC48
  IN2 w0.081: v2(82.79,36.46) 82.84,36.46 83.58,37.2 85.83,37.2 85.86,37.17 91.9,37.17 97.48,31.59 97.48,30.01 99.59,27.91 99.59,27.18 100.45,26.31 100.81,26.31 v2(101.62,25.51)
  IN3 w0.081: v2(162.42,11.48) 163.01,10.89 165.58,10.89 166.4,11.71 167.71,11.71 168.3,11.12 177.63,11.12 179,12.48 179,14.41 179.2,14.61 183.07,14.61 184.34,15.88 184.97,15.88 v2(186.5,17.41)
  IN4 w0.102: v2(101.62,25.51) 103.3,23.83 103.3,17.37 107.8,12.87 109.65,12.87 111.6,10.92 111.6,3.53 109.34,1.27 76.94,1.27 v2(76.31,1.89)
  BOTTOM w0.109: v2(162.42,11.48) 160.35,11.48 158.26,13.57 157.21,13.57 155.15,15.63 147.98,15.63 147.69,15.34 147.69,14.38 147.36,14.05 147.36,13.25 144.13,10.02 142.37,10.02 141.74,9.38 141.74,7.98 141.42,7.65 140.5,7.65 134.85,2 121.59,2 118.79,4.8 112.52,4.8 v1(111.84,4.12) 110.22,2.5 101.25,2.5 100.32,3.44 92.4,3.44 92.08,3.12 90.34,3.12 89.53,3.92 83.32,3.92 81.62,2.22 77.72,2.22 77.35,1.85 76.36,1.85 v2(76.31,1.89) ; v2(82.79,36.46) 82.8,36.45 JNGFF3.52
CLKREQ_PCIE#8: length 193.7
  TOP w0.109: UH1.AE41 v2(183.84,23.55)
  IN2 w0.081: v2(217.41,15.03) 217.41,15.59 218.18,16.36 250.37,16.36 251.3,17.28 265.47,17.28 268.51,14.24 268.51,13.4 270.09,11.82 270.46,11.82 271.44,10.84 274.01,10.84 278.04,6.82 280.97,6.82 281.51,7.36 284.27,7.36 286.69,4.94 290.18,4.94 291.14,5.9 303.66,5.9 305.44,4.12 308.44,4.12 308.89,4.57 312.63,4.57 313.37,3.84 320.71,3.84 324.03,7.16 325.22,7.16 327.07,9.01 328.63,9.01 329.11,9.49 334.49,9.49 341.01,9.49 344.08,12.55 345.46,12.55 350.15,7.86 JNGFF4.52
  IN3 w0.081: v2(217.41,15.03) 217.41,14.84 217.21,14.64 210.3,14.64 209.66,15.28 198.57,15.28 197.86,14.58 196.39,14.58 196.01,14.19 188.54,14.19 187.15,12.8 v2(185.58,12.8)
  BOTTOM w0.109: v2(185.58,12.8) 185.58,14.22 v1(185.23,14.57) 185.23,14.74 184.93,15.04 184.93,15.61 184.75,15.79 184.75,16.38 184.48,16.65 RH132.1 183.72,17.05 183.72,18.62 183.59,18.76 183.59,20.73 183.45,20.87 183.45,21.42 183.84,21.8 v2(183.84,23.55)
CLKREQ_PCIE#9: length 150.9
  TOP w0.109: UH1.AF48 183.76,19.06 183.78,19.04 183.78,17.63 184.49,16.91 RH133.1 184.49,16.57 184.86,16.2 184.86,15.74 185.14,15.47 185.14,14.36 184.88,14.11 182.99,14.11 181.45,12.56 179.2,12.56 175.89,9.25 175.89,8.67 175.34,8.12 175.34,4.83 175.62,4.55 v2(175.62,2.99) 175.62,2.4 v1(175,1.78)
  IN3 w0.081: v2(175.62,2.99) 175.84,2.77 175.84,1.66 175.54,1.36 172.18,1.36 171.25,2.29 171.25,4.46 169.71,5.99 167.56,5.99 166.01,4.44 166.01,2.07 165.16,1.23 76.13,1.23 75.76,1.6 v2(75.76,2.14)
  BOTTOM w0.109: JNGFF5.52 81.21,11.4 80.47,10.66 80.47,4.51 79.45,3.5 76.08,3.5 75.76,3.18 v2(75.76,2.14)
CLKREQ_PCIE#10: length 7.3
  TOP w0.109: UH1.AC41 185.53,23.51 185.16,23.14 185.16,20.78 185.24,20.7 185.24,19 185.48,18.76 v2(185.48,17.41)
  BOTTOM w0.109: v2(185.48,17.41) 185.11,17.05 RH134.1
CLKREQ_PEG#0: length 110.3
  TOP w0.102: 165.76,27.71 165.77,27.72 166.85,27.72 167.76,28.63 171.28,28.63 171.29,28.64 171.3,28.64 171.39,28.74 174.19,28.74 174.26,28.67 UH1.BF31
  TOP w0.109: v2(164.17,26.75) 164.17,27.15 164.73,27.71 165.76,27.71 ; QV42.1 v2(187.27,93.59)
  IN3 w0.081: v2(158.92,50.18) 158.98,50.13 160.57,50.13 180.93,70.48 180.93,74.53 179.81,75.65 179.81,78.29 182.75,81.23 183.53,81.23 185.39,83.08 185.39,84.44 186.83,85.88 186.83,88.65 187.67,89.5 187.67,92.16 187.27,92.55 v2(187.27,93.59) ; v2(164.17,26.75) 163.48,26.75 161.8,25.06 160.75,25.06 160.49,25.33 160.49,26.89 161.34,27.74 161.34,32.57 160.59,33.32 159.65,33.32 159.25,33.72 159.25,39.31 156.77,41.79 154.51,41.79 153.63,42.66 v2(153.05,42.66)
  BOTTOM w0.102: v2(164.17,26.75) 163.93,26.51 RH123.1
  BOTTOM w0.109: v2(158.92,50.18) 158.92,49.04 158.02,48.14 158.02,46.59 154.81,43.39 v1(154.26,43.39) 153.78,43.39 v2(153.05,42.66)
CLKRUN#: length 1.5
  TOP w0.089: UH1.AV32 178.27,28.63 v2(177.97,28.93)
  BOTTOM w0.109: v2(177.97,28.93) 177.84,28.79 T318.1
CMPIN: length 3.6
  TOP w0.203: PU700.13 284.94,29.5 284.45,29 284.45,28.46 284.06,28.08 PR730.1 PR729.1
CMPOUT: length 260.8
  TOP w0.109: v2(253.42,8.73) 252.91,9.24 252.91,9.77 262.47,19.33 266,19.33 266.28,19.61 271.11,19.61 v2(272.52,18.2) ; v2(65.61,3.23) 65.34,2.97 65.34,2.61 65.05,2.31 JIO1.2
  TOP w0.203: PU700.14 285.22,29.1 284.91,28.8 v2(284.91,28.58)
  IN1 w0.102: v2(65.61,3.23) 66.78,3.23 69.96,6.41 71,6.97 73.02,6.97 75.45,4.54 77.78,4.54 81.04,1.27 114.09,1.27 117.3,4.48 120.32,4.48 120.66,4.81 121.42,4.81 122.92,6.32 124.16,6.32 124.5,5.98 125.31,5.98 125.89,6.57 126.33,6.57 127.4,5.5 127.4,4.35 128.1,3.65 129.66,3.65 130.05,3.26 130.05,2.94 131.01,1.98 137.96,1.98 139.27,3.29 139.27,6.14 140.75,7.62 141.26,7.62 141.85,8.22 141.85,9.33 142.18,9.66 143.39,9.66 144.03,10.29 148.16,10.29 148.97,9.48 155.64,9.48 156.21,10.05 157.54,10.05 161.11,6.49 164.79,6.49 165.82,7.52 169.59,7.52 173.43,3.68 177,3.68 178.68,2.01 189.5,2.01 190.87,3.37 192.15,3.37 192.22,3.44 197.73,3.44 199.12,4.83 204.49,4.83 205.28,4.04 209.64,4.04 210.33,4.72 210.33,8.93 210.81,9.42 215.88,9.42 217.2,10.73 219.32,10.73 219.87,11.28 228.07,11.28 228.62,10.73 236.84,10.73 238.26,9.31 252.84,9.31 v2(253.42,8.73) ; v2(284.91,28.58) 283.26,26.92 283.26,25.94 275.97,18.65 272.97,18.65 v2(272.52,18.2)
CNV_BRI_PRX_DTX: length 199.9
  TOP w0.089: UH1.AY2 177.07,42.68 177.07,44.42 176.34,45.15 176.34,45.57 175.98,45.93 175.22,45.93 174.93,45.65 173.18,45.65 171.71,47.11
  TOP w0.102: 171.71,47.11 v2(171.71,47.48)
  TOP w0.109: v2(320.02,15.16) 320.02,15.89 v1(319.94,15.97)
  IN1 w0.102: v2(320.02,15.16) 320.02,14.63 319.38,13.98 318.9,13.98 317.53,12.61 317.53,10.75 317.31,10.53 315.74,10.53 315.32,10.95 312.55,10.95 311.33,12.18 299.96,12.18 298.34,13.79 295.79,13.79 293.69,11.69 291.45,11.69 290.37,12.77 289.55,12.77 284.99,17.33 281.33,17.33 280.27,18.38 277.64,18.38 276.2,16.94 274.96,16.94 274.23,16.21 274.23,15.87 273.79,15.42 267.68,15.42 261.54,21.56 259.27,21.56 255.99,24.84 235.95,24.84 234.62,23.51 v2(234.62,22.11)
  IN3 w0.081: v2(171.71,47.48) 171.71,45.87 174.04,43.55 176.21,43.55 176.53,43.87 179.49,43.87 179.71,44.09 183.39,44.09 184.76,45.46 187.49,45.46 188.32,46.29 194.74,46.29 195.27,45.77 195.27,44.71 196.5,43.48 196.9,43.48 197.31,43.07 197.31,42.77 198.6,41.47 198.6,40.32 198.99,39.94 198.99,39.08 198.48,38.57 198.48,37.14 199.72,35.89 199.72,34.24 200.71,33.24 203.11,33.24 203.72,32.63 205.42,32.63 210.43,27.62 211.78,27.62 213.96,25.43 231.3,25.43 v2(234.62,22.11)
  BOTTOM w0.109: RZ533.2 321.11,21.09 320.66,20.64 320.66,19.2 320.22,18.75 320.22,15.36 v2(320.02,15.16) ; RH614.2 171.71,47.82 v2(171.71,47.48)
CNV_BRI_PTX_DRX: length 201.4
  TOP w0.089: v2(173.68,47.1) 174.19,46.59 175.81,46.59 176.7,45.7 176.7,45.53 176.72,45.52 176.72,45.48 177.75,44.45 177.75,43.75 178.02,43.48 178.02,42.7 178.05,42.67 178.05,42.33 177.97,42.25 177.97,41.81 UH1.AV4
  IN1 w0.102: v2(235.28,22.1) 235.28,23.02 236.87,24.61 255.9,24.61 259.17,21.33 261.43,21.33 267.79,14.98 275.69,14.98 277.16,16.44 279.52,16.44 280.1,17.03 284.97,17.03 289.46,12.54 290.27,12.54 291.35,11.46 293.78,11.46 295.88,13.56 298.25,13.56 299.86,11.95 311.23,11.95 312.5,10.69 315.26,10.69 315.64,10.3 317.54,10.3 317.76,10.52 317.76,11.35 v2(318.19,11.78)
  IN3 w0.081: v2(235.28,22.1) 231.72,25.66 214.92,25.66 213.27,27.31 212.41,27.31 211.87,27.85 210.53,27.85 205.51,32.86 203.91,32.86 203.24,33.53 201.17,33.53 200.04,34.66 200.04,35.9 198.71,37.23 198.71,38.48 199.22,38.99 199.22,40.03 198.83,40.41 198.83,41.57 197.54,42.86 197.54,43.17 197,43.71 196.59,43.71 195.51,44.8 195.51,45.9 194.89,46.52 188.23,46.52 187.39,45.69 184.66,45.69 183.29,44.31 179.61,44.31 179.41,44.12 176.53,44.12 176.13,44.52 174.93,44.52 173.68,45.77 v2(173.68,47.1)
  BOTTOM w0.109: RH603.1 RH604.2 174.22,47.64 v2(173.68,47.1) ; RZ536.2 324.99,20.93 v1(324.11,20.93) 322.97,22.07 320.49,22.07 319.96,21.54 319.96,19.53 319.48,19.05 319.48,16.19 318.62,15.33 318.62,15.1 317.77,14.26 317.77,12.09 318.08,11.78 v2(318.19,11.78)
CNV_COEX1: length 181.8
  TOP w0.102: UH1.AU9 v2(177.99,39.31)
  TOP w0.109: RZ373.2 319.84,1.95 319.46,1.57 v1(318.49,1.57) 318.25,1.81 v2(318.25,2.59)
  IN2 w0.081: v2(314.73,5.2) 313.55,5.2 313.14,5.61 309.22,5.61 308.92,5.91 307.01,5.91 305.83,7.09 290.68,7.09 289.67,6.08 287.82,6.08 287.21,6.7 287.21,7.37 285.92,8.65 282.79,8.65 281.46,9.99 278.31,9.99 273.22,15.08 270.23,15.08 269.02,16.28 269.02,17.34 267.74,18.62 265.09,18.62 263.69,20.02 246.26,20.02 244.13,17.89 228.27,17.89 227.75,18.4 217.86,18.4 215.58,16.12 v2(215.58,15.04)
  IN4 w0.102: v2(177.99,39.31) 178.24,39.31 179.15,38.4 179.15,38.14 179.4,37.89 179.4,36.16 178.48,35.24 178.48,33.89 178.74,33.63 178.74,30.12 179.71,29.15 179.71,28.61 179.99,28.33 180.37,28.33 181.81,26.89 181.81,24.07 182.08,23.8 182.23,23.8 185.42,20.61 193.9,20.61 194.51,21.22 198.59,21.22 199.32,20.49 202.16,20.49 202.52,20.13 202.52,19.69 203.58,18.62 204.92,18.62 205.36,18.18 210.57,18.18 212.13,16.62 214.87,16.62 215.58,15.92 v2(215.58,15.04)
  BOTTOM w0.102: v2(177.99,39.31) 178.19,39.51 178.19,40.83 178.09,40.93 178.09,41.66 177.42,42.33 177.42,42.65 176.98,43.09 176.98,43.43 RH608.1
  BOTTOM w0.109: RH607.2 RH608.1 ; v2(318.25,2.59) 318.25,2.59 318.25,3.99 317.85,4.39 315.59,4.39 314.78,5.2 v2(314.73,5.2)
CNV_COEX2: length 187.1
  TOP w0.089: v2(177.61,43.33) 177.83,43.12 UH1.AW2
  TOP w0.109: v2(318.71,5.64) 318.71,6.74 319.12,7.16 RZ372.2
  IN2 w0.081: v2(318.71,5.64) 318.32,6.03 315.38,6.03 314.39,7.02 313.29,7.02 312.42,6.14 307.1,6.14 305.92,7.32 290.59,7.32 289.58,6.31 287.94,6.31 287.43,6.82 287.43,7.46 286.02,8.88 282.89,8.88 281.55,10.22 278.38,10.22 273.31,15.28 272.51,15.28 270.51,17.29 269.41,17.29 267.85,18.85 265.18,18.85 263.78,20.25 246.16,20.25 244.03,18.12 228.41,18.12 227.9,18.63 217.64,18.63 214.87,15.86 214.87,15.18 v2(214.99,15.07)
  IN4 w0.102: v2(214.99,15.07) 214.99,15.59 214.18,16.39 211.99,16.39 210.6,17.78 204.5,17.78 204.08,18.2 203.68,18.2 202.55,19.33 200.97,19.33 200.05,20.26 199.23,20.26 198.5,20.99 194.6,20.99 193.99,20.38 183.69,20.38 182.98,21.08 181.38,21.08 181.17,21.3 181.17,22.9 181.58,23.31 181.58,24.15 181.36,24.37 181.06,24.37 180.52,24.91 180.52,26.81 180.17,27.16 180.17,27.68 179.75,28.1 179.18,28.1 178.93,28.35 178.93,29.44 178.51,29.86 176.95,29.86 176.44,29.35 175.24,29.35 174.87,29.72 174.87,30.53 175.35,31.01 176.28,31.01 177.05,31.78 177.33,31.78 177.72,32.17 177.72,35.76 176.96,36.52 176.51,36.52 175.61,37.41 175.61,38.82 176.65,39.86 176.65,41.2 176.52,41.33 176.52,42.25 v2(177.61,43.33)
CNV_COEX3: length 174.3
  TOP w0.089: UH1.AV6 v2(177.31,40.7)
  TOP w0.109: v2(317.49,5.47) 317.49,5.26 317.91,4.84 319.09,4.84 RZ374.2
  IN2 w0.081: v2(216.2,15.06) 216.2,16.34 217.8,17.94 227.8,17.94 228.43,17.31 243.87,17.31 246.35,19.79 263.59,19.79 265,18.39 266.02,18.39 268.13,16.27 268.71,16.27 270.14,14.85 273.16,14.85 278.97,9.04 280.85,9.04 281.44,8.44 285.69,8.44 286.98,7.16 286.98,6.53 287.66,5.85 289.77,5.85 290.77,6.85 305.74,6.85 306.91,5.68 308.85,5.68 309.13,5.4 313.05,5.4 313.65,4.81 316.82,4.81 v2(317.49,5.47)
  IN4 w0.102: v2(216.2,15.06) 216.2,16.08 215.43,16.85 212.35,16.85 210.8,18.41 205.57,18.41 205,18.97 203.55,18.97 202.75,19.78 202.75,20.22 202.25,20.71 199.42,20.71 198.68,21.45 194.41,21.45 193.8,20.84 185.52,20.84 182.89,23.48 182.89,26.44 182.49,26.83 182.31,26.83 181.15,28 181.15,29.05 180.19,30.01 180.19,32.78 181.26,33.85 181.26,35.35 180.85,35.76 179.87,35.76 179.59,36.04 179.59,38.03 179.38,38.23 179.38,38.78 177.47,40.7 v2(177.31,40.7)
CNV_PRX_DTX_N0: length 209.4
  TOP w0.076: v2(174.62,44.2) 174.62,43.89 174.73,43.77 175.1,43.77 175.19,43.69 175.41,43.69 175.81,43.3 175.81,43.08 175.64,42.91 UH1.BB3
  IN4 w0.102: v2(249.8,5.06) 249.58,4.84 249.58,4.73 249.37,4.52 247.4,4.52 246.01,5.91 243.95,5.91 238.64,11.21 238.64,12.57 237.58,13.63 230.38,13.63 229.88,14.13 220.08,14.13 218.56,12.61 209.58,12.61 207.68,14.51 199.65,14.51 198.24,15.93 192.15,15.93 191.3,15.08 189.59,15.08 189.03,14.52 187.37,14.52 186.92,14.97 186.92,15.42 186.71,15.63 183.52,15.63 182.46,16.69 181.08,16.69 180.21,17.57 179.94,17.57 178.56,18.94 176.95,18.94 176.86,19.03 174.68,19.03 172.69,21.03 172.69,21.5 172.45,21.74 172.45,23.57 173.68,24.8 173.68,27.07 171.45,29.31 171.45,31.35 173.93,33.83 173.93,35.37 173.53,35.77 173.53,39.76 172.8,40.49 172.8,41.76 174.78,43.73 174.78,44.03 v2(174.62,44.2)
  BOTTOM w0.109: RZ527.1 310.12,8.92 309.47,8.92 309.32,9.07 308.24,9.07 306.99,7.82 306.17,7.82 305.99,8 305.99,8.25 305.68,8.55 305.25,8.55 304.94,8.25 304.94,8 304.76,7.82 304.51,7.82 304.32,8 304.32,8.31 304.15,8.49 303.5,8.49 303.28,8.26 303.28,8 303.09,7.82 293.77,7.82 293.59,8 293.59,8.52 293.28,8.83 292.85,8.83 292.54,8.52 292.54,8 292.36,7.82 292.1,7.82 291.92,8 291.92,8.52 291.62,8.83 291.18,8.83 290.87,8.52 290.87,8 290.69,7.82 290.49,7.82 289.53,8.78 288.28,8.78 287.57,8.07 287.57,7.18 287.34,6.95 286.93,6.95 286.15,6.18 285.98,6.18 285.76,5.95 285.74,5.95 285.11,5.33 285.11,5.31 284.3,4.49 282.23,4.49 281.76,4.02 281.53,4.02 281.35,4.2 281.35,4.58 281.04,4.89 280.6,4.89 280.3,4.58 280.3,4.2 280.12,4.02 279.9,4.02 279.44,4.48 278.2,4.48 277.79,4.89 277.79,6.13 278.33,6.67 278.33,11.11 278.07,11.37 277.29,11.37 276.9,10.98 276.9,9.75 276.5,9.35 275.8,9.35 275.49,9.04 275.49,8.6 275.8,8.3 277.15,8.3 277.34,8.11 277.34,7.77 277.16,7.6 276.5,7.6 276.2,7.29 276.2,6.85 276.5,6.55 276.74,6.55 276.81,6.48 276.81,4.73 276.63,4.55 275.84,4.55 275.12,3.83 268.69,3.83 268.51,4.01 268.51,4.53 268.2,4.84 267.77,4.84 267.46,4.53 267.46,4.01 267.28,3.83 266.88,3.83 265.92,4.79 258.06,4.79 256.72,3.44 250.3,3.44 249.29,4.45 249.29,4.88 249.47,5.06 v2(249.8,5.06)
CNV_PRX_DTX_N1: length 209.2
  TOP w0.109: v2(169.33,46.05) 169.56,46.05 169.67,45.94 171.63,45.94 172.87,44.7 174.91,44.7 175.03,44.58 175.81,44.58 176.15,44.23 176.15,42.59 176.36,42.38 UH1.BA3
  IN4 w0.102: v2(251.32,4.73) 251.11,4.51 251.11,4.04 250.78,3.72 245.7,3.72 245.41,4 245.41,4.3 245.79,4.68 245.79,4.93 245.61,5.11 245.36,5.11 244.97,4.72 244.56,4.72 244.26,5.02 243.7,5.02 237.84,10.88 237.84,12.23 237.1,12.96 229.5,12.96 229.13,13.34 220.41,13.34 218.86,11.78 209.28,11.78 207.41,13.66 205.74,13.66 205.04,12.96 200.72,12.96 200.12,13.56 198.96,13.56 198.11,14.41 191.93,14.41 190.6,13.07 186.83,13.07 186.12,13.79 184.16,13.79 182.38,15.57 180.83,15.57 180.08,16.32 178.66,16.32 177.18,17.79 174.86,17.79 174.68,17.97 174.43,17.97 174.05,18.34 173.46,18.34 172.77,19.03 172.77,19.4 172.08,20.09 171.66,20.09 171.26,20.48 171.26,21.11 171.57,21.42 171.57,23.98 172.68,25.09 172.68,25.35 171.31,26.73 171.31,28.28 170.62,28.97 170.62,31.65 171.77,32.8 171.77,33.44 171.16,34.05 171.16,34.69 172.22,35.75 172.22,36.43 172.51,36.72 172.73,36.72 172.91,36.9 172.91,37.15 172.73,37.33 172.51,37.33 172.22,37.62 172.22,38.66 172.72,39.16 172.72,39.7 172.2,40.22 172.2,42.14 172.41,42.35 172.41,46.46 172.26,46.61 171.74,46.61 171.57,46.43 171.57,44.75 171.28,44.46 170.77,44.46 170.48,44.75 170.48,45.56 170.3,45.74 169.87,45.74 169.56,46.05 v2(169.33,46.05)
  BOTTOM w0.109: RZ529.1 310.53,11.53 310.45,11.45 310.24,11.45 309.68,12.01 299.86,12.01 298.41,13.46 293.87,13.46 293.09,14.23 288.22,14.23 287.07,13.09 284.44,13.09 284.43,13.1 283.77,13.1 283.75,13.09 277.44,13.09 274.39,10.03 274.39,5.39 273.54,4.54 269.8,4.54 268.67,5.68 266.66,5.68 266.56,5.77 266.56,6.02 266.27,6.3 265.87,6.3 265.58,6.02 265.58,5.64 265.42,5.48 257.74,5.48 256.42,4.16 251.09,4.16 251.02,4.23 251.02,4.42 v2(251.32,4.73)
CNV_PRX_DTX_P0: length 209.4
  TOP w0.076: UH1.BB4 175.82,42.51 175.96,42.65 175.96,43.36 175.48,43.84 175.25,43.84 175.2,43.89 175.2,44.15 v2(175.2,44.15)
  IN4 w0.102: v2(175.2,44.15) 174.97,43.92 174.97,43.65 172.99,41.68 172.99,40.57 173.72,39.84 173.72,35.85 174.12,35.44 174.12,33.75 171.63,31.27 171.63,29.39 173.87,27.15 173.87,24.73 172.63,23.49 172.63,21.82 172.87,21.58 172.87,21.11 174.76,19.22 176.93,19.22 177.03,19.13 178.64,19.13 180.01,17.76 180.29,17.76 181.16,16.88 182.54,16.88 183.6,15.82 186.79,15.82 187.11,15.5 187.11,15.05 187.45,14.71 188.96,14.71 189.51,15.26 191.22,15.26 192.07,16.11 198.32,16.11 199.73,14.7 207.76,14.7 209.66,12.8 218.48,12.8 220,14.32 229.96,14.32 230.46,13.82 237.66,13.82 238.83,12.65 238.83,11.29 244.03,6.09 246.08,6.09 247.47,4.7 249.29,4.7 249.39,4.8 249.39,5.14 249.29,5.24 249.08,5.24 v2(248.88,5.03)
  BOTTOM w0.109: RZ528.1 310.17,8.71 309.38,8.71 309.24,8.85 308.33,8.85 307.08,7.6 306.08,7.6 305.77,7.91 305.77,8.16 305.59,8.34 305.34,8.34 305.16,8.16 305.16,7.91 304.85,7.6 304.42,7.6 304.11,7.91 304.11,8.22 304.06,8.27 303.59,8.27 303.49,8.17 303.49,7.91 303.18,7.6 293.68,7.6 293.37,7.91 293.37,8.43 293.19,8.61 292.94,8.61 292.76,8.43 292.76,7.91 292.45,7.6 292.01,7.6 291.71,7.91 291.71,8.43 291.53,8.61 291.27,8.61 291.09,8.43 291.09,7.91 290.78,7.6 290.4,7.6 289.44,8.57 288.37,8.57 287.78,7.98 287.78,7.09 287.43,6.74 287.02,6.74 286.24,5.96 286.07,5.96 v4(285.52,5.41) 284.39,4.28 282.32,4.28 281.85,3.8 281.44,3.8 281.13,4.11 281.13,4.49 280.95,4.67 280.69,4.67 280.51,4.49 280.51,4.11 280.21,3.8 279.81,3.8 279.35,4.26 278.11,4.26 277.57,4.8 277.57,6.22 278.12,6.76 278.12,11.02 277.98,11.16 277.38,11.16 277.12,10.89 277.12,9.66 276.59,9.13 275.89,9.13 275.71,8.95 275.71,8.69 275.89,8.51 277.24,8.51 277.55,8.2 277.55,7.68 277.25,7.38 276.59,7.38 276.41,7.2 276.41,6.94 276.59,6.76 276.83,6.76 277.03,6.57 277.03,4.64 276.72,4.34 275.93,4.34 275.21,3.61 268.6,3.61 268.29,3.92 268.29,4.44 268.11,4.62 267.86,4.62 267.67,4.44 267.67,3.92 267.37,3.61 266.79,3.61 265.83,4.57 258.15,4.57 256.8,3.23 250.21,3.23 249.07,4.36 249.07,4.84 v2(248.88,5.03)
CNV_PRX_DTX_P1: length 209.3
  TOP w0.109: v2(169.77,46.66) 169.56,46.46 169.56,46.36 169.76,46.15 171.72,46.15 172.96,44.91 175,44.91 175.11,44.79 175.9,44.79 176.37,44.32 176.37,42.94 176.42,42.89 UH1.BA2
  IN4 w0.102: v2(169.77,46.66) 169.77,46.12 169.95,45.93 170.38,45.93 170.66,45.64 170.66,44.82 170.84,44.64 171.2,44.64 171.38,44.82 171.38,46.51 171.67,46.8 172.34,46.8 172.6,46.54 172.6,42.27 172.39,42.07 172.39,40.3 172.91,39.78 172.91,39.08 172.41,38.58 172.41,37.69 172.59,37.52 172.81,37.52 173.1,37.23 173.1,36.82 172.81,36.53 172.59,36.53 172.41,36.35 172.41,35.67 171.35,34.61 171.35,34.13 171.96,33.52 171.96,32.72 170.81,31.57 170.81,29.05 171.49,28.36 171.49,26.81 172.87,25.43 172.87,25.01 171.76,23.9 171.76,21.34 171.45,21.04 171.45,20.56 171.74,20.28 172.16,20.28 172.96,19.48 172.96,19.11 173.54,18.53 174.13,18.53 174.51,18.16 174.76,18.16 174.93,17.98 177.26,17.98 178.73,16.5 180.16,16.5 180.91,15.76 182.46,15.76 184.24,13.97 186.2,13.97 186.91,13.26 190.52,13.26 191.86,14.59 198.19,14.59 199.04,13.74 200.19,13.74 200.79,13.14 204.96,13.14 205.67,13.85 207.49,13.85 209.36,11.97 218.78,11.97 220.33,13.52 229.2,13.52 229.58,13.15 237.18,13.15 238.03,12.3 238.03,10.96 243.78,5.21 244.34,5.21 244.64,4.91 244.89,4.91 245.28,5.3 245.69,5.3 245.98,5.01 245.98,4.6 245.6,4.22 245.6,4.08 245.77,3.91 250.7,3.91 250.92,4.12 250.92,4.6 250.79,4.73 v2(250.51,4.73)
  BOTTOM w0.109: RZ530.1 310.39,11.23 310.15,11.23 309.59,11.79 299.77,11.79 298.32,13.24 293.78,13.24 293,14.02 288.31,14.02 287.16,12.87 v4(284.05,12.87) 277.53,12.87 274.6,9.94 274.6,5.3 273.63,4.33 269.71,4.33 268.58,5.46 266.57,5.46 266.34,5.68 266.34,5.93 266.18,6.09 265.96,6.09 265.8,5.93 265.8,5.55 265.51,5.26 257.83,5.26 256.51,3.94 251,3.94 250.8,4.14 250.8,4.44 v2(250.51,4.73)
CNV_PTX_C_DRX_N0: length 3.3
  BOTTOM w0.109: CZ537.2 333.44,7.42 333.44,7.64 333.02,8.06 333.02,9.1 332.9,9.22 JNGFF1.57
CNV_PTX_C_DRX_N1: length 2.9
  BOTTOM w0.109: JNGFF1.51 331.4,9.16 331.64,8.92 331.64,7.6 CZ539.2
CNV_PTX_C_DRX_P0: length 3.3
  BOTTOM w0.109: JNGFF1.59 333.4,9.23 333.24,9.07 333.24,8.15 333.66,7.73 333.66,7.42 CZ536.2
CNV_PTX_C_DRX_P1: length 2.9
  BOTTOM w0.109: JNGFF1.53 331.9,9.05 331.85,9 331.85,7.62 CZ538.2
CNV_PTX_DRX_N0: length 235
  TOP w0.109: v2(167.38,44.61) 167.17,44.61 167.1,44.53 167.1,44.3 167.5,43.89 169.33,43.89 170.41,42.81 171.02,42.81 173.48,40.35 174.54,40.35 174.59,40.41 UH1.BE6
  IN4 w0.102: v2(167.38,44.61) 167.38,44.25 167.67,43.96 168.06,43.96 169,43.02 169,42.61 166.14,39.75 165.26,39.75 164.61,39.1 164.61,38.85 165.24,38.23 165.24,37.82 164.95,37.53 164.54,37.53 163.92,38.15 163.66,38.15 162.11,36.6 162.11,33.28 162,33.17 162,31.6 164.57,29.03 164.57,27.78 163.74,26.95 163.74,26.58 164,26.32 164.59,26.32 165.89,25.02 165.89,24.01 166.44,23.46 166.44,21.87 167.55,20.76 169.24,20.76 170.56,19.44 170.56,19.12 171.26,18.42 171.96,18.42 173.08,17.31 173.68,17.31 174.05,16.93 174.3,16.93 174.44,16.79 176.73,16.79 178.94,14.58 178.94,13.86 179.58,13.22 182.17,13.22 183.06,12.33 185.77,12.33 186.64,11.46 191.46,11.46 191.56,11.56 191.56,12.58 191.99,13.02 192.7,13.02 193.08,12.64 193.08,11.86 193.26,11.68 193.68,11.68 193.83,11.84 193.83,13.05 194.13,13.35 196.62,13.35 197.49,12.48 199.34,12.48 202.08,9.75 203.89,9.75 204.43,10.29 206.83,10.29 207.35,9.77 209.21,9.77 209.81,10.37 218.86,10.37 220.68,12.19 228.86,12.19 229.58,11.46 236.18,11.46 236.77,10.88 236.77,10.54 242.67,4.64 242.67,3.45 v2(242.95,3.17)
  BOTTOM w0.109: CZ537.1 333.44,6.17 333.44,6.05 333.19,5.8 332.48,5.8 331.97,5.65 331.61,5.48 331.61,5.49 331.24,5.32 326.86,5.32 326.16,4.62 321.88,4.62 318.75,1.49 314.61,1.49 313.44,2.67 311.26,2.67 310.33,3.6 310.33,4.74 309.79,5.28 301.88,5.28 301.26,5.9 295.19,5.9 294.31,5.02 287.69,5.02 285.21,2.54 283.62,2.54 282.59,1.51 260.52,1.51 259.38,2.65 258.83,2.65 257.69,1.52 243.48,1.52 242.53,2.46 242.53,3.33 242.66,3.46 242.86,3.46 242.95,3.37 v2(242.95,3.17)
CNV_PTX_DRX_N1: length 235
  TOP w0.109: UH1.BG6 173.59,40.85 173.27,40.85 171.15,42.97 171.15,43.25 170.98,43.41 170.8,43.41 170.7,43.31 v2(170.7,43.18)
  IN4 w0.102: v2(170.7,43.18) 170.73,43.18 170.88,43.34 170.88,43.51 170.79,43.61 170.41,43.61 170.23,43.42 170.23,42.86 170.37,42.71 170.37,40.61 170.13,40.37 169.42,40.37 164.96,35.91 164.96,34.28 163.78,33.09 163.78,31.23 165.17,29.84 165.17,27.99 166.2,26.95 166.2,25.89 167.31,24.78 167.31,23.87 167.54,23.65 167.54,23 167.24,22.7 167.24,21.93 167.82,21.35 169.49,21.35 171.16,19.68 171.88,19.68 172.36,19.21 172.36,18.86 173.32,17.91 173.91,17.91 174.3,17.53 174.55,17.53 174.69,17.39 177.01,17.39 178.49,15.91 179.48,15.91 180.19,15.19 180.19,15.01 180.55,14.66 182.07,14.66 183.34,13.39 185.87,13.39 186.6,12.67 190.8,12.67 192.1,13.97 196.87,13.97 197.75,13.09 199.76,13.09 202.35,10.5 203.75,10.5 204.99,11.74 204.99,12.29 205.91,13.21 207.29,13.21 209.12,11.38 219.03,11.38 220.51,12.86 229.02,12.86 229.8,12.08 236.43,12.08 237.36,11.16 237.36,10.79 243.64,4.51 243.96,4.51 244.54,3.94 244.54,3.38 244.72,3.2 v2(245.05,3.2)
  BOTTOM w0.109: v2(245.05,3.2) 244.82,3.43 244.69,3.43 244.59,3.33 244.59,2.31 244.76,2.15 245.1,2.15 245.23,2.27 245.23,2.48 245.54,2.78 245.97,2.78 246.28,2.48 246.28,2.33 246.46,2.15 257.31,2.15 258.69,3.53 260.26,3.53 260.56,3.22 260.56,2.38 260.74,2.19 261,2.19 261.18,2.38 261.18,3.22 261.49,3.53 261.92,3.53 262.23,3.22 262.23,2.38 262.41,2.19 262.66,2.19 262.85,2.38 262.85,3.22 263.15,3.53 263.59,3.53 263.89,3.22 263.89,2.38 264.08,2.19 264.33,2.19 264.51,2.38 264.51,3.22 264.82,3.53 265.26,3.53 266.22,2.57 273.14,2.57 273.55,2.16 273.87,2.16 274.28,2.57 274.86,2.57 275.27,2.15 276,2.15 276.41,2.57 277.26,2.57 277.68,2.15 282.33,2.15 283.36,3.17 284.95,3.17 285.6,3.82 285.6,3.85 286.2,4.45 286.22,4.45 286.22,4.45 287.43,5.66 289.64,5.66 290.52,6.54 291.47,6.54 291.89,6.12 292.22,6.12 292.63,6.54 293.39,6.54 293.8,6.12 294.22,6.12 294.63,6.54 302.17,6.54 302.47,6.23 302.47,6.11 302.65,5.92 302.91,5.92 303.09,6.11 303.09,6.23 303.4,6.54 303.83,6.54 304.14,6.23 304.14,6.11 304.32,5.92 304.58,5.92 304.76,6.11 304.76,6.23 305.06,6.54 305.74,6.54 306.36,5.92 310.19,5.92 311.34,4.77 312.75,4.77 313.06,4.47 313.06,3.48 313.24,3.3 313.49,3.3 313.68,3.48 313.68,4.5 313.95,4.77 314.51,4.77 314.78,4.5 314.78,3.93 314.89,3.83 315.21,3.83 315.37,3.98 316.69,3.98 316.94,3.73 316.94,3.29 316.69,3.04 315.66,3.04 315.39,2.77 315.39,2.34 315.6,2.13 318.39,2.13 321.52,5.26 325.81,5.26 326.51,5.96 330.92,5.96 331.14,6.18 331.39,6.18 331.52,6.3 331.52,6.48 CZ539.1
CNV_PTX_DRX_P0: length 235
  TOP w0.109: UH1.BD7 174.81,40.31 174.63,40.13 173.39,40.13 170.93,42.6 170.32,42.6 169.24,43.68 167.41,43.68 167.24,43.85 v2(166.92,43.85)
  IN4 w0.102: v2(242.08,3.2) 242.31,3.2 242.48,3.38 242.48,4.56 236.58,10.46 236.58,10.8 236.1,11.28 229.5,11.28 228.78,12 220.76,12 218.94,10.18 209.88,10.18 209.29,9.58 207.28,9.58 206.76,10.1 204.51,10.1 203.97,9.56 202,9.56 201.92,9.63 199.26,12.3 197.41,12.3 196.55,13.16 194.21,13.16 194.02,12.97 194.02,11.76 193.75,11.5 193.18,11.5 192.89,11.78 192.89,12.56 192.62,12.83 192.07,12.83 191.75,12.51 191.75,11.49 191.54,11.27 186.56,11.27 185.69,12.14 182.98,12.14 182.09,13.03 179.51,13.03 178.75,13.78 178.75,14.5 176.65,16.6 174.36,16.6 174.23,16.74 173.97,16.74 173.6,17.12 173,17.12 171.88,18.23 171.18,18.23 170.37,19.04 170.37,19.36 169.17,20.57 167.47,20.57 166.25,21.79 166.25,23.38 165.7,23.93 165.7,24.94 164.51,26.13 163.93,26.13 163.55,26.51 163.55,27.03 164.38,27.86 164.38,28.95 162.08,31.26 161.82,31.52 161.82,33.25 161.92,33.36 161.92,36.68 163.59,38.34 163.99,38.34 164.62,37.72 164.87,37.72 165.05,37.9 165.05,38.15 164.43,38.77 164.43,39.18 165.18,39.94 166.06,39.94 168.81,42.68 168.81,42.95 167.98,43.77 167.59,43.77 167.36,44 167.07,44 v2(166.92,43.85)
  BOTTOM w0.109: CZ536.1 333.66,6.17 333.66,5.96 333.28,5.58 332.51,5.58 332.05,5.44 331.51,5.21 331.29,5.11 326.95,5.11 326.25,4.4 321.97,4.4 318.84,1.28 314.53,1.28 313.35,2.45 311.17,2.45 310.12,3.51 310.12,4.65 309.7,5.06 301.79,5.06 301.17,5.69 295.28,5.69 294.4,4.81 287.78,4.81 285.3,2.33 283.71,2.33 282.68,1.3 260.43,1.3 259.29,2.44 258.92,2.44 257.78,1.3 243.39,1.3 242.32,2.37 242.32,2.96 v2(242.08,3.2)
