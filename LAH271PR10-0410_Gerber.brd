# Allegro board LAH271PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_CHASSIS: length 2.7
  TOP w0.109: CL22.2 v3(171.72,148.17)
GNDA: length 109.9
  TOP w0.203: UA1.22 346.76,19.52 v2(346.92,19.36)
  TOP w0.305: v2(348.91,27.89) 348.88,27.92 CA8.2 ; CA57.2 347.23,18.45 v2(347.41,18.27)
  TOP w0.381: CA9.2 348.18,29.31 v2(348.18,29.95) ; v2(354.03,24.82) 354.37,24.82 CA25.1 354.42,24.15 v2(354.03,24.15) ; v2(346.88,16.97) 346.88,16.54 CA58.2 346.27,16.63 v2(346.27,17) ; CA2.2 v2(357.05,19.6) ; v2(357.17,20.42) 356.88,20.42 356.35,20.95 CA3.2 ; v2(347.88,17.92) 347.88,17.57 CA52.1 348.47,17.49 v2(348.47,17.93)
  TOP w0.508: v2(359.77,16.69) 359.18,16.11 RA228.2 ; v2(354.05,25.65) RA222.2
  GND1 w0.203: 364.22,22.17 JHP1.8 ; JHP1.8 365.35,22.17 ; JHP1.8 366.48,22.17 ; JHP1.8 364.22,20.83 ; JHP1.8 364.22,21.5 ; JHP1.8 366.48,20.83 ; JHP1.8 366.48,21.5 ; JHP1.8 365.35,20.83 ; 364.22,12.97 JHP1.7 ; JHP1.7 365.35,12.97 ; JHP1.7 366.48,12.3 ; JHP1.7 364.22,12.3 ; JHP1.7 366.48,12.97
  GND2 w0.203: 365.35,20.83 JHP1.8 ; JHP1.8 364.22,22.17 ; JHP1.8 364.22,20.83 ; JHP1.8 366.48,21.5 ; JHP1.8 366.48,22.17 ; JHP1.8 366.48,20.83 ; JHP1.8 364.22,21.5 ; JHP1.8 365.35,22.17 ; JHP1.7 366.48,12.3 ; JHP1.7 366.48,12.97 ; JHP1.7 364.22,12.97 ; JHP1.7 364.22,12.3 ; JHP1.7 365.35,12.97
  GND3 w0.203: JHP1.7 365.35,12.97 ; JHP1.7 366.48,12.3 ; JHP1.7 364.22,12.3 ; JHP1.7 366.48,12.97 ; JHP1.7 364.22,12.97 ; JHP1.8 366.48,21.5 ; JHP1.8 365.35,20.83 ; JHP1.8 366.48,22.17 ; JHP1.8 365.35,22.17 ; JHP1.8 364.22,22.17 ; JHP1.8 364.22,20.83 ; JHP1.8 364.22,21.5 ; JHP1.8 366.48,20.83
  VCC w0.203: JHP1.8 366.48,22.17 ; JHP1.8 366.48,20.83 ; JHP1.8 364.22,20.83 ; JHP1.8 364.22,22.17 ; JHP1.8 365.35,20.83 ; JHP1.8 364.22,21.5 ; JHP1.8 365.35,22.17 ; JHP1.8 366.48,21.5 ; 364.22,12.97 JHP1.7 ; JHP1.7 366.48,12.97 ; JHP1.7 366.48,12.3 ; JHP1.7 364.22,12.3 ; JHP1.7 365.35,12.97
  GND4 w0.203: JHP1.8 365.35,22.17 ; JHP1.8 366.48,22.17 ; JHP1.8 364.22,21.5 ; JHP1.8 365.35,20.83 ; JHP1.8 366.48,20.83 ; JHP1.8 364.22,20.83 ; JHP1.8 364.22,22.17 ; JHP1.8 366.48,21.5 ; 364.22,12.3 JHP1.7 ; JHP1.7 365.35,12.97 ; JHP1.7 364.22,12.97 ; JHP1.7 366.48,12.97 ; JHP1.7 366.48,12.3
  GND5 w0.203: 365.35,20.83 JHP1.8 ; JHP1.8 365.35,22.17 ; JHP1.8 364.22,22.17 ; JHP1.8 366.48,22.17 ; JHP1.8 366.48,21.5 ; JHP1.8 364.22,20.83 ; JHP1.8 366.48,20.83 ; JHP1.8 364.22,21.5 ; 364.22,12.97 JHP1.7 ; JHP1.7 366.48,12.3 ; JHP1.7 364.22,12.3 ; JHP1.7 365.35,12.97 ; JHP1.7 366.48,12.97
  BOTTOM w0.109: v3(348.22,19) 347.88,18.66 v2(347.88,17.92) ; v2(346.92,19.36) v3(346.92,20.26) ; v2(354.03,24.82) v3(353.44,24.82)
  BOTTOM w0.381: CA35.1 348.48,27.46 v2(348.91,27.89) ; RA221.2 348.08,17.22 347.88,17.42 v2(347.88,17.92) ; CA225.2 352.04,20.23 CA224.2 353.89,21.16 v2(354.65,21.93)
  BOTTOM w0.457: v2(349.6,23.69) 348.53,23.69 RA227.2
  vias: v2(347.59,29.96) v2(348.77,29.94) v2(349.13,26.84) v2(349.13,26.26) v2(349.23,29.47) v2(353.26,19.52) v2(353.84,19.31) v2(355.22,23.65) v2(355.36,22.83) v2(359.62,21.99) v2(360.29,21.99) v2(360.94,21.99)
GNDA_CHG: length 4
  TOP w0.381: PC718.1 288.19,26.35 v2(288.55,26.71) ; PC720.2 v2(285.55,26.19)
  TOP w0.508: PR709.2 v2(284.97,34.13) ; PC709.2 287.55,35.89 v2(287.6,35.84) PR716.2
  vias: v2(282.69,33.94) v2(282.7,35.74) v2(283.4,35.15) v2(283.39,34.53) v2(283.33,33.94) v2(286.4,31.37) v2(286.4,29.23) v2(287.47,30.3) v2(288.53,31.37) v2(288.53,29.23) v3(284.48,30.79)
VBUS1_ECOK: length 93.6
  TOP w0.109: UE1.M6 133.46,19.98 133.46,17.66 133.8,17.32 133.8,16.22 133.27,15.69 v2(133.27,15.43) 133.73,14.96 v1(133.89,14.96) ; v2(65.64,5.23) 65.53,5.13 61.86,5.13 61.12,4.39 60.91,4.39 60.42,3.9 60.42,3.39 60.66,3.15 60.66,2.68 60.55,2.57 JIO1.20
  IN3 w0.081: v2(65.64,5.23) 65.64,6.24 66.14,6.74 66.14,7.82 67.35,9.03 67.35,9.4 67.79,9.84 69.25,9.84 70.97,8.12 75.84,8.12 77.8,6.17 79.87,6.17 80.91,7.21 80.91,8.12 81.22,8.42 81.35,8.42 83,10.07 85.83,10.07 86.62,10.86 88.34,10.86 89.23,11.75 93.15,11.75 95.64,14.24 104.45,14.24 104.72,14.51 112.08,14.51 113.22,13.36 119.33,13.36 119.5,13.53 120.22,13.53 120.71,13.04 125.87,13.04 126.85,12.06 127.65,12.06 128.6,13.01 130.02,13.01 130.7,13.69 131.03,13.69 132.78,15.43 v2(133.27,15.43)
VBUS2_ECOK: length 119.5
  TOP w0.109: UE1.N3 131.53,19.48 v2(130.75,18.7) ; JIO1.22 60.05,2.73 v2(60.16,2.84) ; v2(56.25,21.43) 56.58,21.43 56.91,21.1 PR38.2 56.91,20.87 57.7,20.08 PR75.1
  IN3 w0.081: v2(130.75,18.7) 130.35,18.3 130.35,17.99 129.55,17.18 127.02,17.18 125.87,16.03 122.03,16.03 121.42,15.42 104.34,15.42 104.05,15.13 95.24,15.13 92.77,12.66 88.85,12.66 87.96,11.78 85.11,11.78 84.22,12.67 82.05,12.67 81.04,11.66 81.04,11.26 80.2,10.41 80.2,8.7 79.71,8.21 79.32,8.21 78.72,8.82 78.72,10.1 78.51,10.31 78.19,10.31 77.9,10.6 77.47,10.6 76.21,11.86 67.99,11.86 67.46,11.34 67.46,10.97 66.61,10.11 66.44,10.11 65.59,9.26 65.18,9.26 63.65,7.74 63.65,5.55 62.98,4.87 61.6,4.87 61.28,4.55 61.07,4.55 60.16,3.64 v2(60.16,2.84)
  IN4 w0.102: v2(56.25,21.43) 56.58,21.43 57.06,20.95 57.06,19.91 55.88,18.72 54.98,18.72 54.56,18.3 54.56,11.8 56.43,9.93 56.43,6.98 56.64,6.76 58.75,6.76 60.04,5.46 60.04,4.8 60.5,4.34 61.08,4.34 61.68,4.94 61.91,4.94 62.18,4.67 62.18,2.92 61.77,2.51 60.5,2.51 v2(60.16,2.84)
  BOTTOM w0.109: v2(130.75,18.7) v1(131.38,18.7)
VBUS3_ECOK: length 168.2
  TOP w0.109: v2(58.76,2.86) 59.05,2.58 JIO1.26 ; v2(140.67,25.55) 140.67,25.39 140.33,25.06 139.73,25.06 UE1.F13
  IN1 w0.102: v2(40.42,35.77) 40.49,35.83 43.93,35.83 45.02,36.92 45.43,36.92 46.37,35.98 49.29,35.98 51.23,37.93 51.23,39.8 51.43,40 53.81,40 54.41,40.59 66.19,40.59 67.44,41.85 71.11,41.85 72.85,43.59 74.78,43.59 75.23,43.14 v2(75.23,42.6)
  IN2 w0.081: v2(75.23,42.6) 76.28,41.55 79.93,41.55 80.63,40.84 81.1,40.84 82.1,39.85 90.36,39.85 91.1,39.1 93.1,39.1 94.67,37.53 94.67,37.52 95.58,36.61 98.13,36.61 99.78,34.96 101.18,34.96 102.41,33.72 102.41,32.08 103.07,31.43 103.07,30.66 104.06,29.67 108.51,29.67 109.73,28.45 115.14,28.45 117.41,26.18 117.41,25.38 118.05,24.74 119.69,24.74 120.6,23.83 120.6,23.73 121.07,23.26 124.12,23.26 125.42,21.96 127.22,21.96 128.18,22.93 128.77,22.93 128.97,23.13 128.97,24.05 130.16,25.24 136.92,25.24 137.12,25.44 137.12,25.85 137.32,26.05 140.26,26.05 140.67,25.65 v2(140.67,25.55)
  IN3 w0.081: v2(40.42,35.77) 40.42,35.05 41.73,33.74 42.86,33.74 43.3,33.3 43.3,32.91 44.76,31.44 44.76,28.49 45.67,27.58 45.67,25.37 46.97,24.08 47.46,24.08 48.76,22.79 50.46,22.79 v2(51.09,22.16)
  IN4 w0.102: v2(58.76,2.86) 58.22,3.41 56.22,3.41 55.54,4.09 55.54,9.31 53.88,10.97 53.88,16.47 51.97,18.38 51.97,20.21 51.09,21.09 v2(51.09,22.16)
  BOTTOM w0.109: v2(40.42,35.77) 40.55,35.9 v1(40.55,36.28) ; v2(51.09,22.16) 52.05,22.16 PR76.1 52.07,22.17 PR53.2
VBUS_C_CTRL_P1#: length 47.7
  TOP w0.109: v2(49.6,23.87) 49.6,25.07 PD14.3 48.82,26.49 50.55,26.49 51.29,25.75 51.95,25.75 52.27,26.08 52.27,27.24 v1(53.03,28) 53.69,28.65 53.69,29.31 53.81,29.44 53.81,29.9 53.57,30.15 v2(53.39,30.15) 53.28,30.15 52.89,29.75 50.9,29.75 50.4,29.24 RT521.2 ; v2(61.65,3.85) 62.05,3.45 JIO1.14
  IN4 w0.102: v2(49.6,23.87) 50.16,23.3 51.54,23.3 51.93,22.91 51.93,20.76 52.26,20.44 52.26,18.41 54.1,16.57 54.1,11.06 55.77,9.4 55.77,5.59 56.66,4.7 56.66,4.3 57.14,3.81 58.55,3.81 58.85,3.51 61.24,3.51 61.58,3.85 v2(61.65,3.85)
  BOTTOM w0.109: v2(53.39,30.15) 53.39,30.12 52.87,29.6 UT5.K4
VBUS_C_CTRL_P2#: length 62.8
  TOP w0.109: v2(55.07,19.13) 55.31,18.89 59.78,18.89 60.4,19.51 60.4,21.59 61.13,22.32 62.31,22.32 62.57,22.58 62.57,22.84 62.26,23.15 61.91,23.15 61.27,23.79 60.91,23.79 59.89,24.81 59.06,24.81 v1(58.87,25) 58.36,25.51 58.36,26.14 v2(57.81,26.69) ; JIO1.16 61.55,2.6 61.7,2.75 61.7,3.2 61.05,3.85 v2(61.05,3.93)
  IN1 w0.102: v2(50.83,33.48) 50.48,33.13 50.48,31.13 49.47,30.12 49.47,29.73 49.74,29.46 50.21,29.46 50.57,29.82 52.4,29.82 52.73,30.15 52.73,30.59 53.25,31.11 55.06,31.11 55.49,30.67 56.34,30.67 v2(56.35,30.68)
  IN3 w0.081: v2(57.81,26.69) 57.81,26.88 57.53,27.15 57.53,27.37 57.18,27.72 57.18,29.85 v2(56.35,30.68)
  IN4 w0.102: v2(55.07,19.13) 54.33,18.4 54.33,11.42 v2(56,9.76) 56,6.81 56.59,6.22 58.44,6.22 59.5,5.16 59.5,4.3 59.87,3.93 v2(61.05,3.93)
  BOTTOM w0.109: UT5.B5 56.87,30.11 56.35,30.63 v2(56.35,30.68) ; PD15.3 55.7,10.06 v2(56,9.76) ; v2(50.83,33.48) 50.55,33.2 RT522.2
VCC_GT_SENSE: length 93.3
  TOP w0.203: v2(269.95,152.94) 269.93,152.94 269.56,152.57 v1(269.56,152.07) 269.56,151.46 271.07,149.95 PR1126.2 ; PR1124.1 247.1,116.41 245.86,116.41 244.66,115.21 v2(244.49,115.21) 244.21,115.21 244.01,115.01 240.34,115.01 239.98,114.65 238.86,114.65 238.46,114.25 UC1.AH38
  IN1 w0.203: v2(244.49,115.21) 244.8,115.21 245.32,115.73 259.86,115.73 263.25,112.34 267.61,112.34 268.86,111.09 272.32,111.09 277.93,116.69 277.93,139.64 274.21,143.36 273.13,143.36 271.79,144.7 271.79,151.98 271.11,152.66 270.25,152.66 269.97,152.94 v2(269.95,152.94)
VCC_IO_SENSE: length 91.3
  TOP w0.254: v2(222.72,97.03) 223.12,96.63 UC1.H14
  IN3 w0.254: v2(222.72,97.03) 222.26,96.57 218.93,96.57 218.45,96.09 218.45,90.97 216.27,88.79 216.27,86.41 224.83,77.86 258.98,77.86 263.95,82.82 263.95,93.91 263.13,94.73 263.13,97.19 263.53,97.59 264.43,97.59 265.97,99.13 265.97,99.62 266.87,100.52 266.87,101.18 266.29,101.76 v2(266.28,101.76)
  BOTTOM w0.254: v2(266.28,101.76) 266.89,101.76 PR306.2
VCC_SA_SENSE: length 103.7
  TOP w0.203: PR1111.2 225.47,116.23 226.72,116.23 226.93,116.02 v2(226.93,115.83) 226.93,115.55 225.86,114.47 UC1.M38 ; PR1108.1 v2(253.71,150)
  IN1 w0.203: v2(253.71,150) 254.13,150.42 265.41,150.42 266.7,149.12 266.7,144.07 268.26,142.52 269.64,142.52 272.01,140.14 272.73,140.14 275.09,137.79 275.09,121.19 273.86,119.97 267.97,119.97 265.31,117.31 262.31,117.31 261.14,118.48 257.25,118.48 256.66,119.07 240.21,119.07 238.03,116.9 227.71,116.9 227.33,116.51 227.33,116.22 v2(226.93,115.83)
VCC_SENSE: length 99
  TOP w0.203: UC1.AG37 237.32,113.92 237.32,114.57 238.66,115.91 239.83,115.91 240.14,116.21 v2(240.14,116.35) 240.68,116.89 PR1119.2
  IN1 w0.203: v2(240.14,116.35) 240.28,116.35 240.45,116.53 240.45,116.8 240.95,117.3 260.54,117.3 261.92,115.92 265.66,115.92 268.5,118.76 274.73,118.76 276.31,120.34 276.31,138.54 273.49,141.35 272.52,141.35 269.27,144.6 269.27,148.56 267.93,149.9 267.93,151.88 267.48,152.34 261.89,152.34 261.17,151.63 257.57,151.63 256.95,152.25 v2(254.54,152.25)
  BOTTOM w0.203: PR1121.1 255.11,148.95 255.07,148.99 RC221.2 254.54,149 v1(254.54,151.08) v2(254.54,152.25)
VCCDSW_EN: length 39.8
  TOP w0.102: UE1.M7 v2(134.33,20.05)
  BOTTOM w0.102: 135.24,17.9 135.24,17.46 135.7,17.01 135.7,15.85 135.3,15.45 CE66.1 135.3,14.61 135.06,14.37 135.06,14.03 134.84,13.81 134.84,11.89 135.59,11.13 v1(137.26,11.13) 138.22,11.13 138.46,11.38 ; 140.25,12.37 142.31,12.37 142.64,12.71 142.64,14.42 142.97,14.75 143.98,14.75 146.93,17.7 146.93,18.47 148.03,19.57 152.26,19.57 153.52,20.83 153.52,24.6 152.87,25.25 RH445.1
  BOTTOM w0.109: 140.25,12.37 140.01,12.14 139.22,12.14 138.46,11.38 ; 135.24,17.9 134.81,18.34 134.5,18.34 134.26,18.58 134.26,19.98 v2(134.33,20.05)
VCCDSW_EN_GPIO: length 57.9
  TOP w0.109: v2(121.34,7.78) 121.12,7.57 120.87,7.57 v1(120.83,7.61) 120.67,7.77 RH431.1 120.67,9.05 120.74,9.12 QH6.2
  BOTTOM w0.109: v2(121.34,7.78) 121.34,5.3 122.18,4.45 124.78,4.45 125.22,4.01 127.77,4.01 129.24,5.48 129.24,6.47 131.09,8.33 131.09,9.04 131.47,9.42 132.07,9.42 132.39,9.1 132.39,8.49 132.7,8.18 134.97,8.18 135.29,8.5 137.39,8.5 138.29,9.4 139.96,9.4 141.75,11.2 143.17,11.2 144.14,12.16 144.14,13.58 148.24,17.68 152.6,17.68 152.94,18.01 152.94,19.89 153.75,20.7 153.75,24.74 152.76,25.72 151.48,25.72 151.14,25.39 RH445.2 DH1.2
VCCDSW_EN_Q: length 3.4
  BOTTOM w0.109: v1(153.07,20.85) 153.07,21.66 RH442.1 DH2.2 152.91,24.11 DH1.1
VCCMPHY_SENSE: length 49.4
  TOP w0.109: T76.1 192.32,15.36 192.32,17.5 191.9,17.93 191.9,19.8 191.58,20.12 191.58,20.65 UH1.K47
  TOP w0.254: v2(189.21,11.87) 189.2,11.88 189.2,12.81 190.34,13.95 190.91,13.95 T76.1
  BOTTOM w0.254: PR810.2 155.82,11.45 156.58,10.69 157.96,10.69 158.25,10.4 175.8,10.4 178.77,7.43 187.2,7.43 188.8,9.02 188.8,11.45 189.21,11.86 v2(189.21,11.87)
VCCST_PWRGD: length 104.5
  TOP w0.109: v2(186.58,77.42) 185.56,77.42 185.08,76.94 185.08,73.33 166.6,54.85 v2(166.6,51.08) ; v2(153.56,26.96) 153.89,26.63 v1(153.89,26.37) 153.89,26.12 154.78,25.23 155.32,25.23 156.23,24.32 156.54,24.32 157.61,23.25 158.59,23.25 158.83,23.49 159.17,23.49 159.46,23.19 UE4.4
  IN4 w0.102: v2(195.11,92.38) 194.08,93.42 193.7,93.42 193.46,93.65 191.18,93.65 190.35,94.48 188.53,94.48 187.96,93.91 187.96,91.66 187.26,90.96 187.26,83.84 188.19,82.91 188.19,77.78 187.84,77.42 v2(186.58,77.42)
  BOTTOM w0.109: v2(166.6,51.08) 166.6,49.49 164.91,47.8 163.85,47.8 159.52,43.47 159.52,40.28 154.27,35.03 154.27,28.27 153.56,27.56 v2(153.56,26.96) ; v2(195.11,92.38) 195.25,92.24 195.77,92.24 196.14,91.88 RC71.2 196.64,91.89 CC301.1 197.37,92.74 RC78.1
VCCST_PWRGD_CPU: length 30.9
  TOP w0.109: v2(222.72,95.46) 223.11,95.84 UC1.H13
  IN2 w0.081: v2(222.72,95.46) 222.72,95.34 222.47,95.09 220.3,95.09 219.96,94.74 218.73,94.74 218.46,94.47 205.36,94.47 205.03,94.8 200.63,94.8 199.92,94.09 v2(196.56,94.09)
  BOTTOM w0.109: v3(194.45,93.97) 194.75,93.97 194.9,94.11 196.53,94.11 v2(196.56,94.09) 196.86,93.78 RC78.2
VCCST_PWRGD_EC: length 5.5
  TOP w0.102: UE1.K10 v2(137.53,21.65)
  BOTTOM w0.109: RE552.1 140.81,19.58 v1(139.84,19.58) 138.66,19.58 137.95,20.29 137.95,21.23 v2(137.53,21.65)
VCCSTG_EN: length 113.8
  TOP w0.109: UZ19.4 194.14,92.25 194.42,92.53 UZ35.4 194.42,93.64 194.17,93.9 v2(193.8,93.9) ; RZ120.1 276.31,78.85 277.46,77.71 280.44,77.71 v2(280.72,77.99)
  IN3 w0.081: v2(193.8,93.9) 193.8,92.93 194.19,92.55 194.19,89.41 194.13,89.36 194.13,86.69 193.8,86.36 193.8,81.34 v2(194.78,80.37)
  BOTTOM w0.109: v2(194.78,80.37) 195.36,80.95 198.06,80.95 v1(198.39,81.28) 198.67,81.56 202.96,81.56 209.58,74.94 253.3,74.94 253.94,74.31 273.27,74.31 276.74,77.78 280.52,77.78 v2(280.72,77.99)
VDD12_A: length 5.7
  TOP w0.203: 61.23,31.44 61.13,31.54 61.13,32.05 61.39,32.31 UV66.32
  TOP w0.508: 61.23,31.44 61.54,31.13 v2(61.78,31.13)
  BOTTOM w0.109: v2(61.78,31.13) 61.78,31.08 v1(61.37,30.67)
  BOTTOM w0.381: v2(72.19,31.41) 72.19,31.84 71.93,32.09 CV951.1 71.11,31.5 CV950.1 71.38,30.94 71.64,30.94 v2(71.75,30.83)
VDD12_B: length 20.9
  TOP w0.203: CV923.1 139.98,39.88 140.48,40.38 140.48,41.01 140.81,41.35 UV67.32 ; v2(151.76,40.14) 151.57,39.95 150.91,39.95 150.7,40.17 UV67.56
  IN2 w0.381: v2(140.61,39.62) 140.61,39.84 140.94,40.17 150.24,40.17 150.93,39.48 152.1,39.48 v2(152.28,39.67)
  BOTTOM w0.109: v2(151.76,40.14) 151.66,40.14 151.61,40.19 151.14,40.19 v1(150.98,40.35)
  BOTTOM w0.508: v2(152.28,39.67) 152.68,40.07 152.68,40.72 CV920.1 152.37,41.36 CV921.1 151.76,41.09 v2(151.76,40.14)
  vias: v2(141.23,39.59)
VDD33_A: length 16
  TOP w0.203: v2(71.52,37.72) 71.29,37.49 71.29,37.07 70.86,36.64 UV66.2 ; UV66.29 61.38,33.51 61.12,33.25 v2(61.01,33.25)
  IN1 w0.381: v2(71.52,37.72) 71.24,37.44 71.24,36.76 70.36,35.88 62.55,35.88 61.01,34.34 v2(61.01,33.25)
  vias: v3(71.88,38.41)
VDD33_B: length 17.5
  TOP w0.203: UV67.29 140.83,42.55 140.46,42.17 v2(140.46,41.97) ; v2(151.22,46.17) 150.56,46.17 150.3,45.9 UV67.2
  BOTTOM w0.381: LV9.1 150.74,46.65 v2(151.22,46.17) 149.76,44.7 149.76,42.49 149.22,41.96 v3(141.34,41.96) 140.47,41.96 v2(140.46,41.97)
VDD_1.2V: length 14
  TOP w0.508: PC209.1 199.09,7.8 198.05,6.75 v3(198.05,6.15) 198.05,5.54 199.18,4.41 206.57,4.41 207.06,4.91 PR201.1
VDDA12_A: length 1.7
  TOP w0.203: v2(66.04,30.2) 66.06,30.22 UV66.43
  BOTTOM w0.109: v1(66.06,26.81) 65.72,27.14 65.72,27.4
VDDA12_B: length 2.7
  TOP w0.203: v2(144.93,38.54) 145.43,39.04 145.43,39.84 145.5,39.91 UV67.43
  BOTTOM w0.109: v1(143.79,36.34) 144.07,36.62 144.07,37.04 144.07,37.05
  vias: v2(146.3,37.71)
VDDP_1.2V:
  vias: v1(203.09,8.83)
VDDRX12_A: length 0.9
  TOP w0.203: UV66.3 70.46,36.86 v2(70.64,37.04)
  vias: v1(68.47,36.48) v2(61.44,36.55) v2(61.44,35.97) v2(66.99,37.37)
VDDRX12_B: length 13
  TOP w0.203: UV67.3 v2(149.9,46.23)
  BOTTOM w0.381: v2(140.4,44.67) 140.4,44.01 140.89,43.52 v3(143.78,43.52) 145.83,43.52 146.31,43.99 146.31,45.07 146.97,45.72 CV925.1 148.63,45.72 CV927.1 149.4,45.73 v2(149.9,46.23)
  vias: v2(141.02,45.52)
VDDTX12_A: length 3
  TOP w0.203: v2(66,29.61) 65.81,29.61 65.62,29.81 65.62,30.53 65.66,30.57 UV66.42 ; UV66.55 70.86,30.48 70.99,30.35 v2(71.25,30.35)
  vias: v1(69.23,29.44)
VDDTX12_B: length 6.5
  TOP w0.203: UV67.55 150.3,39.83 150.66,39.47 151.25,39.47 ; UV67.42 145.1,39.83 145.04,39.77 145.04,39.57 144.92,39.45 v2(144.92,39.16)
  TOP w0.508: 151.25,39.47 151.73,38.98 v2(151.73,38.77)
  BOTTOM w0.356: v2(151.54,37.23) 151.14,37.23 150.77,37.6 CV932.1 150.79,37.98 CV934.1 151.73,38 v2(151.73,38.77)
  vias: v3(148.58,39.96)
VSS_A36: length 7.7
  TOP w0.102: RC178.1 215.5,113.45 217.94,113.45 UC1.A36
  TOP w0.109: RC178.1 214.14,111.95 213.81,111.62 212.85,111.62 v1(212.18,112.3)
VSS_A37: length 6.1
  TOP w0.102: RC179.1 214.5,113.07 215.23,113.8 218.38,113.8 UC1.A37
  TOP w0.109: v1(213.4,114.1) 214.15,113.35 RC179.1
VSS_GT_SENSE: length 92.7
  TOP w0.203: UC1.AH37 238.1,113.93 238.1,114.36 238.72,114.98 239.85,114.98 240.21,115.34 243.87,115.34 244.35,115.82 v2(244.52,115.82) 244.8,115.82 245.72,116.74 246.72,116.74 246.92,116.94 PR1129.1 ; v2(270.26,152.03) 270.51,152.03 v1(271.48,151.06) 271.91,150.64 271.91,149.28 271.33,148.7 PR1128.2
  IN1 w0.203: v2(270.26,152.03) 270.56,152.33 270.98,152.33 271.46,151.84 271.46,144.56 272.99,143.03 274.07,143.03 277.6,139.5 277.6,116.83 272.19,111.42 269,111.42 267.75,112.67 263.39,112.67 260,116.06 245.18,116.06 244.93,115.82 v2(244.52,115.82)
VSS_IO_SENSE: length 89.1
  TOP w0.254: v2(223.68,95.99) 223.68,96.52 UC1.J14
  IN3 w0.254: v2(266.29,100.7) 266.29,100.48 265.59,99.78 265.59,99.29 264.27,97.97 263.38,97.97 262.75,97.34 262.75,94.58 263.56,93.76 263.56,82.98 258.83,78.24 224.99,78.24 216.65,86.57 216.65,88.63 218.84,90.81 218.84,95.93 219.09,96.18 223.53,96.18 223.68,96.03 v2(223.68,95.99)
  BOTTOM w0.254: v2(266.29,100.7) 266.44,100.85 PR310.2
VSS_SA_SENSE: length 106
  TOP w0.203: PR1106.1 v2(253.71,152.25) ; PR1100.2 226.09,116.57 227.19,116.57 227.79,115.97 227.83,115.97 226.26,114.4 226.26,113.96 UC1.M37
  TOP w0.254: 227.83,115.97 v2(227.9,115.97)
  IN1 w0.203: v2(253.71,152.25) 253.71,151.29 254.24,150.75 265.54,150.75 267.03,149.26 267.03,144.2 268.39,142.85 269.78,142.85 272.15,140.47 272.87,140.47 275.42,137.93 275.42,121.06 274,119.64 268.11,119.64 265.45,116.98 262.17,116.98 261,118.15 257.12,118.15 256.52,118.74 240.35,118.74 238.17,116.57 227.85,116.57 227.66,116.38 227.66,116.21 v2(227.9,115.97)
VSS_SENSE: length 104.5
  TOP w0.203: UC1.AG38 237.67,114.46 238.79,115.58 239.97,115.58 240.67,116.28 v2(240.97,116.28) 240.91,116.35 240.91,116.65 PR1125.2
  IN1 w0.203: v2(252.24,152.76) 256.91,152.76 257.71,151.96 261.04,151.96 261.75,152.67 267.61,152.67 268.26,152.02 268.26,150.04 269.6,148.7 269.6,144.74 272.65,141.68 273.63,141.68 276.64,138.67 276.64,120.2 274.86,118.43 268.64,118.43 265.8,115.59 261.78,115.59 260.4,116.97 241.08,116.97 240.78,116.67 240.78,116.47 v2(240.97,116.28)
  BOTTOM w0.203: PR1122.1 254.57,148.06 RC221.1 254.08,148.08 251.86,150.3 v1(251.86,151.05) 251.86,152.38 v2(252.24,152.76)
VSSMPHY_SENSE: length 50.7
  TOP w0.109: T77.1 191.57,13.33 191.56,13.34 191.56,14 192.56,15 192.56,17.55 192.1,18.01 192.1,19.89 191.84,20.14 191.84,20.52 191.95,20.63 191.95,20.97 UH1.K46
  TOP w0.254: T77.1 190.36,13.25 189.86,12.75 189.86,11.89 v2(189.84,11.87)
  BOTTOM w0.254: PR811.2 155.84,10.04 156.11,10.3 157.8,10.3 158.09,10.02 175.62,10.02 178.59,7.05 187.36,7.05 189.18,8.87 189.18,11.12 189.84,11.78 v2(189.84,11.87)
32KHZ_OUT: length 2.6
  TOP w0.102: UE1.F3 v2(131.13,25.65)
  BOTTOM w0.102: v2(131.13,25.65) 130.88,25.65 v1(130.56,25.97) 130.39,26.14 129.61,26.14 CE54.1
81215_ALERT: length 2.5
  TOP w0.203: PR1115.1 266.23,149.28 265.38,148.43 PU1100.41
81215_SCLK: length 2.3
  TOP w0.203: PR1117.1 v1(265.34,149.08) 265.34,148.89 264.98,148.54 PU1100.42
81215_SDIO: length 5.5
  TOP w0.109: v1(267.96,152.21) 267.96,150.39 267.6,150.03 PR1113.1
  TOP w0.203: PU1100.40 265.78,148.28 266.69,149.2 266.69,149.61 267.11,150.03 PR1113.1
81215_VR_HOT: length 5.1
  TOP w0.109: v1(269.49,150.56) 269.01,150.09 PR1110.1
  TOP w0.203: PR1110.1 267.98,149.57 267.7,149.57 266.64,148.52 266.64,147.45 266.52,147.33 PU1100.39
+BL_PWR_SRC: length 4.5
  TOP w0.508: FV1.2 89.14,35.67 87.68,35.67 RV907.1
  BOTTOM w0.127: v2(90.38,37.63) v3(90.38,36.95)
+BL_PWR_SRC_F: length 2.5
  TOP w0.109: 86.81,43.73 86.67,43.87 84.65,43.87 v3(84.46,43.68)
+CAMERA_VDD: length 25.5
  IN3 w0.508: v2(81.24,58.4) 82.65,56.99 82.65,53.7 83.02,53.33 83.02,52.51 83.55,51.99 83.55,51.41 84.14,50.81 84.14,46.62 86.08,44.68 88.62,44.68 91.55,47.61 91.55,49.88 91.81,50.14 v2(92.24,50.14)
  vias: v2(98.45,42.32) v3(96.98,44.49)
+CAMERA_VDD_F: length 5.6
  BOTTOM w0.127: v1(78.89,55.72) 78.2,56.41 QZ1.1
  BOTTOM w0.508: RZ550.1 80.29,59.9 79.78,59.9 QZ1.1
+COINCELL: length 18.8
  TOP w0.254: JRTC1.1 324.9,7.07 324.59,6.76 v2(324.2,6.76)
  IN4 w0.254: v2(337.59,7.36) 337.55,7.32 337.11,7.32 336.45,6.66 336.06,6.66 335.98,6.58 335,6.58 334.93,6.66 332.56,6.66 330.68,8.55 326.31,8.55 324.52,6.76 v2(324.2,6.76)
  BOTTOM w0.254: v2(337.59,7.36) v1(337.59,7.94) 337.59,8.23 338.16,8.81 PR61.1
+DCIN: length 9
  TOP w0.508: PR705.2 286.35,38.08 v2(286.28,38.01)
  BOTTOM w0.508: v2(290.65,33.07) 289.63,34.09 289.63,36.71 v3(288.94,37.4) 288.33,38.01 v2(286.28,38.01)
+DDR_VREF_B_DQ: length 19.9
  TOP w0.109: v2(258.84,95.97) 258.84,95.94 UC1.BR13
  BOTTOM w0.109: v2(258.84,95.97) 258.84,95.05 261.56,92.33 262.2,92.33 v1(269.08,85.44) 269.85,84.68 270.95,84.68 271.42,84.21 RD31.1 272.3,83.79 CD87.1
+DDR_VREF_CA: length 120.4
  TOP w0.254: UC1.BN13 257.21,95.55 v2(256.89,95.22)
  IN1 w0.381: v2(281.22,56.75) 279.88,55.41 279.88,48.21 277.32,45.64 277.32,44.63 274.63,41.95 274.63,40.25 270.07,35.69 270.07,34.38 268.03,32.33 262.76,32.33 261.69,31.26 254.37,31.26 254.1,30.99 250.54,30.99 248.25,28.7 235.28,28.7 234.37,29.61 v2(234.37,30.01)
  IN2 w0.381: v2(256.89,95.22) 257.11,95.22 258.03,94.29 258.63,94.29 258.9,94.03 258.9,86.96 261.91,83.96 261.91,75.42 274.54,62.79 275.82,62.79 276.97,61.64 276.97,59.86 280.08,56.75 v2(281.22,56.75)
  BOTTOM w0.109: v1(233.51,32.78) RD10.1
  BOTTOM w0.381: v2(234.37,30.01) RD9.1 CD25.1 RD10.1
+DGFF_PWR: length 0.7
  TOP w0.109: 101.91,15.12 v1(101.91,15.8)
+DGFF_PWR_SRC: length 0.8
  BOTTOM w0.109: v2(107.46,14.11) v3(106.62,14.11)
+DGFF_SRC_EN#: length 5.2
  TOP w0.109: v1(95.2,9.91) RZ514.1 93.42,10.56 RZ512.2 93.42,11.37 93.41,11.38 CZ526.2 93.75,11.82 94.28,11.28 QZ19.4
+DIMM_DQ_R_VREF_B: length 131.7
  IN3 w0.508: v2(204.56,85.63) 204.56,85.98 204.35,86.19 200.03,86.19 197.77,83.93 197.77,76.23 v2(198.65,75.35)
  BOTTOM w0.508: v2(204.56,85.63) 205.57,85.63 v3(206.54,84.67) 213.22,77.99 266.77,77.99 268.14,79.35 RD30.2 CD90.1 RD32.1 CD89.1 CD88.1 270.52,83.78 RD31.2 ; v2(198.65,75.35) 204.12,75.35 207.95,71.52 231.94,71.52 234.69,68.77 RD84.2
+EC_DEBUG_VCC: length 6
  BOTTOM w0.109: v3(50.4,4.55) 51.03,4.55 RE71.2
  BOTTOM w0.254: RE71.2 52.41,3.9 53.81,3.9 53.91,3.8 55.08,3.8 55.12,3.77 JDEG1.1
+EDP_VDD: length 1.5
  TOP w0.109: UV24.1 95.52,20.71 v1(94.73,21.51)
+IR_F: length 0.5
  BOTTOM w0.109: v2(71.1,49.09) v1(71.1,48.57)
  vias: v2(70.5,48.97) v2(75.15,53.33) v2(75.77,53.33)
+LCDVDD: length 38
  TOP w0.356: CV20.1 100.98,39.79 v2(100.81,39.96)
  TOP w0.381: v2(107.28,46.46) 107.28,46.14 106.88,45.74 99,45.74 97.64,44.38
  TOP w0.508: v2(84.94,29.45) 84.94,29.7 85.08,29.84 RV910.1
  IN1 w0.508: v2(100.81,39.96) 100.81,39.76 100.22,39.16 96.8,39.16 96.42,39.54 96.42,40.63 v2(96.17,40.89)
  BOTTOM w0.508: RV7.1 v2(107.28,46.46) ; 95.13,21.61 95.1,21.58 95.1,20.07 94.4,19.37 91.29,19.37 90.79,19.88 90.79,20.7 89.93,21.55 89.93,22.69 87.71,24.92 87.71,25.7 86.83,26.58 86.83,27.13 85.79,28.16 85.61,28.16 84.94,28.84 v2(84.94,29.45)
  vias: v2(95.21,22.94) v2(95.21,22.31) v2(95.61,41.15) v2(95.61,40.54) v3(94.35,35.37)
+MIC2-VREFO-L: length 9.2
  TOP w0.203: v2(350.3,21.46) 350.2,21.37 349.67,21.37 348.8,22.23 UA1.28
  TOP w0.381: RA5.1 354.24,22.58 v2(354.76,22.58)
  BOTTOM w0.381: v2(354.76,22.58) 354,22.58 353.33,23.25 v3(352.58,23.25) 350.93,23.25 350.5,22.82 350.5,21.66 v2(350.3,21.46)
+MIC2-VREFO-R: length 9.2
  TOP w0.203: UA1.29 348.83,22.63 349.55,21.9 v2(349.92,21.9)
  TOP w0.381: RA6.1 354.57,23.4 v2(354.78,23.19)
  BOTTOM w0.381: v2(349.92,21.9) v1(349.92,22.67) 349.92,23.02 350.68,23.78 353.54,23.78 354.14,23.19 v2(354.78,23.19)
+PECI_VREF: length 5
  TOP w0.33: UE1.J11 v2(138.33,22.45)
  BOTTOM w0.356: 139.13,23.33 139.13,22.87 CE25.1 138.71,22.45 v2(138.33,22.45)
  BOTTOM w0.508: 139.13,23.33 139.13,23.78 v3(139.4,24.04) 139.84,24.48 RE59.2
+PWR_SRC_R: length 8.2
  TOP w0.254: JUSH1.26 188.6,2.66 188.93,2.99 191.29,2.99 192.66,1.62 v3(194.19,1.62) 194.99,2.42 RZ85.2
+REGCTL_PNP10:
  vias: v3(185.12,127.41)
+RSVD_VCC3P3_2: length 3.3
  BOTTOM w0.109: RL6.2 186.26,123.65 186.26,125.18 186.43,125.34 UL1.1
+RTC_CELL: length 371.9
  TOP w0.254: RE551.2 152.33,28.91 151.83,29.42 QE15.3 150.67,28.82 151.28,28.21 151.28,27.55 151.78,27.05 151.78,24.22 153.21,22.8 153.21,20.21 v2(153.85,19.56)
  TOP w0.508: RE507.2 133.73,32.91 133.73,33.19 v2(133.78,33.24)
  IN1 w0.254: v2(321.25,38.23) 321.09,38.07 319.95,38.07 316.77,41.25 315.07,41.25 314.4,40.58 312.59,40.58 310.1,43.07 310.1,43.45 308.34,45.21 304.44,45.21 304.23,45.42 301.04,45.42 300.21,44.6 296.66,44.6 295.17,43.1 290.36,43.1 289.71,42.46 288.31,42.46 287.67,43.1 283.29,43.1 277.15,36.96 277.15,35.64 274.15,32.64 274.15,27.23 270.2,23.28 263.84,23.28 260.57,26.55 254.08,26.55 v2(253.83,26.8)
  IN2 w0.381: v2(133.78,33.24) 133.78,33.03 133.42,32.67 132.72,32.67 132.1,33.29 131.61,33.29 131.15,32.83 130.84,32.83 130.26,32.26 v2(130.26,32) 130.26,31.22 130.64,30.84 130.64,30.14 129.44,28.94 129.44,28.31 v2(129.1,27.97)
  IN3 w0.254: v2(127.89,38.11) 127.95,38.17 135.28,38.17 136.95,36.5 137.97,36.5 139.39,35.08 144.51,35.08 146.03,33.57 149.71,33.57 152.1,31.18 152.1,28.42 152.25,28.27 152.25,26.92 153.12,26.05 153.12,20.3 v2(153.85,19.56) ; v2(338.95,7.87) 338.95,8.6 341.5,11.15 341.5,19.68 341.88,20.07 341.88,29.78 343.45,31.35 343.45,31.61 344.63,32.8 344.63,33.19 346.22,34.78 350.16,34.78 350.89,34.05 350.89,32.13 351.78,31.23 v2(353,31.23) ; v2(253.83,26.8) 253.83,24.44 247.79,18.39 232.36,18.39 227.85,13.88 212.15,13.88 205.84,7.57 205.84,7.42 205.58,7.15 205.58,6.37 204.26,5.05 202.55,5.05 v2(201.87,5.73)
  IN4 w0.254: v2(201.87,5.73) 201.33,5.19 197.78,5.19 197.07,5.9 197.07,7.18 196.65,7.6 196.04,7.6 195.62,8.02 187.57,8.02 187.42,7.87 180.48,7.87 179.35,9 178.26,9 176.36,10.9 175.26,10.9 174.8,11.36 168.8,11.36 167.7,12.46 167.17,12.46 164.31,15.32 164.02,15.32 163.52,15.82 161.84,15.82 161.36,16.3 160.77,16.3 160.26,16.81 159.51,16.81 159,17.31 157.34,17.31 156.89,17.76 155.22,17.76 154.66,18.32 154.66,18.75 v2(153.85,19.56)
  BOTTOM w0.109: v2(153.85,19.56) 154.61,20.31 v3(154.89,20.31)
  BOTTOM w0.254: v2(130.26,32) 130.26,32.26 130.77,32.77 RE32.2 130.51,33.29 130.51,34.07 130.09,34.49 128.58,34.49 127.98,35.09 127.98,38.02 v2(127.89,38.11) 127.94,38.16 127.94,40.05 128.2,40.3 128.72,40.3 129.16,39.86 130.02,39.86 130.24,39.64 RE31.1 ; RA213.2 353.7,27.28 355.47,27.28 355.91,27.72 355.91,30.41 355.08,31.23 v2(353,31.23) 352.95,31.28 351.66,31.28 351.16,31.79 351.16,33.55 347.7,37.01 334.55,37.01 332.98,38.58 321.61,38.58 v2(321.25,38.23) ; PD8.1 339.27,8.2 v2(338.95,7.87) 338.95,7.67 339.05,7.57 PC24.1
  BOTTOM w0.381: v2(129.1,27.97) 129.02,28.06 RE750.2 128.41,27.34 RE508.2
+RTC_CELL_PCH: length 43.2
  TOP w0.102: v3(167.63,18.56) v2(167.63,19.25)
  TOP w0.254: QE15.1 153.19,29.95 CE63.1 154.5,28.91 RE551.1 154.5,28.91 RE546.1 154.5,27.35 v2(154.14,26.99) ; RH297.1 164.04,18.27 RH200.1 164.73,18.36 165.66,19.29 v2(165.66,19.99)
  IN2 w0.254: v2(167.63,19.25) 167.52,19.14 166.52,19.14 v2(165.66,19.99)
  IN4 w0.254: v2(154.14,26.99) 156.06,26.99 157.53,25.52 158.61,25.52 159.19,24.94 161.74,24.94 163.53,23.15 163.53,22.37 164.24,21.66 164.6,21.66 165.66,20.6 v2(165.66,19.99)
  BOTTOM w0.254: v2(167.63,19.25) 167.77,19.25 168.43,18.58 168.79,18.58 169.43,17.94 169.43,15.76 170.29,14.89 172.32,14.89 173.48,16.06 176.85,16.06 177.13,16.34 177.13,17.86 RH201.1 176.89,18.46 176.41,18.94 RH198.1
+RTC_CELL_VBAT: length 4.5
  TOP w0.33: CE11.1 131.38,31.44 v2(131.09,31.16) 130.73,30.8 UE1.A2
  BOTTOM w0.109: v1(131.96,31.31) 131.8,31.16 v2(131.09,31.16)
  BOTTOM w0.381: RE32.1 131.03,31.22 v2(131.09,31.16)
+SIM_PWR: length 131.1
  TOP w0.109: v2(342.88,49.4) v3(343.77,49.4)
  IN2 w0.508: v2(342.88,49.4) 340.55,47.08 336.81,47.08 335.18,45.44 329.73,45.44 328.43,46.75 324.29,46.75 322.36,44.82 322.36,41.86 321.36,40.86 320.6,40.86 319.58,39.84 318.28,39.84 317.75,40.37 317.75,42.5 316.99,43.26 313.06,43.26 312.28,44.04 311,44.04 306.42,48.63 303.45,48.63 302.82,47.99 302.82,46.39 300.19,43.76 297.57,43.76 296.84,43.03 292.63,43.03 290.15,40.54 290.15,38.93 289.59,38.37 289.59,35.89 288.14,34.44 287.47,34.44 286.88,33.85 286.88,33.18 283.52,29.81 283.52,26.83 279.92,23.23 279.92,20.23 v2(279.54,19.84)
  IN3 w0.457: v2(297.99,11.26) 297.94,11.26 297.31,10.62
  IN3 w0.508: 297.31,10.62 296.81,10.62 295.32,9.14 287.26,9.14 287.11,9.29 282.03,9.29 278.02,13.3 278.02,18.32 v2(279.54,19.84)
  BOTTOM w0.279: JNGFF2.28 298.25,11 v2(297.99,11.26)
  BOTTOM w0.508: v2(342.88,49.4) 343.06,49.22 CZ37.1 345.55,49.15 JSIM1.8
+TBT_SVR_IND:
  vias: v3(27.45,50.31)
+TRM_CT1: length 4.4
  TOP w0.109: v1(181.63,139.14) CL16.1 183.07,139.55 182.17,140.45 TL1.3
+TRM_CT2: length 4.3
  TOP w0.109: TL1.4 183.44,140.32 184.31,139.44 CL17.1 v1(185.59,139.14)
+TRM_CT3: length 4.2
  TOP w0.109: TL1.9 189.79,139.39 CL20.1 v1(188.04,139.2)
+TRM_CT4: length 4.6
  TOP w0.109: v1(192.66,138.56) 191.87,138.56 191.22,139.21 CL21.1 190.95,139.84 191.06,139.95 TL1.10
+UZ12_TPM: length 7
  TOP w0.109: v2(114.89,23.26) v1(114.89,24.01)
  TOP w0.254: v2(114.89,23.26) 115.31,23.26 115.4,23.35 CZ50.1 115.91,23.32 RZ367.2 116.47,21.91 UZ12.8
  BOTTOM w0.254: CZ75.1 117.46,22.97 RZ89.2 115.18,22.97 v2(114.89,23.26)
+UZ12_VHIO: length 5.6
  TOP w0.254: v2(123.23,24.41) UZ12.22
  BOTTOM w0.33: CZ54.1 121.69,23.07 ; CZ53.1 121.65,24.36
  BOTTOM w0.381: 121.69,23.07 122.03,23.07 123.23,24.27 v2(123.23,24.41) 123.18,24.36 121.65,24.36
  vias: v2(121.23,20.03) v2(121.82,20.02) v3(118.62,18.31)
+V_DDR_REF: length 1.9
  TOP w0.203: PU200.4 203.18,13.51 202.97,13.72 202.97,14.68 PC208.1
+V_DDR_REFCA_A: length 26.6
  TOP w0.254: JDIMM2.164 232.68,35.98 232.44,35.74 v1(232.44,33.33) v2(232.44,32.48)
  IN1 w0.381: v2(232.44,32.48) 232.06,32.87 232.06,36.3 232.58,36.83 232.58,43.74 232.13,44.19 v2(232.13,44.2)
  BOTTOM w0.305: v2(232.13,44.2) 232.13,44.26 232.68,44.81 JDIMM1.164
  BOTTOM w0.508: CD28.1 CD29.1 RD11.1 CD60.1 ; CD60.1 RD10.2 232.59,32.33 v2(232.44,32.48) ; CD60.1 CD61.1 CD26.1 RD8.2
+V_DDR_REFCA_B: length 57.3
  TOP w0.254: JDIMM4.164 232.68,49.88 231.73,48.93 v2(231.32,48.93)
  IN1 w0.381: v2(231.32,48.93) 231.67,48.93 234.79,45.82 234.79,36.53 235.28,36.03 v2(235.28,29.99)
  IN3 w0.381: v2(232.74,66.74) 232.74,49.73 231.95,48.93 v2(231.32,48.93)
  BOTTOM w0.102: v1(233.77,68.42) RD84.1
  BOTTOM w0.305: JDIMM3.164 232.68,60.94 232.44,61.17 232.44,62.25 232.74,62.56 CD97.1
  BOTTOM w0.381: RD9.2 v2(235.28,29.99)
  BOTTOM w0.508: RD36.1 232.82,63.13 CD97.1 CD95.1 CD94.1 v2(232.74,66.74) 232.75,66.74 233.08,67.07 RD84.1 233.77,66.23 CD126.1 233.79,65.39 233.78,65.38 CD125.1
+VR_CAP: length 7.8
  TOP w0.33: UE1.C10 v2(137.53,28.05)
  IN1 w0.254: v2(128.41,21.69) 128.49,21.76 129.18,21.76 130.03,22.61 130.03,24.91 130.68,25.56 130.68,26.95
  BOTTOM w0.109: v1(137.95,28.45) 137.55,28.05 v2(137.53,28.05)
+VSYS: length 13.2
  TOP w0.356: v2(58.85,37.33) 58.19,37.33 57.97,37.11 57.33,37.11 57.27,37.18 CT349.1 CT347.1
  IN1 w0.381: v2(58.33,32.13) 59.95,33.75 59.95,34.69 60.05,34.79 60.05,35.74 58.85,36.94 v2(58.85,37.33)
  BOTTOM w0.254: UT5.A5 57.53,29.88 57.82,29.88
  BOTTOM w0.381: v2(58.33,32.13) 58.33,32.06 58.48,31.91 58.48,31.5 RT512.1 ; RT569.1 58.83,29.93 57.88,29.93 57.82,29.88
  BOTTOM w0.508: RT569.1 RT512.1
A_CHIP_ID0: length 5.1
  BOTTOM w0.109: UE12.10 9.75,10.01 9.68,9.94 RE568.1 RE566.2 11.08,9 11.08,7.46 v1(11.33,7.21)
A_CHIP_ID1: length 3.8
  BOTTOM w0.109: UE12.23 8.4,16.14 RE565.2 RE567.1 7.26,16.66 v1(6.99,16.93)
AC_DIS: length 168.8
  TOP w0.109: v2(65.99,3.68) 65.44,3.68 65.08,3.32 65.08,2.7 64.55,2.17 JIO1.4 ; UE1.H12 139.06,23.32 139.8,23.32 v2(140.09,23.61) 140.21,23.61 142.06,25.46 RE83.1 ; PR2163.2 48.9,22.81 49.16,23.07 49.16,24.21 v2(49.12,24.25) PD14.2
  IN3 w0.081: v2(140.09,23.61) 140.09,23.16 139.82,22.89 139.82,19.7 140.14,19.38 140.14,15.14 139.29,14.29 139.29,12.76 138.69,12.16 138.69,11.57 137.97,10.85 137.97,10.59 136.45,9.07 135.43,9.07 134.13,7.77 129.6,7.77 129.2,7.37 127.06,7.37 125.57,8.87 121.88,8.87 121.13,9.62 119.37,9.62 119.24,9.75 115.79,9.75 115.04,8.99 111.81,8.99 109.55,11.25 96.42,11.25 94.35,9.18 94.35,8.24 94.12,8.01 93.72,8.01 93.06,7.34 92.24,7.34 91.47,6.57 83.74,6.57 83.06,5.9 83.06,4.36 82.09,3.4 81.19,3.4 79.75,4.83 75.35,4.83 73.01,7.17 70.42,7.17 69.37,6.7 66.36,3.68 v2(65.99,3.68)
  IN4 w0.102: v2(65.99,3.68) 66.79,2.88 66.79,2.07 66.38,1.66 58.02,1.66 56.5,3.18 56.13,3.18 55.31,4 55.31,9.21 53.65,10.87 53.65,16.38 51.49,18.53 50.11,18.53 48.75,19.9 48.75,23.89 v2(49.12,24.25)
  BOTTOM w0.109: v2(140.09,23.61) 140.87,23.61 v1(141,23.49) ; PD15.2 53.68,8.76 54.13,8.31 55.33,8.31 55.64,8 60.92,8 60.93,7.99 62.83,7.99 62.92,8.07 63.71,8.07 64.84,9.2 65.73,9.2 66.84,8.1 66.84,7.37 67.04,7.17 67.04,7.06 67.65,6.45 67.65,4.88 66.46,3.68 v2(65.99,3.68)
AC_DISC#: length 126.1
  TOP w0.102: UE1.E13 v2(140.07,25.51)
  TOP w0.109: JIO1.7 63.55,7.85 64.06,8.36 65.14,8.36 66.62,6.88 v2(66.66,6.88) 66.84,7.06 66.84,8.06 66.27,8.62 66.27,11.17 63.18,14.26 v1(57.77,14.26) 57.24,14.79 57.24,15.13 56.82,15.55 56.14,15.55 v2(55.73,15.14) 55.37,15.5 55.37,17.11 54.99,17.49 PQ5.2
  IN3 w0.081: v2(66.66,6.88) 67.03,6.88 67.56,6.35 68.09,6.35 69.42,7.69 70.33,7.89 73.3,7.89 75.49,5.71 80.06,5.71 81.95,7.59 81.95,7.63 82.26,7.94 83.49,7.94 83.8,7.64 91.02,7.64 92.02,8.63 92.02,8.75 92.38,9.11 92.69,9.11 96.05,12.47 109.95,12.47 111.52,10.9 118.77,10.9 119.22,11.34 124.24,11.34 125.35,10.23 128.4,10.23 129.37,11.2 131.66,11.2 131.83,11.37 134.69,11.37 135.04,11.02 136.63,11.02 137.54,11.93 137.54,12.57 138.19,13.22 138.19,17.29 137.29,18.2 137.29,18.77 137.93,19.42 137.93,24.96 138.23,25.25 139.82,25.25 140.07,25.5 v2(140.07,25.51)
  BOTTOM w0.109: PQ8.2 52.35,12.27 54.37,14.29 55.3,14.29 55.73,14.72 v2(55.73,15.14)
AC_PRESENT: length 46.1
  TOP w0.102: UH1.BG42 173.22,22.69 170.53,22.69 v2(170.53,22.69) 170.53,22.41 169.42,21.3 RH243.1 ; UE1.K8 v2(135.93,21.65)
  IN2 w0.081: v2(170.53,22.69) 168.92,21.08 167.63,21.08 167.05,21.66 165.48,21.66 165.09,22.05 164.33,22.05 163.02,23.36 162.2,23.36 161.52,22.68 161.07,22.68 160.98,22.59 159.8,22.59 159.48,22.91 159.05,22.91 v2(158.94,23.02)
  IN4 w0.102: v2(158.94,23.02) 158.94,23.46 158.11,24.3 156.66,24.3 156.1,24.86 153.52,24.86 153.13,25.25 148.65,25.25 148.21,25.69 147.31,25.69 144.74,23.13 142.53,23.13 141.43,22.02 136.57,22.02 136.2,21.65 v2(135.93,21.65)
  BOTTOM w0.109: v2(158.94,23.02) 158.94,22.72 v1(158.73,22.51)
ACAV_IN: length 290
  TOP w0.102: UE1.C7 v2(134.33,28.05)
  TOP w0.109: v2(287.75,33.44) 287.8,33.49 287.99,33.49 288.57,34.08 PR713.1 ; v2(134.18,12.34) 134.18,13.28 134.46,13.55 DZ12.1 ; v2(186.21,95.34) 186.21,95.71 187.3,96.8 UV68.1
  IN1 w0.102: v2(287.75,33.44) 287.75,34.38 286.76,35.37 286.76,36.53 v2(285.71,37.57)
  IN2 w0.081: v2(191.34,61.99) 190.95,61.6 190.52,61.6 189.83,60.91 189.83,60.03 189.44,59.63 188.15,59.63 187.19,60.59 184.79,60.59 184.54,60.34 183.25,60.34 178.96,56.04 v2(178.96,55.77) 178.96,54.87 176.38,52.29 175.73,52.29 173.64,50.2 173.64,49.55 172.35,48.26 172.35,46.15 169.98,43.78 169.98,43 170.54,42.44 170.54,41.91 170.24,41.62 169.38,41.62 166.67,38.91 164.27,38.91 164.2,38.84 161.76,38.84 157.96,35.04 157.3,35.04 154.52,32.27 152.25,32.27 151.85,31.87 145.04,31.87 144.07,30.9 141.59,30.9 141.29,31.19 139.76,31.19 138.86,30.29 138.32,30.29 137.98,29.95 137.98,27.89 137.73,27.64 137.28,27.64 137.13,27.48 137.13,27.08 136.9,26.85 134.92,26.85 134.76,27.01 134.76,27.62 v2(134.33,28.05)
  IN3 w0.081: v2(191.34,61.99) 191.82,61.51 193.61,61.51 195.35,59.77 195.35,57.62 197.39,55.58 197.83,55.58 198.67,54.73 198.67,54.65 198.72,54.6 199.74,53.58 199.97,53.58 202.73,50.82 203.25,50.82 206.59,47.48 206.59,43.48 206.5,43.4 206.5,40.99 209.71,37.78 212.76,37.78 215.91,34.63 220.16,34.63 220.85,33.94 221.58,33.94 223.35,32.16 227.42,32.16 228.32,31.26 232.55,31.26 232.78,31.03 262.1,31.03 263.25,32.18 274.6,32.18 280.75,38.33 284.95,38.33 v2(285.71,37.57) ; v2(134.18,12.34) 134.96,12.34 136.93,14.3 137.39,14.3 137.57,14.48 137.57,17.03 136.66,17.94 136.66,19.19 135.51,20.34 135.51,21.06 135.7,21.25 136.13,21.25 136.34,21.46 136.34,25.06 136.5,25.23 136.92,25.23 137.1,25.4 137.1,28.24 135.94,29.4 134.94,29.4 134.33,28.8 v2(134.33,28.05)
  BOTTOM w0.109: v2(186.21,95.34) 186.82,94.73 188.43,94.73 188.66,94.5 v3(190.68,94.5) 191.09,94.5 192.07,93.52 192.07,89.48 192.49,89.05 195.61,89.05 196.33,88.33 197.06,88.33 198.24,87.15 198.24,84.72 197.35,83.83 195.18,83.83 188.59,77.23 188.59,72.31 186.62,70.34 186.62,66.55 183.09,63.01 181.43,63.01 180.03,61.61 180.03,56.84 v2(178.96,55.77)
ALW_PWRGD_3V_5V: length 187.2
  TOP w0.109: v2(116.3,11.9) PR103.2 116.3,11.21 PR102.2 117.54,10.33 117.97,10.76 UZ6.2
  IN2 w0.081: v2(82.96,8.79) 82.31,9.44 80.83,9.44 79.58,10.7 79.58,16.59 80.31,17.32 82.42,17.32 83.24,18.14 83.24,23.93 83.31,24.01 83.31,24.49 83.1,24.71 82.67,24.71 81.86,23.9 81.3,23.9 80.27,24.93 77.53,24.93 76.35,23.75 76.35,22.21 75.77,21.64 67.5,21.64 66.55,22.59 65.52,22.59 65.03,22.1 64.28,22.1 64.08,22.3 63.56,22.3 63.3,22.05 63.3,21.55 62.93,21.18 60.86,21.18 60.57,21.47 60.57,22.11 60.26,22.42 59.49,22.42 59.41,22.5 58.99,22.5 58.6,22.5 58.11,22.01 58.11,21.26 57.07,20.22 54.54,20.22 53.21,18.89 48.09,18.89 47.79,19.19 46.83,19.19 46.28,18.64 46.28,17.54 44.98,16.24 40.59,16.24 39.8,17.04 37.99,17.04 36.41,18.62 35.06,18.62 34.25,19.42 34.25,19.99 33.46,20.79 32.81,20.79 v2(32.56,20.54)
  IN3 w0.081: v2(137.17,14.84) 135.06,12.74 133.93,12.74 133.18,11.99 131.46,11.99 131.35,11.89 129.09,11.89 128.12,10.92 125.64,10.92 124.52,12.03 119.45,12.03 119.03,12.45 116.84,12.45 v2(116.3,11.9) 115.75,12.45 112.8,12.45 112.16,13.09 95.76,13.09 92.46,9.79 91.6,9.79 91.39,9.58 87.14,9.58 86.21,8.65 83.1,8.65 v2(82.96,8.79)
  BOTTOM w0.109: v2(137.17,14.84) 137.71,14.3 139.32,14.3 139.77,14.75 142.61,14.75 142.87,15.01 143.88,15.01 146.45,17.59 v1(146.45,18.65) 147.61,19.81 150.68,19.81 151.41,20.54 151.41,22.69 DH2.1 ; RT550.1 39.3,27.45 40.53,27.45 41.39,26.59 41.39,23.95 41.06,23.62 39.63,23.62 39.3,23.96 38.53,23.96 38.2,23.63 35.6,23.63 35.38,23.85 35.38,24.36 35.02,24.72 33.4,24.72 32.59,23.9 32.59,23.61 32.46,23.49 32.46,22.85 32.66,22.65 32.66,20.64 v2(32.56,20.54) 32.24,20.54 31.75,21.03 QT1.2
ALW_PWRGD_3VR_5VR: length 16.3
  TOP w0.109: v2(315.43,30.82) 317.02,30.82 v1(317.16,30.69)
  TOP w0.254: v2(315.43,30.82) 315.08,31.17 PR508.2 ; PR509.2 v2(314.13,41.06)
  IN3 w0.254: v2(315.43,30.82) 314.3,30.82 313.74,31.39 313.74,33.91 312.67,34.98 312.67,40.1 313.63,41.06 v2(314.13,41.06)
ALWON: length 375.8
  TOP w0.109: v2(133.14,30.09) 133.14,30.06 133.15,30.05 133.15,29.27 UE1.A5 ; PR505.1 v2(313.2,31.94) ; v2(275.66,86.09) 275.26,85.7 275.26,85.08 274.27,84.08 270.34,84.08 259.63,73.37 v1(225.33,73.37) 213.16,73.37 203.23,83.3 199.76,83.3 191.63,75.18 191.63,72.3 192,71.93 192,68.61 184.37,60.99 v2(184.37,60.74)
  IN2 w0.081: v2(275.66,86.09) 275.51,86.24 274.41,86.24 273.72,85.56 273.72,79.09 278.21,74.6 281.62,74.6 282.19,75.17 286.28,75.17 286.79,74.65 v2(286.79,74.6) ; v2(184.37,60.74) 183.34,60.74 179.21,56.62 178.89,56.62 178.55,56.28 178.55,54.82 176.25,52.52 175.64,52.52 173.41,50.29 173.41,49.64 172.12,48.35 172.12,46.24 169.75,43.87 169.75,42.9 170.31,42.34 170.31,42.01 170.17,41.87 169.12,41.87 167.87,40.62 167.03,40.62 166.24,39.83 164.74,39.83 163.97,39.07 161.67,39.07 157.86,35.27 157.23,35.27 154.46,32.5 152.15,32.5 151.81,32.15 145,32.15 143.99,31.14 143.41,31.14 142.52,32.03 140.45,32.03 140.12,31.71 139.02,31.71 136.47,29.16 136.47,28.76 136.16,28.45 134.46,28.45 133.15,29.77 133.15,30.05 133.14,30.06 v2(133.14,30.09)
  IN3 w0.081: v2(91.45,20.33) 91.6,20.19 93.17,20.19 93.39,20.4 98.15,20.4 98.78,19.77 100.91,19.77 101.61,20.48 105.78,20.48 108.26,22.96 111.49,22.96 112.02,23.49 112.98,23.49 113.53,24.04 114.4,24.04 115.13,24.77 120.57,24.77 120.96,24.38 122.5,24.38 123.21,25.08 123.87,25.08 126.3,27.52 129.23,27.52 130.26,28.55 130.26,28.9 131.01,29.66 132.71,29.66 v2(133.14,30.09)
  IN4 w0.102: v2(91.45,20.33) 90.01,20.33 88.01,22.33 85.02,22.33 84.15,23.19 80.99,23.19 78.91,25.27 71.61,25.27 70.16,23.83 64.59,23.83 64.11,23.35 64.11,22.65 63.88,22.42 63.49,22.42 63.29,22.22 63.29,21.43 63.09,21.23 58.71,21.23 56.52,19.04 56.52,13 56.67,12.84 56.67,8.16 56.99,7.83 63.85,7.83 65.19,9.17 v2(65.19,9.8)
  BOTTOM w0.109: v2(313.2,31.94) 313.38,31.94 313.86,32.41 313.86,37.72 311.8,39.78 311.8,41.97 309.18,44.58 309.18,50.55 300.92,58.81 300.06,58.81 290.25,68.62 290.25,71.78 287.43,74.6 v2(286.79,74.6) ; v2(65.19,9.8) 65.19,10.26 PR113.1
AR_DET#: length 14.1
  TOP w0.089: v2(176.15,36.17) UH1.BB16
  TOP w0.109: RH400.1 165.47,37.96 RH401.1 166.72,36.23 166.53,36.04 v2(166.53,36.02)
  IN1 w0.102: v2(166.53,36.02) 168.83,36.02 169.07,36.26 176.07,36.26 v2(176.15,36.17)
  BOTTOM w0.109: v3(166.09,36.58) 166.53,36.14 v2(166.53,36.02)
AUD_AZACPU_SCLK: length 85.5
  TOP w0.076: UC1.G27 222.44,106.92 v2(222.1,107.26)
  TOP w0.109: v2(179.25,57.98) 179.08,57.98 177.44,56.33 177.44,52.18 RH38.1
  IN4 w0.102: v2(179.25,57.98) 181.09,57.98 182.67,59.55 185.56,59.55 186.57,58.55 187.94,58.55 188.68,59.29 191.95,59.29 194.07,61.41 194.07,65.41 193.43,66.05 193.43,67.55 195.46,69.57 195.78,69.57 199.82,73.6 199.82,79.63 200.6,80.41 200.6,82.11 203.4,84.9 204.44,84.9 210.26,90.72 211.1,90.72 212.62,92.24 212.62,98.41 217.59,103.38 218.25,103.38 218.97,104.1 218.97,104.92 219.44,105.38 219.8,105.38 220.53,106.11 221.62,106.11 222.1,106.59 v2(222.1,107.26)
AUD_AZACPU_SCLK_R: length 10.5
  TOP w0.102: UH1.AM3 180.85,42.38 180.65,42.59 180.65,44.08 180.15,44.58 180.15,46.16 179.08,47.22 179.08,47.38 v1(178.83,47.63) 178.69,47.63 177.8,48.52
  TOP w0.109: 177.8,48.52 177.8,49.95 177.57,50.18 177.08,50.18 176.93,50.33 RH38.2
AUD_AZACPU_SDI: length 10
  TOP w0.076: UC1.G29 222.15,108.73 218.26,108.73 218.14,108.6 215.85,108.6
  TOP w0.102: 215.85,108.6 214.65,109.81
  TOP w0.109: RC66.1 214.14,110.32 v1(214.39,110.07) 214.65,109.81
AUD_AZACPU_SDI_R: length 95.3
  TOP w0.109: v2(211.83,113.02) 211.83,111.8 212.47,111.15 RC66.2 ; UH1.AN3 180.39,42.26 180.26,42.39 180.26,43.92 179.76,44.42 179.76,45.99 176.29,49.46 176.29,52.11 176.95,52.77 176.95,56.53 178.05,57.64 178.05,60.18 182.98,65.1 184.9,65.1 186.79,67 v3(186.79,67.01) v2(188.44,68.66)
  IN3 w0.081: v2(188.44,68.66) 191.55,68.66 196.87,73.98 196.87,81.39 195.63,82.63 195.63,84.68 197.58,86.62 197.58,88.48 196.28,89.78 196.28,90.98 197.89,92.59 197.89,93.93 204.75,100.79 204.75,104.89 206.56,106.71 206.56,107.75 v2(211.83,113.02)
AUD_AZACPU_SDO: length 85.7
  TOP w0.102: v2(222.76,104.9) 222.44,105.23 UC1.G25
  TOP w0.109: v2(179.24,57.38) 177.99,56.14 v1(177.99,54.69) RH39.1
  IN4 w0.102: v2(179.24,57.38) 181.18,57.38 182.87,59.07 185.36,59.07 186.37,58.06 188.14,58.06 188.88,58.8 192.15,58.8 194.56,61.21 194.56,65.61 193.92,66.25 193.92,67.35 195.66,69.09 195.98,69.09 200.3,73.4 200.3,79.43 201.09,80.21 201.09,81.91 203.6,84.42 204.64,84.42 210.46,90.24 215.12,90.24 216.99,92.11 216.99,102 217.52,102.52 218.3,102.52 218.99,103.21 218.99,103.44 220.02,104.47 222.33,104.47 v2(222.76,104.9)
AUD_AZACPU_SDO_R: length 9.4
  TOP w0.102: UH1.AM2 180.85,42.75 180.85,43.08 180.85,43.08 180.85,44.15 180.34,44.66 180.34,46.24 179.35,47.23
  TOP w0.109: RH39.2 178.29,50.46 v1(178.29,49.6) 178.29,48.43 178.7,48.01 178.9,48.01 179.35,47.56 179.35,47.23
AUD_HP_NB_SENSE: length 23.8
  TOP w0.508: v2(352.36,16.13) 352.32,16.09 CA41.1 350.77,16.09 RA220.1 350.71,16.09 350.29,16.51 v2(349.38,16.51)
  BOTTOM w0.508: v2(349.38,16.51) 349.09,16.8 349.09,18.67 349.84,19.42 352.33,19.42 353.12,18.62 v3(353.79,18.62) 354.42,18.62 355,18.05 357.17,18.05 DA2.3 359.87,15.35 359.87,13.72 360.49,13.1 JHP1.6 ; QA10.2 353.85,15.79 353.5,16.13 v2(352.36,16.13)
AUD_HP_OUT_L: length 1.3
  TOP w0.508: LA15.1 353.18,21.27 RA7.1
AUD_HP_OUT_L1: length 11.2
  TOP w0.508: LA15.2 354.51,21 355.33,21 CA3.1 v2(355.39,20.29)
  IN1 w0.508: JHP1.1 359.32,20.7 358.38,21.64 v2(356.43,21.64)
  BOTTOM w0.109: v2(355.39,20.29) 353.81,20.29 v3(353.77,20.33)
  BOTTOM w0.508: v2(355.39,20.29) 355.39,21.5 DA1.3 356.42,21.65 v2(356.43,21.64)
AUD_HP_OUT_R: length 1.3
  TOP w0.508: RA8.1 353.17,20.4 LA16.1
AUD_HP_OUT_R1: length 20.6
  TOP w0.508: v2(355.34,18.93) CA2.1 354.82,19.6 LA16.2
  IN1 w0.508: v2(358.14,20.8) 361.09,17.85 364.68,17.85 367.75,14.78 JHP1.2
  BOTTOM w0.508: v2(355.34,18.93) v3(355.91,19.5) 356.25,19.84 356.25,20.43 DA1.2 358.14,20.97 v2(358.14,20.8)
AUD_PC_BEEP: length 4.3
  TOP w0.203: v2(349.35,24.87) 349.1,24.63 UA1.34
  BOTTOM w0.254: v2(349.35,24.87) v1(349.84,25.37) 350.88,26.41 CA27.2 CA28.2
AUD_SENSE_A: length 62.7
  TOP w0.109: UA1.48 339.57,26.18 338.7,27.06 338.7,28.12 338.38,28.44 338.38,32 338.75,32.36 338.75,37.39 341.16,39.8 344.59,39.8 v1(344.91,39.48) 345.31,39.08 345.84,39.08 v2(345.88,39.04)
  IN1 w0.254: v2(346.74,31.49) 346.74,31.88 347.79,32.94 347.79,37.13 v2(345.88,39.04)
  IN4 w0.203: v2(346.74,31.49) 346.57,31.65 345.69,31.65 344.4,30.36 344.06,30.36 343.18,29.48 343.18,28.81 343.42,28.57 343.42,27.43 342.91,26.92 342.91,20.08 344.21,18.79 344.21,17.22 344.42,17.01 344.42,16.32 344.1,15.99 344.1,15.32 345,14.42 347.14,14.42 347.14,14.41 347.98,13.57 351.02,13.57 351.65,14.2 v2(351.65,14.55)
  BOTTOM w0.203: v2(351.65,14.55) 352.16,14.55 QA10.1
AUX_EN_WOWL: length 26.7
  TOP w0.102: UE1.D3 v2(131.13,27.25)
  TOP w0.109: v2(130.73,37.45) 131.37,38.1 132.87,38.1 133.73,38.97 134.66,38.97 RZ379.2 RZ70.1 135.69,40.13 136.73,40.13 137.38,39.48 138.07,39.48 138.39,39.15 138.39,38.1 DZ9.2
  BOTTOM w0.109: v2(130.73,37.45) 129.82,36.55 129.82,35.19 130.98,34.04 131.49,34.04 131.65,33.88 131.65,33.3 132.65,32.29 132.65,32 133.02,31.63 133.02,30.85 132.53,30.37 132.53,29.21 v1(132.29,28.96) 131.13,27.81 v2(131.13,27.25)
BARREL_DISC: length 108.2
  TOP w0.102: UE1.E7 v2(134.34,25.66)
  TOP w0.109: JIO1.15 61.55,7.18 v2(61.43,7.3)
  IN3 w0.081: v2(134.34,25.66) 134.34,25.11 133.08,23.85 131.56,23.85 131.36,23.64 130.96,23.64 129.6,22.28 129.6,21.02 129.28,20.7 127.3,20.7 126.74,20.13 125.49,20.13 125.11,19.75 122.76,19.75 121.99,20.53 119.53,20.53 117.73,18.73 116.79,18.73 116.47,18.4 115.03,18.4 114.49,17.86 114.49,16.99 114.41,16.91 103.57,16.91 103.13,16.47 93.96,16.47 93.73,16.23 84.19,16.23 83.37,17.06 76.45,17.06 75.2,15.8 75.2,13.34 74.96,13.09 64.89,13.09 63.5,14.48 58.64,14.48 56.48,12.32 56.48,6.52 55.55,5.59 55.55,4.49 56.39,3.65 58.66,3.65 61.43,6.41 v2(61.43,7.3)
  BOTTOM w0.109: v1(134.24,24.54) 134.24,25.56 v2(134.34,25.66)
BAT1_LED#: length 23.5
  TOP w0.109: UE1.D10 137.54,27.25 v2(138.36,27.25) ; v2(139.88,11.54) 140.34,11.07 RZ28.1
  IN3 w0.081: v2(138.36,27.25) 138.75,27.64 139.5,27.64 139.64,27.78 140.79,27.78 141.73,26.84 141.73,26.69 142.64,25.77 142.64,22.79 141.8,21.95 141.8,21.19 141.66,21.05 141.66,19.86 140.97,19.17 140.97,14.8 140.15,13.97 140.15,11.81 v2(139.88,11.54)
  BOTTOM w0.109: v2(139.88,11.54) 139.98,11.54 v1(140.29,11.84)
BAT1_LED#_R: length 2.1
  TOP w0.109: QZ3.2 136.95,9.78 QZ22.1
BAT2_LED#: length 22.8
  TOP w0.109: v1(140.17,9.06) RZ361.1 139.7,10.1 v2(139.31,10.49) ; UE1.D11 v2(138.33,26.45)
  IN3 w0.081: v2(139.31,10.49) 139.31,11.81 139.94,12.44 139.94,14.06 140.77,14.88 140.77,19.51 141.44,20.18 141.44,21.22 141.59,21.38 141.59,22.4 142.42,23.22 142.42,24.52 140.79,26.15 139.93,26.15 139.64,26.45 v2(138.33,26.45)
BATDRV: length 4.5
  TOP w0.203: PU700.18 287.47,27.58 v1(286.74,26.86) 286.49,26.61 285.79,26.61 285.74,26.66 285.24,26.66 284.51,25.93 PR701.1
BATDRV_GATE: length 313.4
  TOP w0.254: v2(55.12,14.95) 55.12,14.71 54.71,14.3 PD12.3 54.5,14.3 53.36,15.44 PD13.3 ; v2(59.59,7.34) 60.05,6.88 JIO1.21
  IN1 w0.254: v2(66.11,5.86) 68.08,5.86 69.54,7.32 70.74,7.89 70.85,7.93 73.69,7.93 74.04,7.57 76.15,7.57 80.16,3.56 82.11,3.56 83.75,5.2 v2(83.75,5.34)
  IN2 w0.254: v2(55.12,14.95) 55.12,14.71 54.68,14.27 51.13,14.27 50.68,13.81 50.68,12.88 51.36,12.2 55.2,12.2 57.22,10.17 58.8,10.17 59.48,9.49 59.48,7.45 v2(59.59,7.34) 60.28,6.65 62.84,6.65 63.63,5.86 v2(66.11,5.86)
  IN3 w0.254: v2(83.75,5.34) 83.75,5.62 84.2,6.07 91.68,6.07 92.45,6.84 93.41,6.84 94.04,7.46 94.43,7.46 94.91,7.94 94.91,9.03 96.63,10.75 107.73,10.75 109.99,8.49 115.31,8.49 115.91,9.09 120.52,9.09 121.3,8.31 125.34,8.31 126.97,6.68 127.33,6.68 127.81,6.2 128.97,6.2 130.01,7.24 134.33,7.24 135,7.92 138.79,7.92 139.55,7.15 143.32,7.15 143.81,7.64 145.81,7.64 146.84,8.68 158.19,8.68 160.14,6.73 164.91,6.73 166.07,7.89 171.63,7.89 175.34,4.18 177.23,4.18 179.63,1.78 194.06,1.78 196.38,4.11 206.84,4.11 207.48,4.75 208.55,4.75 209.7,5.91 209.7,8.9 212.94,12.13 228.98,12.13 231.43,14.58 250.64,14.58 256.08,20.03 256.08,26.05 256.99,26.95 258.42,26.95 259.11,26.27 v2(259.11,23.98)
  IN3 w1.016: 309.77,13.56 309.77,13.57 306.13,17.21 302.31,17.21 302.06,16.96 293.83,16.96 287.15,23.64 286.59,23.64
  IN4 w0.254: v2(259.11,23.98) 270.68,23.98 271.5,24.81 277.71,24.81 279.88,22.64 284.73,22.64 v2(285.59,23.5)
  BOTTOM w0.254: v2(310.49,12.9) 309.97,13.42 v3(309.92,13.42) 309.17,14.17 PC725.1
  vias: v2(285.32,24.02)
