# Allegro board LAH271PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CNV_PTX_DRX_P1: length 235.1
  TOP w0.109: v2(171.26,43.67) 171.26,43.44 171.36,43.34 171.36,43.06 173.36,41.06 173.68,41.06 173.69,41.05 173.78,41.05 174.03,40.8 UH1.BF6
  IN4 w0.102: v2(171.26,43.67) 170.99,43.67 170.87,43.79 170.34,43.79 170.04,43.5 170.04,42.78 170.18,42.64 170.18,40.68 170.06,40.56 169.34,40.56 164.77,35.98 164.77,34.36 163.59,33.17 163.59,31.15 164.98,29.76 164.98,27.91 166.01,26.87 166.01,25.81 167.12,24.7 167.12,23.8 167.35,23.57 167.35,23.08 167.05,22.78 167.05,21.85 167.74,21.16 169.41,21.16 171.08,19.49 171.81,19.49 172.17,19.13 172.17,18.79 173.24,17.72 173.84,17.72 174.22,17.34 174.47,17.34 174.61,17.2 176.93,17.2 178.41,15.72 179.4,15.72 180.01,15.11 180.01,14.93 180.47,14.47 181.99,14.47 183.26,13.21 185.8,13.21 186.52,12.48 190.88,12.48 192.18,13.78 196.79,13.78 197.67,12.9 199.68,12.9 202.27,10.31 203.82,10.31 205.18,11.66 205.18,12.21 205.99,13.02 207.21,13.02 209.04,11.19 219.1,11.19 220.59,12.68 228.95,12.68 229.72,11.9 236.36,11.9 237.17,11.08 237.17,10.71 243.56,4.32 243.89,4.32 244.35,3.86 244.35,3.36 v2(244.17,3.18)
  BOTTOM w0.109: v2(244.17,3.18) 244.38,2.98 244.38,2.22 244.67,1.93 245.19,1.93 245.45,2.18 245.45,2.39 245.63,2.57 245.88,2.57 246.06,2.39 246.06,2.24 246.37,1.93 257.4,1.93 258.78,3.31 260.17,3.31 260.35,3.13 260.35,2.29 260.65,1.98 261.09,1.98 261.4,2.29 261.4,3.13 261.58,3.31 261.83,3.31 262.01,3.13 262.01,2.29 262.32,1.98 262.75,1.98 263.06,2.29 263.06,3.13 263.24,3.31 263.5,3.31 263.68,3.13 263.68,2.29 263.99,1.98 264.42,1.98 264.73,2.29 264.73,3.13 264.91,3.31 265.17,3.31 266.13,2.35 273.06,2.35 273.46,1.94 273.96,1.94 274.37,2.35 274.77,2.35 275.18,1.94 276.09,1.94 276.5,2.35 277.17,2.35 277.59,1.93 282.42,1.93 283.45,2.96 285.04,2.96 v4(286.03,3.95) 287.52,5.44 289.73,5.44 290.61,6.32 291.38,6.32 291.8,5.91 292.31,5.91 292.72,6.32 293.3,6.32 293.71,5.91 294.31,5.91 294.72,6.32 302.08,6.32 302.26,6.14 302.26,6.02 302.57,5.71 303,5.71 303.31,6.02 303.31,6.14 303.49,6.32 303.74,6.32 303.92,6.14 303.92,6.02 304.23,5.71 304.67,5.71 304.97,6.02 304.97,6.14 305.15,6.32 305.65,6.32 306.27,5.71 310.1,5.71 311.25,4.56 312.66,4.56 312.84,4.38 312.84,3.39 313.15,3.08 313.58,3.08 313.89,3.39 313.89,4.41 314.04,4.56 314.42,4.56 314.57,4.41 314.57,3.84 314.8,3.61 315.3,3.61 315.46,3.76 316.6,3.76 316.73,3.64 316.73,3.38 316.6,3.26 315.57,3.26 315.17,2.86 315.17,2.25 315.51,1.91 318.48,1.91 321.61,5.04 325.9,5.04 326.6,5.74 331.01,5.74 331.23,5.96 331.48,5.96 331.88,6.36 331.88,6.37 CZ538.1
CNV_RF_RESET#: length 214.9
  TOP w0.102: UH1.BE16 174.62,35.96 174.51,35.85 174.06,35.85 173.83,36.08 172.54,36.08 171.92,35.47 171.18,35.47 170.93,35.72
  TOP w0.109: v2(334.97,11.25) 334.97,11 334.9,10.93 334.9,10.69 336.13,9.46 336.13,7.65 338.33,5.45 RZ3.1 338.74,5.06 338.8,5.12 339.21,5.12 v1(339.23,5.1) 339.23,4.7 QZ17.2 ; v2(170.36,35.26) RH617.1 170.66,35.98 170.93,35.72
  IN2 w0.081: v2(334.97,11.25) 334.97,11.18 334.54,10.75 330.82,10.75 330.02,11.54 328.01,11.54 324.75,8.28 323.54,8.28 321.7,6.45 315.55,6.45 314.56,7.43 313.09,7.43 312.24,6.58 307.28,6.58 306.1,7.75 290.41,7.75 289.4,6.74 288.19,6.74 287.87,7.07 287.87,8.18 286.31,9.74 285.17,9.74 284.11,10.8 278.38,10.8 275.05,14.14 275.05,14.14 273.11,16.07 272.37,16.07 270.7,17.74 269.6,17.74 268.04,19.3 265.37,19.3 263.91,20.76 244.77,20.76 243.01,19 233.11,19 230.73,21.38 v2(220.2,21.38)
  IN3 w0.081: v2(170.36,35.26) 170.36,35.12 171.76,33.73 174.13,33.73 174.69,34.28 174.69,39.19 174.41,39.47 174.41,40.99 175.99,42.58 177.72,42.58 178.13,42.99 192.91,42.99 193.14,43.22 195.46,43.22 196.85,41.82 196.85,38.11 199.27,35.7 199.27,33.16 200.45,31.98 205.42,31.98 210.24,27.16 211.59,27.16 213.82,24.93 217.55,24.93 220.2,22.27 v2(220.2,21.38)
CNV_RF_RESET#_R: length 6.2
  TOP w0.109: v1(336.77,1.72) 337.52,2.47 337.52,3.23 338.04,3.76 QZ17.3 337.74,4.16 337.27,3.69 RZ378.2 336.89,3.71 RZ531.2 337.42,5.06 RZ3.2
CNV_RGI_PRX_DTX: length 197.7
  TOP w0.089: UH1.AV3 178.24,42.07 178.24,42.75 178.21,42.78 178.21,43.54 177.94,43.81 177.94,44.51 176.89,45.55 176.89,45.6 176.88,45.61 176.88,45.77 175.87,46.78 174.6,46.78 v2(174.27,47.11)
  TOP w0.109: v2(318.74,11.28) v1(318.74,10.55)
  IN1 w0.102: v2(318.74,11.28) 318.74,11.02 317.74,10.02 315.6,10.02 315.16,10.46 312.4,10.46 311.14,11.72 307.63,11.72 306.88,10.96 300.3,10.96 297.93,13.33 296.63,13.33 295.88,12.59 295.88,11.49 295.59,11.19 291.3,11.19 290.18,12.31 289.36,12.31 284.97,16.7 280.1,16.7 279.61,16.21 277.25,16.21 275.79,14.75 267.69,14.75 261.33,21.1 259.08,21.1 255.84,24.34 237.32,24.34 235.93,22.95 v2(235.93,22.14)
  IN3 w0.081: v2(174.27,47.11) 174.27,45.5 175.03,44.75 176.22,44.75 176.56,44.41 179.3,44.41 179.45,44.56 183.19,44.56 184.55,45.91 187.3,45.91 188.13,46.75 195.31,46.75 197.77,44.29 197.77,42.95 199.06,41.66 199.06,40.51 200.19,39.38 200.19,38.93 200.04,38.78 200.04,37.08 200.42,36.69 201.03,36.69 202.25,35.48 203.68,35.48 209.75,29.4 210.64,29.4 212.51,27.54 213.37,27.54 215.01,25.89 232.18,25.89 v2(235.93,22.14)
  BOTTOM w0.109: v2(174.27,47.11) 173.79,46.63 173.27,46.63 RH613.2 ; v2(318.74,11.28) 318.62,11.4 318.62,12.32 318.01,12.93 318.01,14.14 318.86,14.99 318.86,15.22 319.71,16.07 319.71,18.91 320.19,19.39 320.19,21.41 320.62,21.84 321.82,21.84 322.11,21.54 322.48,21.54 RZ535.2
CNV_RGI_PTX_DRX: length 199.8
  TOP w0.089: v2(171.22,47.08) 171.47,46.83 171.75,46.83 173.12,45.45 174.99,45.45 175.29,45.75 175.89,45.75 176.16,45.47 176.16,45.07 176.88,44.36 176.88,42.3 176.48,41.9 UH1.BA4
  TOP w0.109: v2(319.43,15.2) 319.43,15.12 v1(319.93,14.62)
  IN1 w0.102: v2(233.85,22.13) 233.85,23.37 235.65,25.16 255.99,25.16 259.36,21.79 261.63,21.79 267.77,15.65 271.4,15.65 272.33,16.58 274.2,16.58 274.84,17.23 276.02,17.23 277.47,18.67 280.54,18.67 281.66,17.56 285.09,17.56 289.65,13 290.46,13 291.54,11.92 293.59,11.92 295.69,14.02 298.44,14.02 300.05,12.4 311.42,12.4 312.64,11.19 315.4,11.19 315.83,10.76 317.17,10.76 317.3,10.89 317.3,13.18 319.32,15.2 v2(319.43,15.2)
  IN3 w0.081: v2(171.22,47.08) 171.22,45.76 174.21,42.77 177.64,42.77 178.05,43.18 192.83,43.18 193.11,43.46 195.65,43.46 197.12,41.98 197.12,38.17 199.49,35.8 199.49,34.14 200.63,33.01 202.96,33.01 203.56,32.4 205.32,32.4 210.34,27.39 211.68,27.39 213.87,25.21 230.77,25.21 v2(233.85,22.13)
  BOTTOM w0.109: RH606.1 171.39,46.12 RH605.1 171.4,46.9 v2(171.22,47.08) ; v2(319.43,15.2) 319.43,15.25 319.95,15.78 319.95,18.82 320.43,19.29 320.43,21.29 320.74,21.6 321.51,21.6 322.02,21.09 RZ534.2
CNV_WT_RCOMP: length 10.3
  TOP w0.109: UH1.BA1 176.63,44.34 175.96,45.01 175.96,45.41 175.82,45.55 175.38,45.55 175.02,45.19
  TOP w0.152: RH612.2 170.41,47.63 170.41,47.07 v1(170.64,46.84) 170.93,46.55 171.66,46.55 173.02,45.19 175.02,45.19
COMP_1PH: length 4.5
  TOP w0.203: PU1100.50 261.78,148.46 260.95,149.29 v1(260.2,149.29) PC1107.2 259.37,150.13 PC1108.2
COMP_2PH: length 4
  TOP w0.203: PC1119.2 270.14,145.12 PC1117.2 268.99,144.84 267.86,144.84 267.77,144.93 PU1100.33
COMP_4PH: length 3.9
  TOP w0.203: PC1113.1 PR1133.1 257.68,145.95 258.56,145.95 v1(258.67,145.83) 259.17,145.33 PU1100.6
CONTACTLESS_DET#: length 53.5
  TOP w0.102: UH1.BG8 173.1,39.69 172.88,39.92
  TOP w0.109: 172.88,39.92 172.56,40.23 172.47,40.23 v2(171.78,40.93) 170.7,42 169.51,42 169.29,42.22 169.29,42.97 168.8,43.46 166.74,43.46 166.2,44.01 166.2,44.13 RH90.2 165.34,45.65 v1(164.86,46.13)
  IN3 w0.081: v2(179.65,23.85) 179.82,24.01 180.37,24.01 180.63,24.28 180.63,26.52 180.13,27.02 179.68,27.02 179.42,27.28 179.42,27.9 178.94,28.38 178.94,29.19 178.65,29.48 178.65,30.31 178.97,30.62 178.97,31.66 178.58,32.04 178.31,32.04 177.99,32.36 177.99,32.85 177.45,33.39 171.8,33.39 170.36,34.83 168.87,34.83 168.72,34.98 168.72,36.46 167.83,37.36 167.83,37.75 168.82,38.74 168.82,41.23 169.23,41.64 171.07,41.64 v2(171.78,40.93)
  BOTTOM w0.109: DZ8.2 181.02,17.81 179.75,17.81 179,18.56 179,18.73 178.5,19.23 178.5,20.48 177.93,21.05 177.93,21.92 178.67,22.66 179.03,22.66 179.65,23.28 v2(179.65,23.85)
CONTACTLESS_DET#_R: length 19.5
  TOP w0.109: v2(180.91,12.1) 180.91,11.87 180.59,11.54 178.85,11.54 176.43,9.13 176.43,8.53 175.86,7.96 175.86,5.48 177.71,3.64 177.71,3.11 177.6,3 JUSH1.4
  BOTTOM w0.109: v2(180.91,12.1) 181.09,12.28 181.09,14.44 181.29,14.65 181.29,15.93 DZ8.1 179.77,16.16 v1(179.72,16.11)
CORE_SW1:
  vias: v2(251.76,132.01) v2(252.27,132.37) v3(252.96,133.47)
CORE_SW2: length 0.7
  BOTTOM w0.109: v2(244.3,132.35) v1(244.3,131.64)
  vias: v2(244.91,132.34)
CORE_SW3: length 0.7
  BOTTOM w0.109: v2(236.67,132.4) v1(236.67,131.67)
  vias: v2(237.29,132.4)
CORE_SW4:
  vias: v1(229.1,129.47) v2(228.52,129.34) v2(228.68,129.92)
CPU_2_PCH_TRIGGER: length 95.8
  TOP w0.109: v2(199.76,85.05) 199.25,85.05 195.54,81.35 194.59,81.35 191.53,78.29 v1(190.49,78.29) 189.75,78.29 188.74,77.27 188.74,71.6 189.31,71.03 189.31,68.93 185.04,64.66 183.44,64.66 180.08,61.3 180.08,55.6 179.42,54.94 179.42,52.69 179.79,52.32 179.79,49.82 180.91,48.7 180.91,48.16 181.23,47.85 181.34,47.85 181.59,47.6 181.59,47.04 181.55,47 181.55,46.25 182.25,45.55 182.25,42.86 182.22,42.83 UH1.AK2
  IN2 w0.081: v2(224.4,103.86) 223.85,103.31 223.85,96.47 224.17,96.14 224.17,95.69 222.74,94.26 218.99,94.26 218.72,93.99 213.27,93.99 208.98,89.69 208.98,87.99 205.84,84.86 200.31,84.86 200.11,85.05 v2(199.76,85.05)
  BOTTOM w0.109: RC177.1 224.96,103.86 v2(224.4,103.86)
CPU_2_PCH_TRIGGER_R: length 3.8
  TOP w0.102: v2(224.34,102.88) 223.79,103.43 UC1.J23
  BOTTOM w0.109: v1(223.89,103.64) 223.89,103.33 v2(224.34,102.88) 224.78,103.32 225.33,103.32 RC177.2
CPU_24MHZ_R_D: length 100.7
  TOP w0.102: v2(220.84,110.43) 221.14,110.14 UC1.E31 ; v2(202.92,47.25) 202.69,47.01 202.38,47.01 RH169.1
  IN1 w0.102: v2(220.84,110.43) 220.65,110.43 220.58,110.36 220.58,110.09 220.73,109.94 221.84,109.94 222.36,109.43 223.77,109.43 224.82,108.37 225.63,107.57 225.63,103.73 225.19,103.3 223.37,103.3 222.95,103.72 219.32,103.72 218.97,103.37 217.54,103.37 209.32,95.16 209.32,89.51 204.72,84.91 204.01,84.91 187.72,68.61 187.72,62.58 190.18,60.12 192.66,60.12 193.02,60.48 194.43,60.48 195.97,58.94 195.97,57.92 196.4,57.49 197.28,57.49 199.09,55.68 199.09,54.29 199.76,53.62 200.72,53.62 201.13,53.21 201.13,48.57 202.18,47.51 202.18,47.35 202.58,46.96 202.75,46.96 202.92,47.13 v2(202.92,47.25)
CPU_24MHZ_R_D#: length 100.7
  TOP w0.102: UC1.D31 220.49,110.1 v2(220.18,110.41) ; RH170.1 202.38,46.82 202.69,46.82 v2(202.92,46.59)
  IN1 w0.102: v2(220.18,110.41) 220.39,110.2 220.39,110.01 220.65,109.75 221.76,109.75 222.28,109.24 223.69,109.24 225.44,107.49 225.44,103.81 225.11,103.49 223.44,103.49 223.03,103.9 219.24,103.9 218.9,103.56 217.46,103.56 209.14,95.23 209.14,89.59 204.64,85.09 203.93,85.09 187.53,68.69 187.53,62.5 190.1,59.94 192.74,59.94 193.1,60.29 194.35,60.29 195.78,58.86 195.78,57.85 196.32,57.3 197.2,57.3 198.9,55.61 198.9,54.21 199.68,53.43 200.64,53.43 200.94,53.13 200.94,48.49 202,47.43 202,47.28 202.28,46.99 202.5,46.77 202.74,46.77 v2(202.92,46.59)
CPU_C10_GATE#: length 281.3
  TOP w0.109: UZ61.2 195.18,88.28 195.66,87.8 RZ543.1 196.22,87.8 196.39,87.62 RH446.2 197.53,87.62 v2(197.98,88.08) 197.14,88.92 RC562.1 ; v2(174.17,48.89) 174.17,48.39 v1(173.57,47.79) 173.27,47.79 RH616.1
  IN3 w0.081: v2(219.67,30.38) 219.19,29.9 214.95,29.9 209.96,34.9 207.66,34.9 205.79,36.76 205.79,38.33 203.75,40.37 203.75,41.3 201.32,43.73 201.32,45.86 199.37,47.81 198.98,47.81 197.78,49.01 197.78,49.24 197.46,49.56 197.46,50.6 196.32,51.74 195.06,51.74 194.22,52.58 194.22,53.6 192.68,55.15 186.37,55.15 185.76,55.76 v2(179.59,55.76)
  IN4 w0.102: v2(269.5,98.66) 269.5,97.45 269.86,97.09 270.94,97.09 271.36,97.51 274.11,97.51 275.54,96.08 276.19,96.08 282.73,89.54 283.91,89.54 284.26,89.19 284.26,85.27 283.81,84.81 282.16,84.81 281.69,84.35 281.69,80.62 281.93,80.38 281.93,79.35 282.25,79.03 282.25,77.77 283.45,76.56 288.94,76.56 290.08,75.42 290.08,73.12 293.08,70.12 293.08,66.17 293.88,65.36 293.88,55.76 289.66,51.54 289.66,46.22 287.78,44.34 283.29,44.34 278.7,39.75 278.7,26.95 277.63,25.88 270.77,25.88 269.96,25.07 256.41,25.07 253.57,27.91 253.57,28.48 252.49,29.56 250.89,29.56 249.2,31.25 229.64,31.25 228.77,30.38 v2(219.67,30.38)
  BOTTOM w0.109: v2(197.98,88.08) 198.48,87.58 198.48,84.62 197.45,83.59 195.28,83.59 188.82,77.13 188.82,72.21 186.86,70.24 186.86,66.45 183.18,62.78 181.53,62.78 180.26,61.51 180.26,56.43 v2(179.59,55.76) 179.59,55.07 177.75,53.23 177.75,52.58 176,50.83 176,49.56 175.74,49.3 174.57,49.3 v2(174.17,48.89)
  BOTTOM w0.254: PR309.1 269.04,99.22 269.5,98.76 v2(269.5,98.66)
CPU_DP1_AUXN: length 255.6
  TOP w0.076: UC1.E27 221.14,106.8 221.44,106.49 221.45,106.49 v2(221.46,106.49)
  TOP w0.102: CV877.1 75.36,31.77 75.7,31.77 76.29,32.36 v4(76.29,33.01) 76.29,34.59 76.33,34.63 76.33,35.31 76.29,35.35 76.29,37.6 76.73,38.04 77.96,38.04 78.83,38.91 78.83,39.51 79.76,40.44 79.76,42.78 80.75,43.77 80.75,46.31 81.3,46.86 v2(81.3,47.74)
  IN2 w0.094: v2(221.46,106.49) 221.7,106.25 221.81,106.25 221.88,106.32 221.88,106.6 221.96,106.68 223.07,106.68 223.33,106.94 223.33,107.6 223.15,107.78 223.15,108.41 223.79,109.05 225.44,109.05 226.12,109.73 226.12,114.21 225.8,114.52 225.8,116.97 226.04,117.21 226.04,118.07 223.02,121.09 220.7,121.09 219.75,120.13 213.44,120.13 207.12,126.45 205.86,126.45 204.71,127.6 198.01,127.6 196.35,125.94 196.35,120.84 193.98,118.47 189.22,118.47 186.61,115.86 186.61,110.7 185.73,109.82 185.73,107.12 183.93,105.32 183.93,100.26 183.43,99.76 183.43,95.43 183.42,95.42 183.42,95.41 183.38,95.37 183.38,86.06 183.9,85.54 183.9,83.43 182.19,81.72 182.19,75.44 181.35,74.61 181.35,71.03 176.89,66.57 175.66,66.57 163.99,54.9 163.99,53.73 157.74,47.48 156.97,47.48 156.66,47.79 154.86,47.79 154.15,47.08 139.68,47.08 139.37,46.77 137.24,46.77 136.68,47.33 135.2,47.33 134.01,48.52 131.17,48.52 128.94,46.29 126.19,46.29 124.33,44.43 123.38,44.43 123.06,44.1 118.03,44.1 116.24,45.9 116.24,46.82 115.55,47.52 110.78,47.52 110.1,48.2 108.64,48.2 107.5,47.06 104.18,47.06 103.02,45.9 99.55,45.9 98.68,46.78 97.01,46.78 96.54,46.31 89.96,46.31 88.59,44.93 86.01,44.93 83.69,47.26 81.11,47.26 81.03,47.34 81.03,47.53 81.1,47.61 v2(81.3,47.74)
CPU_DP1_AUXN_C: length 3.1
  TOP w0.102: CV877.2 74.13,31.79 73.86,31.79 v4(73.47,32.18) 72.85,32.79 72.38,32.79 72.29,32.71 UV66.59
CPU_DP1_AUXP: length 255.5
  TOP w0.076: UC1.D27 220.49,106.81 220.81,106.49 220.82,106.49 v2(220.82,106.49)
  TOP w0.102: CV876.1 75.4,32 75.44,31.96 75.62,31.96 76.1,32.44 76.1,32.68 76.06,32.72 76.06,33.3 76.1,33.34 v4(76.1,35.02) 76.1,37.68 76.66,38.23 77.88,38.23 78.64,38.99 78.64,39.59 79.57,40.52 79.57,42.86 80.56,43.85 80.56,46.39 81.11,46.94 81.11,47.35 80.8,47.65 v2(80.58,47.74)
  IN2 w0.094: v2(220.82,106.49) 221.36,106.87 222.99,106.87 223.13,107.02 223.13,107.52 222.95,107.7 222.95,108.49 223.71,109.25 225.36,109.25 225.92,109.81 225.92,114.13 225.61,114.44 225.61,117.05 225.85,117.29 225.85,117.99 222.94,120.89 220.78,120.89 219.83,119.93 213.36,119.93 207.04,126.26 205.78,126.26 204.63,127.4 198.09,127.4 196.54,125.86 196.54,120.76 194.06,118.27 189.3,118.27 186.8,115.78 186.8,110.62 185.92,109.74 185.92,107.04 184.12,105.24 184.12,100.18 183.62,99.68 183.62,95.35 183.58,95.3 183.58,86.14 184.09,85.62 184.09,83.35 182.38,81.64 182.38,75.36 181.54,74.53 181.54,70.95 176.97,66.37 175.74,66.37 164.18,54.82 164.18,53.65 157.82,47.28 156.89,47.28 156.58,47.6 154.94,47.6 154.23,46.89 139.76,46.89 139.45,46.57 137.16,46.57 136.6,47.14 135.11,47.14 133.93,48.32 131.25,48.32 129.02,46.1 126.27,46.1 124.41,44.23 123.47,44.23 123.14,43.91 117.95,43.91 116.04,45.82 116.04,46.74 115.47,47.32 110.7,47.32 110.02,48 108.72,48 107.58,46.86 104.26,46.86 103.1,45.71 99.47,45.71 98.6,46.58 97.09,46.58 96.62,46.11 90.04,46.11 88.67,44.74 85.93,44.74 83.61,47.06 81.03,47.06 80.83,47.26 80.83,47.49 v2(80.58,47.74)
CPU_DP1_AUXP_C: length 3.2
  TOP w0.102: CV876.2 74.1,31.98 73.94,31.98 73.84,32.08 73.84,32.13 73.43,32.54 73.38,32.54 72.93,32.99 72.37,32.99 72.24,33.11 UV66.60
CPU_DP1_N0: length 241.7
  TOP w0.102: v2(224.8,115.14) 224.88,115.23 224.88,115.36 224.68,115.56 224.32,115.56 223.99,115.24 223.99,113.23 224.04,113.19 224.17,113.19 224.33,113.35 224.33,113.52 UC1.K37 ; CV869.2 63.34,40.38 63.34,41.74 v2(63.12,41.95)
  IN2 w0.094: v2(63.12,41.95) 63.29,41.78 63.29,41.53 63.59,41.24 64.53,41.24 65.25,41.97 66.49,41.97 67.53,43.01 67.53,46.02 69,47.49 70.05,47.49 70.78,48.22 73.14,48.22 74.19,49.27 77.98,49.27 80.81,46.44 83.38,46.44 85.67,44.14 88.92,44.14 90.25,45.47 96.46,45.47 96.84,45.08 106.5,45.08 107.5,44.08 114.71,44.08 115.5,43.29 125.53,43.29 127.72,45.48 129.45,45.48 130.82,46.85 133.14,46.85 133.62,46.38 136.4,46.38 137.07,45.71 139.56,45.71 139.9,46.05 142.19,46.05 142.77,45.47 150.78,45.47 151.55,44.7 152.45,44.7 153.99,46.24 154.85,46.24 155.13,45.96 157.34,45.96 164.93,53.55 164.93,54.68 175.96,65.72 177.2,65.72 184.02,72.54 184.02,82.21 184.7,82.88 184.7,85.88 184.19,86.38 184.19,90.8 184.72,91.33 184.72,93.47 184.22,93.97 184.22,99.07 184.73,99.58 184.73,104.98 186.54,106.79 186.54,109.51 191.04,114 191.04,114.51 192.22,115.69 192.62,115.69 193.35,116.41 193.35,116.72 194.61,117.98 196.29,117.98 199.09,120.78 200.35,120.78 203.18,123.61 207.71,123.61 209.32,122 210.36,122 213.02,119.34 220.15,119.34 221.07,120.27 222.64,120.27 224.95,117.95 224.95,117.02 223.95,116.02 223.95,115.65 224.22,115.38 224.56,115.38 v2(224.8,115.14)
CPU_DP1_N0_C: length 4.8
  TOP w0.102: CV869.1 63.34,39.08 63.34,38.87 63.84,38.37 64.57,38.37 v4(65.5,37.44) 65.76,37.18 65.76,36.72 65.66,36.62 UV66.15
CPU_DP1_N1: length 241.8
  TOP w0.094: v2(223.89,111.88) 223.63,111.61 UC1.J34
  TOP w0.102: CV871.2 61.56,40.38 61.56,41.74 v2(61.36,41.94)
  IN2 w0.094: v2(223.89,111.88) 223.74,112.03 223.5,112.03 222.94,112.59 222.94,115.88 224.32,117.26 224.32,117.72 222.56,119.48 221.25,119.48 220.5,118.72 212.74,118.72 211.08,120.38 210.09,120.38 207.46,123.01 203.43,123.01 200.6,120.18 199.36,120.18 195.81,116.63 194.68,116.63 193.24,115.19 193.24,114.78 192.93,114.48 192.53,114.48 192.1,114.05 192.1,113.1 189.31,110.31 188.87,110.31 187.33,108.77 187.33,106.71 185.92,105.3 185.92,99.43 184.81,98.31 184.81,94.22 185.34,93.68 185.34,82.6 185.14,82.4 185.14,78.6 184.8,78.26 184.8,72.47 177.4,65.07 176.17,65.07 165.59,54.49 165.59,53.37 157.52,45.3 155.82,45.3 154.99,44.47 154.11,44.47 153.64,44 152.95,44 152.43,43.48 151.79,43.48 150.5,44.77 141.84,44.77 141.1,44.03 139.23,44.03 138.68,44.58 137.96,44.58 137.42,44.04 128.56,44.04 125.18,40.65 118.68,40.65 118.53,40.49 116.09,40.49 113.12,43.46 101.48,43.46 100.47,44.47 96.62,44.47 96.24,44.85 90.47,44.85 89.17,43.55 85.11,43.55 83.97,44.68 82.05,44.68 80.89,45.84 80.53,45.84 78.35,48.02 73.95,48.02 73.56,47.63 71.3,47.63 69.15,45.48 68.92,45.48 68.13,44.68 68.13,42.76 66.74,41.37 65.5,41.37 64.77,40.64 63.34,40.64 62.78,41.21 61.89,41.21 61.55,41.54 61.55,41.74 v2(61.36,41.94)
CPU_DP1_N1_C: length 5.3
  TOP w0.102: UV66.18 64.46,36.63 64.56,36.74 64.56,37.09 64.06,37.59 63.73,37.59 62.74,38.59 v4(62.37,38.59) 61.88,38.59 61.56,38.9 61.56,39.07 CV871.1
CPU_DP1_N2: length 239.5
  TOP w0.102: v2(59.53,41.94) 59.74,41.72 59.74,40.34 CV873.2 ; v2(222.13,118.29) 222.34,118.08 222.34,116.81 222.52,116.64 222.52,113.85 222.41,113.74 222.41,113.33 222.71,113.02 UC1.H36
  IN2 w0.094: v2(59.53,41.94) 59.81,41.65 59.81,41.47 60.04,41.24 61.01,41.24 61.64,40.61 62.53,40.61 63.12,40.02 65,40.02 65.75,40.78 66.98,40.78 68.73,42.53 68.73,44.22 71.52,47.01 76.96,47.01 77.43,46.53 79,46.53 80.28,45.25 80.64,45.25 81.82,44.07 83.58,44.07 84.7,42.95 89.42,42.95 90.7,44.23 95.93,44.23 96.29,43.87 100.21,43.87 101.22,42.86 111.32,42.86 113.38,40.8 114.82,40.8 115.81,39.81 119.79,39.81 120.02,40.04 125.44,40.04 128.71,43.31 136.42,43.31 137.24,42.49 139.05,42.49 139.87,43.31 150.58,43.31 151.03,42.85 152.67,42.85 153.21,43.39 154.01,43.39 154.49,43.88 155.33,43.88 156.07,44.62 157.68,44.62 166.29,53.23 166.29,54.32 176.36,64.39 177.89,64.39 181.11,67.61 181.5,67.61 185.42,71.52 185.42,77.99 185.75,78.33 185.75,82.16 185.99,82.4 185.99,90.77 186.49,91.27 186.49,92.52 186.17,92.84 186.17,93.85 185.41,94.61 185.41,98.07 186.54,99.19 186.54,105.05 188.2,106.72 188.2,107.75 189.55,109.09 189.55,109.65 193.84,113.94 193.84,114.41 194.88,115.45 195.51,115.45 199.59,119.53 200.8,119.53 203.66,122.39 206.92,122.39 211.68,117.63 220.28,117.63 221.5,118.85 222.16,118.85 222.32,118.69 222.32,118.48 v2(222.13,118.29)
CPU_DP1_N2_C: length 5.9
  TOP w0.102: UV66.21 63.26,36.65 63.36,36.76 63.36,36.95 62.89,37.42 62.89,37.48 62.47,37.9 61.66,37.9 v4(61.04,38.52) 60.71,38.85 59.99,38.85 59.78,39.07 59.78,39.34 59.68,39.43 CV873.1
CPU_DP1_N3: length 244.4
  TOP w0.102: v2(57.75,41.91) 57.96,41.7 57.96,40.33 CV875.2 ; UC1.J38 223.17,114.13 223.03,114.13 222.95,114.21 222.95,114.42 223.05,114.52 223.29,114.52 223.36,114.58 223.36,114.82 223.2,114.97 223.2,116.93 v2(223,117.12)
  IN2 w0.094: v2(223,117.12) 223.17,117.28 223.17,117.42 223.07,117.52 221.8,117.52 221.3,117.02 211.34,117.02 206.57,121.79 203.91,121.79 201.05,118.93 199.84,118.93 193.06,112.15 193.06,109.87 191.02,107.83 191.02,107.41 190.29,106.68 189.16,106.68 187.19,104.7 187.19,98.98 186.83,98.62 186.83,93.07 187.52,92.38 187.52,91.35 187.12,90.95 187.12,85.4 187.49,85.03 187.49,83.27 188.49,82.27 188.49,77.74 187.63,76.87 187.63,74.77 186.35,73.5 186.35,71.49 181.8,66.94 181.4,66.94 175.82,61.36 174.22,61.36 166.98,54.12 166.98,52.97 163.53,49.53 163.53,48.65 161.36,46.48 160.43,46.48 157.97,44.02 156.32,44.02 155.56,43.26 154.86,43.26 153.66,42.06 141.65,42.06 141.11,42.6 140.27,42.6 138.58,40.92 137.1,40.92 135.41,42.6 129.08,42.6 125.73,39.25 120.48,39.25 119.01,37.78 116.37,37.78 115.01,39.14 115.01,39.74 114.6,40.15 105.4,40.15 104.16,41.39 101.82,41.39 101.53,41.67 100.82,41.67 100.46,42.03 100.46,42.73 99.92,43.26 96.03,43.26 95.67,43.63 90.96,43.63 89.69,42.36 84.43,42.36 83.32,43.47 81.59,43.47 80.4,44.65 79.94,44.65 79.69,44.9 77.02,44.9 75.56,46.37 71.72,46.37 70.92,45.57 70.92,44.26 70.07,43.4 69.92,43.4 69.36,42.84 69.36,42.31 67.23,40.18 65.99,40.18 65.23,39.42 62.88,39.42 62.28,40.02 61.39,40.02 60.77,40.64 59.78,40.64 59.31,41.11 58.29,41.11 58,41.4 58,41.65 v2(57.75,41.91)
CPU_DP1_N3_C: length 6.7
  TOP w0.102: CV875.1 58.08,39 58.08,38.95 58.4,38.63 58.7,38.63 58.72,38.61 v4(58.97,38.61) 59.37,38.61 59.73,38.26 60.46,38.26 61.63,37.09 62.38,37.09 62.56,36.9 62.56,36.76 62.46,36.65 UV66.23
CPU_DP1_P0: length 241.7
  TOP w0.102: v2(63.75,41.95) 63.53,41.73 63.53,40.36 CV868.2 ; UC1.K36 224.21,113 223.96,113 223.8,113.15 223.8,115.32 224.24,115.75 224.67,115.75 v2(224.83,115.91)
  IN2 w0.094: v2(63.75,41.95) 63.71,41.99 63.6,41.99 63.49,41.88 63.49,41.61 63.67,41.43 64.44,41.43 65.17,42.16 66.41,42.16 67.34,43.09 67.34,46.1 68.92,47.68 69.97,47.68 70.7,48.42 73.06,48.42 74.11,49.47 78.06,49.47 80.89,46.63 83.46,46.63 85.75,44.34 88.84,44.34 90.17,45.67 96.54,45.67 96.92,45.28 106.58,45.28 107.58,44.27 114.79,44.27 115.58,43.49 125.45,43.49 127.63,45.67 129.37,45.67 130.74,47.05 133.22,47.05 133.7,46.57 136.48,46.57 137.15,45.91 139.48,45.91 139.82,46.24 142.27,46.24 142.85,45.66 150.86,45.66 151.63,44.89 152.37,44.89 153.91,46.44 154.93,46.44 155.21,46.16 157.26,46.16 164.73,53.63 164.73,54.76 175.88,65.92 177.12,65.92 183.82,72.62 183.82,82.29 184.5,82.97 184.5,85.8 184,86.3 184,90.88 184.52,91.41 184.52,93.39 184.02,93.89 184.02,99.15 184.54,99.66 184.54,105.06 186.35,106.87 186.35,109.59 190.84,114.08 190.84,114.59 192.14,115.88 192.54,115.88 193.15,116.49 193.15,116.8 194.53,118.18 196.21,118.18 199.01,120.97 200.27,120.97 203.1,123.8 207.79,123.8 209.4,122.19 210.44,122.19 213.1,119.53 220.07,119.53 220.99,120.46 222.72,120.46 225.15,118.03 225.15,116.94 224.14,115.94 224.14,115.73 224.3,115.57 224.59,115.57 224.83,115.81 v2(224.83,115.91)
CPU_DP1_P0_C: length 4.8
  TOP w0.102: CV868.1 63.53,39.09 63.53,38.95 63.87,38.61 v4(64.23,38.61) 64.6,38.61 65.45,37.76 65.49,37.76 65.95,37.3 65.95,36.73 66.06,36.63 UV66.14
CPU_DP1_P1: length 241.8
  TOP w0.094: UC1.J35 223.85,112.61 v2(223.87,112.61)
  TOP w0.102: CV870.2 61.75,40.36 61.75,41.75 v2(61.94,41.94)
  IN2 w0.094: v2(223.87,112.61) 223.95,112.52 223.95,112.41 223.77,112.22 223.58,112.22 223.14,112.67 223.14,115.8 224.52,117.18 224.52,117.8 222.64,119.67 221.17,119.67 220.42,118.92 212.82,118.92 211.16,120.58 210.17,120.58 207.54,123.21 203.35,123.21 200.52,120.38 199.28,120.38 195.73,116.83 194.6,116.83 193.04,115.27 193.04,114.86 192.85,114.67 192.45,114.67 191.9,114.13 191.9,113.18 189.23,110.51 188.79,110.51 187.14,108.86 187.14,106.79 185.73,105.38 185.73,99.51 184.61,98.4 184.61,94.13 185.15,93.6 185.15,82.69 184.94,82.48 184.94,78.68 184.61,78.34 184.61,72.55 177.32,65.27 176.08,65.27 165.39,54.58 165.39,53.45 157.44,45.5 155.73,45.5 154.91,44.67 154.03,44.67 153.56,44.2 152.87,44.2 152.35,43.68 151.87,43.68 150.58,44.96 141.76,44.96 141.02,44.23 139.31,44.23 138.76,44.78 137.88,44.78 137.34,44.24 128.48,44.24 125.09,40.85 118.6,40.85 118.44,40.69 116.17,40.69 113.2,43.66 101.56,43.66 100.55,44.67 96.7,44.67 96.32,45.04 90.39,45.04 89.09,43.74 85.19,43.74 84.05,44.88 82.13,44.88 80.97,46.04 80.61,46.04 78.43,48.22 73.87,48.22 73.48,47.82 71.22,47.82 69.07,45.68 68.84,45.68 67.93,44.77 67.93,42.84 66.65,41.57 65.42,41.57 64.69,40.84 63.42,40.84 62.86,41.4 61.97,41.4 61.75,41.62 61.75,41.75 v2(61.94,41.94)
CPU_DP1_P1_C: length 5.3
  TOP w0.102: UV66.17 64.86,36.63 64.75,36.74 64.75,37.17 64.14,37.78 63.81,37.78 62.78,38.82 61.92,38.82 61.75,38.98 61.75,39.1 CV870.1
CPU_DP1_P2: length 239.5
  TOP w0.102: v2(222.72,118.29) 222.53,118.11 222.53,116.89 222.71,116.71 222.71,113.99 222.79,113.91 222.98,113.91 223.13,113.76 223.13,113.53 223.03,113.43 222.85,113.43 UC1.H37 ; CV872.2 59.93,40.4 59.93,41.71 v2(60.17,41.95)
  IN2 w0.094: v2(60.17,41.95) 60.01,41.79 60.01,41.55 60.12,41.44 61.09,41.44 61.72,40.81 62.61,40.81 63.2,40.22 64.91,40.22 65.67,40.97 66.9,40.97 68.54,42.61 68.54,44.3 71.44,47.2 77.04,47.2 77.52,46.72 79.08,46.72 80.36,45.44 80.73,45.44 81.91,44.26 83.66,44.26 84.78,43.15 89.34,43.15 90.62,44.42 96.01,44.42 96.37,44.07 100.29,44.07 101.3,43.05 111.4,43.05 113.46,40.99 114.91,40.99 115.89,40 119.7,40 119.94,40.24 125.36,40.24 128.62,43.51 136.5,43.51 137.32,42.69 138.97,42.69 139.79,43.51 150.66,43.51 151.12,43.05 152.59,43.05 153.13,43.59 153.93,43.59 154.41,44.07 155.25,44.07 155.99,44.81 157.6,44.81 166.1,53.31 166.1,54.4 176.28,64.58 177.81,64.58 181.03,67.81 181.42,67.81 185.22,71.6 185.22,78.07 185.56,78.41 185.56,82.24 185.8,82.48 185.8,90.85 186.29,91.35 186.29,92.44 185.98,92.76 185.98,93.77 185.21,94.53 185.21,98.15 186.34,99.27 186.34,105.13 188.01,106.8 188.01,107.83 189.35,109.17 189.35,109.73 193.65,114.03 193.65,114.49 194.8,115.64 195.43,115.64 199.51,119.73 200.72,119.73 203.58,122.59 207,122.59 211.76,117.83 220.2,117.83 221.42,119.05 222.24,119.05 222.52,118.77 222.52,118.49 v2(222.72,118.29)
CPU_DP1_P2_C: length 5.9
  TOP w0.102: CV872.1 60.06,39.43 59.97,39.35 59.97,39.15 60.07,39.04 60.85,39.04 61.44,38.44 61.44,38.39 61.74,38.09 62.55,38.09 v4(63.34,37.3) 63.55,37.09 63.55,36.75 63.66,36.64 UV66.20
CPU_DP1_P3: length 244.4
  TOP w0.102: UC1.J37 223.5,114.04 223.55,114.08 223.55,114.9 223.39,115.05 223.39,116.92 v2(223.59,117.12) ; CV874.2 58.15,40.4 58.15,41.72 v2(58.35,41.91)
  IN2 w0.094: v2(223.59,117.12) 223.36,117.35 223.36,117.5 223.15,117.71 221.71,117.71 221.22,117.22 211.42,117.22 206.66,121.99 203.83,121.99 200.97,119.13 199.76,119.13 192.86,112.23 192.86,109.95 190.82,107.91 190.82,107.49 190.21,106.87 189.08,106.87 186.99,104.78 186.99,99.06 186.63,98.7 186.63,92.99 187.33,92.3 187.33,91.43 186.92,91.03 186.92,85.32 187.29,84.95 187.29,83.19 188.29,82.19 188.29,77.82 187.43,76.95 187.43,74.85 186.16,73.58 186.16,71.57 181.72,67.14 181.32,67.14 175.74,61.56 174.14,61.56 166.78,54.21 166.78,53.06 163.34,49.61 163.34,48.73 161.28,46.67 160.35,46.67 157.89,44.21 156.24,44.21 155.48,43.45 154.77,43.45 153.57,42.25 141.73,42.25 141.19,42.8 140.18,42.8 138.5,41.11 137.18,41.11 135.49,42.8 129,42.8 125.65,39.45 120.4,39.45 118.93,37.97 116.45,37.97 115.21,39.22 115.21,39.82 114.68,40.35 105.48,40.35 104.25,41.58 101.9,41.58 101.61,41.87 100.9,41.87 100.65,42.11 100.65,42.81 100.01,43.46 96.11,43.46 95.75,43.82 90.88,43.82 89.61,42.55 84.51,42.55 83.4,43.66 81.67,43.66 80.48,44.85 80.02,44.85 79.78,45.1 77.1,45.1 75.64,46.56 71.64,46.56 70.73,45.65 70.73,44.34 69.99,43.6 69.84,43.6 69.16,42.92 69.16,42.39 67.15,40.38 65.91,40.38 65.15,39.62 62.96,39.62 62.36,40.21 61.47,40.21 60.85,40.84 59.86,40.84 59.39,41.3 58.38,41.3 58.2,41.48 58.2,41.77 v2(58.35,41.91)
CPU_DP1_P3_C: length 6.6
  TOP w0.102: CV874.1 58.27,39.17 58.27,39.03 58.48,38.82 58.62,38.82 58.65,38.85 59.4,38.85 59.81,38.45 60.54,38.45 61.67,37.32 v4(61.98,37.32) 62.42,37.32 62.75,36.98 62.75,36.76 62.86,36.65 UV66.22
CPU_DP2_AUXN: length 70
  TOP w0.076: v2(220.81,105.74) 221.14,106.06 UC1.E26
  TOP w0.102: CV74.1 191.58,124.81 191.58,125.29 191.89,125.59 193.21,125.59 193.25,125.63 193.83,125.63 193.87,125.59 194.38,125.59 195.41,124.56 197.06,124.56 v2(197.21,124.72)
  IN4 w0.076: 222.07,105.54 222.05,105.53 222.03,105.53 221.7,105.21 221.22,105.21 221.03,105.39 v2(220.81,105.74)
  IN4 w0.102: 222.07,105.54 226.24,109.72 226.24,114.15 225.82,114.58 225.82,116.64 226.02,116.85 226.02,118.22 223.15,121.09 223.15,121.93 222.65,122.43 222.15,122.43 221.67,122.91 221.67,128.36 220.03,130 220.03,131.91 217.69,134.24 209.08,134.24 207.54,132.7 202.81,132.7 199.98,129.88 199.98,127.4 198.11,125.52 198.11,124.93 197.9,124.72 v2(197.21,124.72)
CPU_DP2_AUXN_C: length 2.5
  TOP w0.102: CV74.2 191.63,123.61 191.63,123.4 191.59,123.36 191.59,122.81 191.63,122.78 191.63,122.32 191.44,122.13 UV8.25
CPU_DP2_AUXP: length 70
  TOP w0.076: v2(221.46,105.74) 221.46,105.75 UC1.F26
  TOP w0.102: v2(197.21,124.03) 197.21,124.08 196.92,124.37 195.33,124.37 194.3,125.4 v4(193.54,125.4) 191.96,125.4 191.77,125.21 191.77,124.62 191.86,124.53 CV73.1
  IN4 w0.076: 221.93,105.68 221.92,105.66 221.92,105.64 221.64,105.36 221.28,105.36 221.17,105.47 221.17,105.87 221.22,105.92 221.39,105.92 221.46,105.85 v2(221.46,105.74)
  IN4 w0.102: v2(197.21,124.03) 197.21,124.25 197.27,124.31 197.44,124.31 197.65,124.53 197.97,124.53 198.3,124.85 198.3,125.44 200.17,127.32 200.17,129.8 202.89,132.51 207.62,132.51 209.16,134.05 217.62,134.05 219.84,131.83 219.84,129.92 221.48,128.28 221.48,122.83 222.07,122.24 222.58,122.24 222.96,121.86 222.96,121.02 225.84,118.14 225.84,116.93 225.63,116.72 225.63,114.5 226.06,114.07 226.06,109.8 221.93,105.68
CPU_DP2_AUXP_C: length 2.4
  TOP w0.102: UV8.24 191.84,122.2 191.82,122.22 v4(191.82,123.07) 191.82,123.58 CV73.2
CPU_DP2_N0: length 78.2
  TOP w0.094: v2(223.12,111.3) 223.05,111.3 UC1.H33
  TOP w0.102: v2(200.5,124.06) 200.72,124.06 200.97,123.81 200.97,123.13 201.36,122.75 201.41,122.69 202.04,122.69 202.88,123.53 203.76,123.53 203.92,123.37 203.92,123.2 202.95,122.23 202.46,122.23 201.75,121.52 201.75,121.24 200.97,120.46 200.97,119.4 200.03,118.46 200.03,115.93 199.54,115.45 197.33,115.45 197.16,115.28 196.82,115.28 CV66.1
  IN4 w0.102: v2(200.5,124.06) 200.72,124.28 200.72,125.65 200.38,125.99 200.38,126.9 201.04,127.57 201.04,127.91 201.7,128.57 201.7,128.77 201.12,129.35 201.12,129.7 201.37,129.96 201.73,129.96 202.31,129.38 202.51,129.38 202.65,129.52 202.65,130.24 202.9,130.49 203.26,130.49 203.51,130.24 203.51,129.52 203.65,129.38 203.9,129.38 204.14,129.38 205.67,129.38 205.8,129.5 205.8,130.62 205.68,130.73 204.3,130.73 203.97,131.07 203.97,131.58 204.27,131.88 206.69,131.88 207.7,130.87 207.7,129.41 208.31,128.8 208.31,128.06 209.88,126.49 211.24,126.49 211.93,125.8 211.93,121.09 213.01,120.01 219.35,120.01 219.49,120.15 219.49,120.68 219.74,120.93 220.1,120.93 220.35,120.68 220.35,120.15 220.49,120.01 220.69,120.01 220.83,120.15 220.83,120.68 221.08,120.93 221.44,120.93 221.69,120.68 221.69,120.15 222.15,119.69 222.77,119.69 223.03,119.95 223.39,119.95 223.64,119.7 223.64,119.35 223.45,119.16 223.45,118.96 223.6,118.82 223.8,118.82 223.98,119 224.34,119 224.59,118.75 224.59,118.4 224.4,118.21 224.4,118.01 224.66,117.76 224.66,116.68 223.49,115.51 223.49,111.67 v2(223.12,111.3)
CPU_DP2_N0_C: length 2.4
  TOP w0.102: CV66.2 195.5,115.32 195.29,115.32 195.25,115.36 194.76,115.36 194.47,115.65 194.28,115.65 194.17,115.75 UV8.7
CPU_DP2_N1: length 77.8
  TOP w0.076: UC1.G38 221.98,114.22 221.91,114.29 221.91,114.51 222.08,114.68 222.08,115.06 222.1,115.08 222.1,115.1
  TOP w0.102: v2(199.51,123.46) 199.98,122.99 199.98,122.98 200.12,122.84 200.12,122.33 200.37,122.07 200.98,122.07 201.12,121.93 201.12,121.73 200.98,121.59 200.37,121.59 200.12,121.34 200.12,119.53 199.39,118.8 199.39,118.25 199.25,118.11 198.98,118.11 198.73,117.86 198.73,117.5 198.98,117.25 199.25,117.25 199.39,117.11 199.39,116.72 199.19,116.52 198.72,116.52 198.48,116.77 CV68.1 ; 222.1,115.1 222.1,115.53 221.85,115.77 221.36,115.77 v2(221.09,116.04)
  IN4 w0.102: v2(221.09,116.04) 221.49,115.65 221.93,115.65 222.23,115.96 222.23,116.66 220.8,118.09 220.8,118.45 221.21,118.85 221.21,119.05 221.07,119.2 220.87,119.2 220.46,118.79 220.11,118.79 219.92,118.98 212.86,118.98 210.79,121.05 210.79,122.53 210.5,122.82 210.5,123.18 211.14,123.82 211.14,125.38 210.98,125.53 210.7,125.53 210.48,125.31 210.48,123.85 210.15,123.52 209.8,123.52 208.56,124.76 208.56,125.11 208.84,125.4 208.84,125.6 208.7,125.74 208.5,125.74 208.22,125.45 207.73,125.45 207.17,126.02 207.17,126.36 207.48,126.67 208.07,126.67 208.21,126.82 208.21,127.02 208.07,127.16 207.69,127.16 207.43,127.41 207.43,128.33 207.23,128.53 206.63,128.53 206.36,128.27 206.36,125.47 206.11,125.22 205.58,125.22 205.35,125.45 205.35,128.36 205.14,128.57 204.69,128.57 204.44,128.33 204.44,125.41 204.19,125.16 203.84,125.16 203.59,125.41 203.59,128.37 203.4,128.56 202.85,128.56 202.64,128.35 202.64,127.48 202.38,127.23 201.84,127.23 201.7,127.09 201.7,126.89 201.84,126.75 202.38,126.75 202.64,126.5 202.64,126.12 202.35,125.83 201.7,125.83 201.56,125.69 201.56,125.49 201.7,125.35 202.23,125.35 202.4,125.18 202.4,122.6 202.15,122.35 201.55,122.35 201.3,122.6 201.3,122.9 201.16,123.04 200.96,123.04 200.82,122.9 200.82,122.6 200.56,122.35 200.14,122.35 199.84,122.65 199.84,123.13 v2(199.51,123.46)
CPU_DP2_N1_C: length 4.2
  TOP w0.102: CV68.2 197.26,116.63 v4(196.78,116.63) 196.12,116.63 195.9,116.85 195.57,116.85 195.53,116.88 195.04,116.88 195,116.85 194.55,116.85 194.45,116.95 UV8.10
CPU_DP2_N2: length 76.7
  TOP w0.076: UC1.F35 221.6,111.94 v2(221.55,111.94)
  TOP w0.102: CV70.1 196.8,118.2 197.88,118.2 199.49,119.82 199.49,121.96 198.82,122.63 198.82,123.62 198.69,123.75 198.46,123.75 198.35,123.86 v2(198.35,124.09)
  IN4 w0.102: v2(221.55,111.94) 221.91,112.3 221.91,113.61 220.46,115.06 220.46,117.46 219.55,118.37 219.35,118.37 219.21,118.22 219.21,118.02 219.87,117.37 219.87,116.24 219.66,116.03 219.19,116.03 218.95,116.27 218.95,117.07 217.78,118.24 211.64,118.24 211.39,118.49 211.39,119.57 211.25,119.7 211.05,119.7 210.91,119.55 210.91,118.49 210.65,118.24 210.3,118.24 210.05,118.49 210.05,119.28 209.89,119.44 209.69,119.44 209.56,119.31 209.56,118.49 209.31,118.24 208.9,118.24 208.51,118.64 208.51,119.83 207.89,120.45 207.89,120.97 208.25,121.33 208.87,121.33 209.25,121.71 209.25,123.21 207.9,124.56 203.95,124.56 203.81,124.42 203.81,124.22 203.95,124.08 207.61,124.08 207.87,123.82 207.87,123.47 207.61,123.22 203.2,123.22 203.06,123.08 203.06,122.88 203.2,122.73 208.43,122.73 208.68,122.48 208.68,122.13 208.43,121.88 203.06,121.88 202.94,121.75 199.79,121.75 198.59,122.96 198.59,123.85 v2(198.35,124.09)
CPU_DP2_N2_C: length 2.3
  TOP w0.102: UV8.13 194.21,118.15 194.32,118.05 194.45,118.05 194.66,118.26 195.28,118.26 195.32,118.23 195.51,118.23 CV70.2
CPU_DP2_N3: length 79
  TOP w0.076: 220.67,114.77 220.69,114.75 220.71,114.75 220.97,114.49 220.97,113.83 220.84,113.69 220.84,113.48 221.12,112.92 UC1.E36
  TOP w0.102: v2(219.8,115.14) 219.72,115.07 219.57,115.07 219.45,115.19 219.45,115.37 219.77,115.69 220.19,115.69 220.52,115.36 220.52,114.93 220.67,114.77 ; v2(198.27,121.75) 198.68,121.34 198.68,120 198.55,119.87 198.35,119.87 198.16,120.06 CV72.1
  IN4 w0.102: v2(219.8,115.14) 219.57,115.14 219.35,114.92 218.76,114.92 218,115.68 218,117.13 217.51,117.62 208.61,117.62 208.47,117.48 208.47,117.28 208.61,117.14 217.11,117.14 217.36,116.88 217.36,116.53 217.11,116.28 207.72,116.28 207.58,116.14 207.58,115.94 207.72,115.79 213.55,115.79 213.8,115.54 213.8,115.19 213.55,114.94 203.27,114.94 201.62,116.58 201.62,118.19 201.3,118.51 201.3,118.87 202.02,119.59 202.02,119.79 201.88,119.93 201.68,119.93 200.96,119.21 200.6,119.21 200.35,119.46 200.35,119.82 201.34,120.81 201.34,121.01 201.2,121.15 201,121.15 200.01,120.16 199.65,120.16 199.33,120.49 199.13,120.49 198.98,120.35 198.98,120.15 200.41,118.72 200.41,118.36 200.16,118.11 199.81,118.11 198.14,119.78 198.14,120.86 198.47,121.19 198.47,121.55 v2(198.27,121.75)
CPU_DP2_N3_C: length 4.3
  TOP w0.102: UV8.16 194.33,119.35 194.44,119.25 194.73,119.25 194.92,119.43 v4(195.28,119.43) 195.78,119.43 196.32,119.97 197.25,119.97 CV72.2
CPU_DP2_P0: length 78.2
  TOP w0.094: UC1.H34 223.02,111.92 v2(223.09,111.92)
  TOP w0.102: v2(201.4,124.06) 201.16,123.82 201.16,123.21 201.49,122.88 201.96,122.88 202.8,123.72 203.84,123.72 204.11,123.45 204.11,123.13 203.02,122.04 202.54,122.04 201.94,121.44 201.94,121.16 201.16,120.38 201.16,119.32 200.22,118.38 200.22,115.85 199.62,115.26 197.41,115.26 197.24,115.09 196.74,115.09 CV65.1
  IN4 w0.102: v2(223.09,111.92) 222.88,111.92 222.72,112.08 222.72,112.23 222.83,112.33 223.2,112.33 223.31,112.43 223.31,115.59 224.47,116.75 224.47,117.68 224.22,117.93 224.22,118.29 224.4,118.47 224.4,118.67 224.26,118.82 224.06,118.82 223.87,118.63 223.52,118.63 223.27,118.88 223.27,119.24 223.45,119.42 223.45,119.62 223.31,119.77 223.11,119.77 222.85,119.5 222.07,119.5 221.5,120.07 221.5,120.6 221.36,120.74 221.16,120.74 221.02,120.6 221.02,120.07 220.77,119.82 220.41,119.82 220.16,120.07 220.16,120.6 220.02,120.74 219.82,120.74 219.68,120.6 219.68,120.07 219.43,119.82 212.93,119.82 211.74,121.02 211.74,125.72 211.16,126.3 209.8,126.3 208.12,127.98 208.12,128.72 207.51,129.33 207.51,130.79 206.61,131.69 204.35,131.69 204.16,131.5 204.16,131.14 204.38,130.92 205.76,130.92 205.99,130.7 205.99,129.42 205.75,129.19 204.14,129.19 203.57,129.19 203.32,129.44 203.32,130.17 203.18,130.31 202.98,130.31 202.84,130.16 202.84,129.44 202.59,129.19 202.23,129.19 201.65,129.77 201.45,129.77 201.31,129.63 201.31,129.43 201.89,128.85 201.89,128.49 201.23,127.83 201.23,127.49 200.56,126.82 200.56,126.07 200.91,125.73 200.91,123.98 201.04,123.85 201.2,123.85 v2(201.4,124.06)
CPU_DP2_P0_C: length 2.4
  TOP w0.102: UV8.6 194.18,115.35 194.28,115.46 194.39,115.46 194.62,115.23 194.72,115.13 v4(195.01,115.13) 195.5,115.13 CV65.2
CPU_DP2_P1: length 77.8
  TOP w0.076: 221.91,115.1 221.91,115.08 221.93,115.06 221.93,114.74 221.76,114.57 221.76,114.22 221.93,114.06 UC1.F37
  TOP w0.102: CV67.1 198.44,116.33 199.27,116.33 199.58,116.64 199.58,117.19 199.32,117.44 199.06,117.44 198.92,117.58 198.92,117.78 199.06,117.92 199.32,117.92 199.58,118.17 199.58,118.72 200.31,119.45 200.31,121.24 200.43,121.36 v4(200.7,121.36) 201.02,121.36 201.31,121.65 201.31,122.01 201.06,122.26 200.45,122.26 200.31,122.41 200.31,122.92 200.17,123.06 v2(200.17,123.46) ; v2(221.21,115.34) 221.46,115.58 221.77,115.58 221.91,115.45 221.91,115.1
  IN4 w0.102: v2(200.17,123.46) 200.02,123.31 200.02,122.73 200.21,122.54 200.49,122.54 200.63,122.68 200.63,122.98 200.88,123.23 201.23,123.23 201.49,122.98 201.49,122.68 201.63,122.54 202.07,122.54 202.21,122.68 202.21,125.1 202.15,125.16 201.62,125.16 201.37,125.41 201.37,125.77 201.62,126.02 202.27,126.02 202.45,126.2 202.45,126.42 202.31,126.56 201.76,126.56 201.51,126.81 201.51,127.17 201.76,127.42 202.31,127.42 202.45,127.56 202.45,128.43 202.77,128.75 203.47,128.75 203.77,128.45 203.77,125.49 203.91,125.35 204.11,125.35 204.26,125.49 204.26,128.41 204.61,128.76 205.21,128.76 205.53,128.44 205.53,125.53 205.66,125.4 206.04,125.4 206.18,125.54 206.18,128.34 206.55,128.72 207.31,128.72 207.62,128.41 207.62,127.49 207.76,127.34 208.15,127.34 208.4,127.09 208.4,126.74 208.15,126.49 207.56,126.49 207.36,126.28 207.36,126.1 207.81,125.64 208.14,125.64 208.42,125.93 208.78,125.93 209.03,125.67 209.03,125.32 208.75,125.04 208.75,124.84 209.88,123.71 210.08,123.71 210.29,123.93 210.29,125.39 210.63,125.72 211.06,125.72 211.33,125.46 211.33,123.74 210.68,123.1 210.68,122.9 210.98,122.6 210.98,121.12 212.94,119.16 220,119.16 220.18,118.98 220.38,118.98 220.79,119.38 221.15,119.38 221.4,119.13 221.4,118.78 220.99,118.37 220.99,118.17 222.42,116.74 222.42,115.88 222.01,115.46 221.33,115.46 v2(221.21,115.34)
CPU_DP2_P1_C: length 4.1
  TOP w0.102: UV8.9 194.45,116.55 194.55,116.66 v4(195.29,116.66) 195.82,116.66 196.04,116.44 196.45,116.44 196.48,116.4 197.07,116.4 197.11,116.44 197.29,116.44 CV67.2
CPU_DP2_P2: length 76.7
  TOP w0.076: UC1.F34 222.28,111.97 v2(222.32,111.97)
  TOP w0.102: CV69.1 196.77,118.01 197.95,118.01 199.68,119.74 199.68,122.04 199.01,122.71 v2(199.01,124.09)
  IN4 w0.102: v2(222.32,111.97) 222.19,111.97 222.09,112.06 222.09,113.69 220.65,115.14 220.65,117.54 219.63,118.55 219.28,118.55 219.02,118.3 219.02,117.95 219.68,117.29 219.68,116.32 219.58,116.22 219.27,116.22 219.14,116.35 219.14,117.15 217.86,118.43 211.72,118.43 211.58,118.57 211.58,119.64 211.33,119.89 210.98,119.89 210.72,119.63 210.72,118.57 210.58,118.43 210.38,118.43 210.24,118.57 210.24,119.36 209.97,119.63 209.61,119.63 209.38,119.39 209.38,118.57 209.24,118.43 208.98,118.43 208.7,118.72 208.7,119.91 208.08,120.53 208.08,120.89 208.32,121.14 208.94,121.14 209.43,121.63 209.43,123.29 207.97,124.75 203.88,124.75 203.63,124.49 203.63,124.14 203.88,123.89 207.54,123.89 207.68,123.75 207.68,123.55 207.54,123.4 203.12,123.4 202.87,123.15 202.87,122.8 203.12,122.55 208.35,122.55 208.49,122.41 208.49,122.2 208.35,122.06 202.99,122.06 202.86,121.94 199.87,121.94 198.78,123.04 198.78,123.85 v2(199.01,124.09)
CPU_DP2_P2_C: length 2.3
  TOP w0.102: CV69.2 195.49,118.04 v4(194.99,118.04) 194.7,118.04 194.52,117.86 194.33,117.86 194.23,117.75 UV8.12
CPU_DP2_P3: length 79
  TOP w0.076: 220.81,114.9 220.82,114.89 220.82,114.86 221.13,114.56 221.13,113.96 221.18,113.91 221.58,113.91 221.63,113.86 221.63,113.8 221.39,113.56 UC1.E37
  TOP w0.102: CV71.1 198.44,119.68 198.63,119.68 198.87,119.92 198.87,121.55 v2(199.07,121.74) ; 220.81,114.9 220.71,115 220.71,115.44 220.27,115.88 219.69,115.88 219.41,115.59 v2(219.15,115.59)
  IN4 w0.102: v2(199.07,121.74) 198.8,121.74 198.66,121.59 198.66,121.11 198.33,120.78 198.33,119.86 199.88,118.3 200.08,118.3 200.23,118.44 200.23,118.64 198.8,120.07 198.8,120.42 199.05,120.68 199.4,120.68 199.73,120.35 199.93,120.35 200.92,121.34 201.28,121.34 201.53,121.09 201.53,120.73 200.54,119.74 200.54,119.54 200.68,119.4 200.88,119.4 201.6,120.12 201.95,120.12 202.21,119.86 202.21,119.51 201.49,118.79 201.49,118.59 201.81,118.27 201.81,116.66 203.35,115.12 213.47,115.12 213.61,115.27 213.61,115.47 213.47,115.61 207.65,115.61 207.4,115.86 207.4,116.21 207.65,116.47 217.04,116.47 217.18,116.61 217.18,116.81 217.04,116.95 208.53,116.95 208.28,117.2 208.28,117.56 208.53,117.81 217.59,117.81 218.19,117.21 218.19,115.75 218.84,115.1 219.27,115.1 219.39,115.23 219.39,115.45 219.25,115.59 v2(219.15,115.59)
CPU_DP2_P3_C: length 4.3
  TOP w0.102: UV8.15 194.32,118.95 194.43,119.06 194.81,119.06 194.96,119.2 195.58,119.2 195.62,119.24 195.86,119.24 196.36,119.74 v4(196.67,119.74) 197.23,119.74 CV71.2
CPU_DP3_AUXN: length 71
  TOP w0.094: v2(219.52,106.45) 219.52,106.53 UC1.B27
  TOP w0.102: JDGFF4.B6 174.07,135.61 174.26,135.42 174.26,135.22 173.96,134.91 v2(173.95,134.91)
  IN4 w0.102: v2(173.95,134.91) 174.15,134.71 174.15,134.16 172.16,132.16 172.16,130.54 173.7,129.01 177,129.01 177.58,128.42 177.58,126.28 181.49,122.37 182.46,122.37 183.35,121.48 184.89,121.48 185.1,121.68 187.84,121.68 189.83,119.69 190.21,119.69 190.71,119.19 190.71,117.23 191.9,116.05 191.9,113.65 194.29,111.26 194.29,109.64 194.88,109.05 197.41,109.05 200.21,106.24 210.46,106.24 210.75,106.53 214.28,106.53 216.11,104.7 217.29,104.7 218.42,105.83 219.03,105.83 219.34,106.14 219.35,106.28 v2(219.52,106.45)
CPU_DP3_AUXP: length 71
  TOP w0.094: v2(218.83,106.46) 218.83,106.57 UC1.A27
  TOP w0.102: JDGFF4.B5 174.67,135.65 174.67,135.64 174.45,135.43 174.45,135.1 174.63,134.93 v2(174.78,134.93)
  IN4 w0.102: v2(218.83,106.46) 218.92,106.55 218.98,106.55 219.16,106.36 219.16,106.22 218.95,106.02 218.34,106.02 217.21,104.89 216.19,104.89 214.36,106.71 210.67,106.71 210.39,106.42 200.29,106.42 197.48,109.23 194.96,109.23 194.48,109.72 194.48,111.34 192.08,113.73 192.08,116.13 190.9,117.31 190.9,119.27 190.29,119.88 189.91,119.88 187.91,121.87 185.02,121.87 184.81,121.67 183.43,121.67 182.54,122.56 181.57,122.56 177.77,126.36 177.77,128.5 177.08,129.19 173.78,129.19 172.35,130.62 172.35,132.08 174.34,134.08 174.34,134.79 174.48,134.93 v2(174.78,134.93)
CPU_DP3_N0: length 70.9
  TOP w0.109: JDGFF4.A2 176.47,137.03 176.24,137.26 176.24,138.49 177.11,139.35 v1(177.29,139.35) 178.48,139.35 179.33,138.5 179.33,137.8 179.5,137.63 v2(180.1,137.63) ; UC1.D34 220.49,111.51 v2(220.17,111.2)
  IN4 w0.076: v2(220.17,111.2) 220.17,111.41 220.42,111.66 220.42,112.37 220.14,112.66 219.5,112.66 219.2,112.96 219.2,113.14 219.09,113.25 219.09,113.58 219.08,113.6
  IN4 w0.102: v2(180.1,137.63) 180.31,137.42 181.32,137.42 183.04,135.7 194.02,135.7 199.29,130.43 199.29,127.65 196.58,124.94 196.58,122.77 197.53,121.82 197.53,119.5 199.94,117.09 199.94,116.72 202.37,114.3 213.8,114.3 215.01,115.5 217.17,115.5 219.08,113.6
CPU_DP3_N1: length 65
  TOP w0.076: 217.76,112.24 217.77,112.24 217.96,112.42 218.15,112.42 218.2,112.37 218.87,112.37 UC1.B34
  TOP w0.109: v2(174.66,137.66) 174.71,137.6 174.71,137.14 174.67,137.1 JDGFF4.A5 ; 217.76,112.24 216.73,112.24 216.42,111.92 216.24,111.92 v2(216.04,111.72)
  IN4 w0.102: v2(216.04,111.72) 215.83,111.72 214.75,110.65 204.07,110.65 203.8,110.38 200.87,110.38 199.17,112.07 197.29,112.07 195.87,113.5 195.87,116.91 194.25,118.53 194.25,120.98 191.35,123.88 188.66,123.88 187.49,125.05 182.98,125.05 182.81,125.23 181.42,125.23 179.55,127.1 179.55,131.3 177.12,133.73 177.12,135.69 176.07,136.74 175.21,136.74 174.75,137.2 174.75,137.57 v2(174.66,137.66)
CPU_DP3_N2: length 82.5
  TOP w0.076: v2(221.44,111.23) 221.44,111.13 221.14,110.83 UC1.E33
  TOP w0.109: JDGFF4.A8 172.87,137.2 172.91,137.24 172.91,137.55 171.72,138.74 171.72,140.27 172.21,140.77 v2(172.94,140.77)
  IN4 w0.076: v2(221.44,111.23) 221.62,111.4 221.75,111.4 221.84,111.31 221.84,110.89 221.45,110.51 221.45,110.19 221.15,109.88 220.86,109.88 220.85,109.87
  IN4 w0.102: v2(172.94,140.77) 173.19,140.51 173.29,140.51 173.84,140.51 174.25,140.11 174.25,139.17 173.57,138.5 173.57,136.97 174.42,136.12 175.74,136.12 176.47,135.39 176.47,133.51 178.94,131.04 178.94,126.84 181.17,124.62 182.53,124.62 183.49,123.65 185.43,123.65 186.03,123.05 189.4,123.05 190.36,122.09 192.27,122.09 193.61,120.75 193.61,116.58 194.21,115.99 194.21,114 195.96,112.24 195.96,111.01 196.15,110.82 196.56,110.82 196.97,111.24 198.91,111.24 200.42,109.73 203.07,109.73 204.21,108.59 206.9,108.59 207.67,109.36 209.5,109.36 210.94,107.93 214.18,107.93 215.47,109.22 220.19,109.22 220.85,109.87
CPU_DP3_N3: length 66.3
  TOP w0.076: UC1.B33 v2(218.91,111.57)
  TOP w0.109: v2(178.34,134.68) 178.56,134.9 178.56,135.12 178.44,135.24 178.04,135.24 177.37,134.57 176.56,134.57 175.92,135.21 175.92,135.54 175.87,135.59 JDGFF4.B3
  IN4 w0.102: v2(178.34,134.68) 178.34,134.18 180.4,132.12 186.42,132.12 187.27,132.97 192.64,132.97 194.58,131.03 194.58,129.29 194.76,129.1 194.76,122.14 195.79,121.11 195.79,118.67 197.97,116.49 197.97,115.82 199.25,114.54 199.25,113.74 200.56,112.43 206.17,112.43 206.78,111.83 213.82,111.83 215.47,113.48 216.63,113.48 218.41,111.7 218.41,111.19 218.62,110.99 218.89,110.99 218.99,111.1 218.99,111.49 v2(218.91,111.57)
CPU_DP3_P0: length 70.9
  TOP w0.109: v2(180.1,136.59) 180.33,136.83 180.33,137 180.22,137.12 179.29,137.12 178.82,137.59 178.82,138.28 178.26,138.84 177.32,138.84 176.76,138.27 176.76,137.47 177.07,137.16 JDGFF4.A1 ; UC1.C34 219.87,111.65 219.87,112.03 v2(219.82,112.08)
  IN4 w0.076: v2(219.82,112.08) 219.63,111.89 219.63,111.66 219.75,111.55 220.09,111.55 220.27,111.73 220.27,112.31 220.07,112.51 219.44,112.51 219.05,112.9 219.05,113.07 218.94,113.19 218.89,113.19 218.69,113.19 218.68,113.2
  IN4 w0.102: 218.68,113.2 216.94,114.94 215.24,114.94 214.03,113.74 202.14,113.74 199.38,116.49 199.38,116.85 196.97,119.27 196.97,121.59 196.02,122.54 196.02,125.17 198.73,127.89 198.73,130.19 193.79,135.14 182.81,135.14 181.09,136.86 180.37,136.86 v2(180.1,136.59)
CPU_DP3_P1: length 65
  TOP w0.076: 217.76,112.75 217.77,112.75 217.96,112.57 218.21,112.57 218.26,112.52 218.97,112.52 UC1.B36
  TOP w0.109: v2(175.38,137.66) 175.23,137.51 175.23,137.14 175.27,137.1 JDGFF4.A4 ; v2(215.96,112.83) 215.96,112.57 216.08,112.44 216.21,112.44 216.52,112.75 217.76,112.75
  IN4 w0.102: v2(175.38,137.66) 175.31,137.59 175.31,137.43 175.44,137.3 176.3,137.3 177.68,135.92 177.68,133.96 180.11,131.53 180.11,127.33 181.65,125.79 183.04,125.79 183.22,125.61 187.72,125.61 188.89,124.44 191.58,124.44 194.81,121.21 194.81,118.77 196.43,117.15 196.43,113.73 197.53,112.63 199.4,112.63 201.1,110.94 203.57,110.94 203.84,111.21 214.52,111.21 215.59,112.28 215.94,112.28 216.07,112.41 216.07,112.71 v2(215.96,112.83)
CPU_DP3_P2: length 82.5
  TOP w0.076: v2(222.2,111.16) 222.14,111.16 UC1.F33
  TOP w0.109: v2(172.93,139.7) 173.18,139.95 173.18,140.12 173.04,140.25 172.43,140.25 172.23,140.06 172.23,138.96 173.43,137.76 173.43,137.21 173.47,137.16 JDGFF4.A7
  IN4 w0.076: 221.24,109.47 221.25,109.49 221.25,109.77 221.6,110.12 221.6,110.44 221.99,110.83 221.99,110.95 222.19,111.16 v2(222.2,111.16)
  IN4 w0.102: v2(172.93,139.7) 173.19,139.95 173.29,139.95 173.61,139.95 173.69,139.87 173.69,139.4 173.01,138.73 173.01,136.74 174.19,135.56 175.51,135.56 175.91,135.15 175.91,133.28 178.38,130.81 178.38,126.61 180.94,124.06 182.29,124.06 183.26,123.09 185.2,123.09 185.8,122.5 189.17,122.5 190.13,121.54 192.04,121.54 193.05,120.52 193.05,116.35 193.65,115.76 193.65,113.76 195.4,112.01 195.4,110.78 195.92,110.26 196.79,110.26 197.2,110.68 198.68,110.68 200.18,109.17 202.84,109.17 203.98,108.03 207.13,108.03 207.9,108.81 209.27,108.81 210.7,107.37 214.42,107.37 215.7,108.66 220.43,108.66 221.24,109.47
