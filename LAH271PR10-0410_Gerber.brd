# Allegro board LAH271PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3.3V_ALW2: length 49.5
  TOP w0.254: v2(104.48,24.42) 105.18,23.72 105.18,22.12 105.55,21.75 105.55,20.84 106.68,19.7 109.73,19.7 110.25,19.18 111.88,19.18 112.37,18.69 112.37,15.65 v3(112.78,15.24) 112.78,14 112.33,13.55 v2(112.33,11.95)
  IN3 w0.254: v2(126.61,31.88) 126.3,31.58 125.65,31.58 125.49,31.74 120.7,31.74 118.68,29.72 113.53,29.72 112.05,31.19 110.52,31.19 108.3,28.97 108.3,27.91 106.07,25.68 105.61,25.68 104.48,24.56 v2(104.48,24.42)
  BOTTOM w0.254: v2(112.33,11.95) 112.33,10.42 112.02,10.11 PR104.2
  BOTTOM w0.305: v2(126.61,31.88) 126.97,32.24 127.5,32.24 RE57.2
+3.3V_ALW_DSW_R: length 3.2
  TOP w0.109: v1(129.88,9.39) 129.49,9.78 RH439.2 128.87,10.29 128.55,10.61 QH7.1
+3.3V_ALW_PCH: length 545
  TOP w0.254: v2(162.55,48.9) 162.7,48.75 162.7,47.54 160.67,45.5 160.67,36.98 v2(161.28,36.37) ; v2(21.49,4.35) 19.19,2.05 14.41,2.05 13.36,3.09 JAPS1.1 13.36,5.86 v2(12.88,6.34) ; RZ69.1 125.57,20.96 125.88,21.27 v2(125.88,21.53) ; RH204.2 164.84,22.15 v2(165.54,22.85) ; RZ368.1 121.52,16.49 120.87,17.15 120.87,18.42 120.64,18.65 v2(120.64,18.67)
  TOP w0.381: RH376.1 161.9,36.52 ; 161.9,36.52 161.33,36.52 161.28,36.48 v2(161.28,36.37) ; 161.9,36.52 RH330.1 ; v2(275.45,93.87) 275.99,94.4 RC137.2 ; RH310.1 182.73,15.63 v2(182.23,15.14) ; v2(165.66,29.84) 165.41,29.84 164.61,29.03 RH56.1 ; RH61.1 164.92,31.7 RH57.1 164.07,32.18 v2(164.24,32.35) ; RH203.2 161.08,25.62 v2(160.92,25.46)
  TOP w0.457: v2(164.3,35.61) 163.95,35.96 RC74.1 163.95,37.92 RH400.2
  TOP w0.508: v2(164.3,35.61) 164.63,35.28 RH736.1 ; v2(133.06,37.45) 134.24,37.45 RZ1385.1 RZ379.1 ; RT615.1 180.75,15.22 v2(180.71,15.18) ; RH101.1 v2(332.59,37.3)
  IN1 w0.508: v2(202.87,26.75) 203.31,26.31 211.35,26.31 212.09,25.57 215.37,25.57 216.11,26.31 247.21,26.31 250.48,29.58 262.96,29.58 263.51,29.03 266.08,29.03 271.86,34.82 271.86,35.58 273.64,37.36 274.27,37.36 280.24,43.34 280.24,46.07 283.16,48.99 283.16,55.1 285.59,57.53 288.75,57.53 292.04,60.82 292.04,64.69 293.91,66.55 v2(293.95,66.55) ; v2(161.28,36.37) 163.54,36.37 v2(164.3,35.61)
  IN2 w0.254: v2(21.49,4.35) 22.7,4.35 25.68,7.33 25.68,7.9 27.82,10.04 38.5,10.04 40.28,11.82 43.32,11.82 44.88,13.38 44.88,15.06 46.25,16.43 49.96,16.43 50.59,17.06 53.13,17.06 54.68,18.61 57.43,18.61 58.83,20.01 63.23,20.01 64.1,20.88 66.58,20.88 v2(67.12,20.33)
  IN2 w0.381: v2(13.1,29.06) 13.6,29.56 14.48,29.56 15.06,28.98 16.12,28.98 17.08,29.94 17.08,31.14 16.56,31.66 16.56,34.1 16.89,34.43 16.89,36.77 17.22,37.11 17.73,37.11 20.25,39.63 21.65,39.63 23.4,41.37 23.4,45.18 24.67,46.45 24.67,47.83 27.89,51.05 27.89,51.48 29.18,52.77 29.61,52.77 30.56,53.71 31.3,53.71 32.36,52.65 34.11,52.65 35.36,52.53 35.38,52.53 35.48,52.52 35.63,52.51 35.64,52.49 35.96,52.43 36.13,52.36 36.14,52.36 36.31,52.32 36.76,52.21 36.87,52.19 36.93,52.18 37.77,52 38,51.96 38.89,51.07 v2(38.89,49.49) ; v2(188.81,15.14) 188.32,14.65 187.19,14.65 186.72,15.11 186.72,15.48 186.4,15.79 182.89,15.79 v2(182.23,15.14)
  IN2 w0.508: v2(123.73,28.49) 124.11,28.87 124.11,29.75 124.69,30.33 124.69,33.98 125.37,34.67 129.27,34.67 130.12,35.51 130.12,37.71 130.74,38.33 132.18,38.33 v2(133.06,37.45) ; v2(275.45,93.87) 275.55,93.76 275.55,88.44 277.12,86.88 277.12,85.36 278.9,83.58 278.9,82.76 v2(279.54,82.11) 279.97,82.11 281.19,83.33 284.79,83.33 287.13,80.99 v2(287.13,80.58)
  IN3 w0.381: v2(182.23,15.14) 182.19,15.18 v2(180.71,15.18) 180.33,15.56 179.17,15.56 178.64,15.02 178.64,12.87 177.26,11.49 168.45,11.49 167.86,12.08 165.17,12.08 164.33,11.25 163.55,11.25 162.76,12.03 162.48,12.03 161.63,12.89 160.22,12.89 159.08,14.02 159.08,14.91 159.34,15.17 159.34,17 161.64,19.3 162.85,19.3 162.89,19.26 163.48,19.26 163.92,19.7 163.92,20.77 165.54,22.39 v2(165.54,22.85)
  IN4 w0.254: v2(120.64,18.67) 120.64,18.49 121.63,17.5 122.48,17.5 125.31,14.67 125.31,13.43 127.37,11.37 129.3,11.37 130.01,10.65 v2(131.04,10.65)
  BOTTOM w0.254: v2(162.55,48.9) 165.67,52.02 166.74,52.02 168.13,53.42 168.13,57.76 JSPI1.16 166.75,59.15 166.32,59.15 166.08,58.91 165.58,58.91 RH185.1 ; v2(12.88,6.34) 9.06,6.34 7.36,8.04 6.39,8.04 3.71,10.71 3.71,25.67 5.13,27.09 10.49,27.09 11.86,28.46 12.39,28.46 13,29.06 v2(13.1,29.06)
  BOTTOM w0.381: v2(165.66,29.84) 165.08,29.84 RH80.1 ; v2(38.89,49.49) 38.89,48.81 RT391.2 40.02,47.2 40.02,45.89 40.11,45.34 40.78,43.91 43.07,41.62 44.49,41.62 44.54,41.58 UH7.5 ; RH86.1 167.87,27.67 v2(168.26,28.06) 168.99,28.78 RH329.2 169.37,29.07 170.07,29.78 172.86,29.78 RH311.1
  BOTTOM w0.508: RC133.1 278.65,82.65 279.19,82.11 v2(279.54,82.11) ; v2(287.13,80.58) 288.46,79.25 v3(288.46,77.93) 288.46,76.72 291.7,73.48 291.7,68.81 v2(293.95,66.55) 295.04,66.55 313.28,48.31 316.25,48.31 319.55,45 319.55,39.78 319.29,39.52 319.29,38.4 320.58,37.11 322.68,37.11 322.87,37.3 v2(332.59,37.3) ; RH731.1 192.75,15.03 193.51,14.27 196.84,14.27 197.08,14.51 200.12,14.51 201.6,15.99 206.31,15.99 207.96,17.64 207.96,21.05 207.19,21.83 207.19,22.07 206.46,22.8 206.46,24.52 205.15,25.82 203.8,25.82 v2(202.87,26.75) ; RH730.1 182.15,15.23 v2(182.23,15.14)
  vias: v2(109.73,26.57) v2(110.32,26.56) v2(110.92,26.57) v2(154.4,23.85) v2(168.84,32.24) v2(169.06,25.56) v2(169.42,32.24) v2(169.65,25.56) v2(170.23,25.26)
+3.3V_ALW_PCH_PWR: length 1.1
  BOTTOM w0.109: v1(105.6,27.65) 105.73,27.52 CZ520.1
+3.3V_ALW_PCHRES: length 8
  BOTTOM w0.102: v2(193,33.23) 193.5,33.23 193.73,33.46 v1(193.73,33.67)
  BOTTOM w0.381: v2(178.08,31.28) 178.41,30.95 RH293.1
  BOTTOM w0.508: RH246.1 180.41,19.32 v2(179.73,18.63) 179.42,18.94 179.42,19.08 179.01,19.5 arc(179,19.5) RH300.1 ; RH306.1 187.51,16.46 v2(187.51,15.22) ; v2(193,33.23) 192.67,33.23 RH302.1 ; v2(182.59,19.39) 182.79,19.59 182.79,19.63 182.81,19.64 RH303.1
  vias: v2(169.6,41.21) v2(172.21,27.13) v2(172.68,26.79) v2(172.93,34.28) v2(173.52,34.27) v2(183.77,34.79)
+3.3V_ALW_R: length 139.3
  TOP w0.254: PR313.1 PR311.2 PR300.1 273.48,99.69 273.5,99.7 PC313.1 275.29,99.7 v2(275.31,99.67) ; PR515.1 v2(313.06,31.17) ; PR500.1 v2(312.53,41.7)
  TOP w0.381: 326.72,26.03 326.72,25.83 327.05,25.49 v2(327.05,25.3) ; 326.72,26.03 UZ60.5 ; 326.72,26.03 CZ540.1 ; v2(283.68,24.42) 283.46,24.64 PR725.2 ; UV68.5 185.76,96.8 184.61,95.65 RV820.1 ; RV821.1 182.83,96.2 182.91,96.28 UV60.5
  TOP w0.508: PR721.1 v2(284.02,23.52) ; v2(283.34,23.51) 283.2,23.37 PR720.1 ; 182.83,95.24 183.31,94.76 184.15,94.76 184.61,95.22 RV820.1 ; 182.83,95.24 RV821.1 ; 182.83,95.24 182.49,94.9 CV811.1 181.85,93.87 v2(182.03,93.69) ; PR730.2 v2(281.82,28.08)
  IN1 w0.508: v2(182.03,93.69) 181.79,93.69 181.24,93.15 181.24,92.7 180.01,91.47 v2(179.83,91.47)
  IN2 w0.254: v2(312.53,41.7) 311.91,41.7 308.52,45.09 304.18,45.09 v2(303.63,44.54)
  IN3 w0.254: v2(313.06,31.17) 313.06,30.95 312.58,30.47 311.19,30.47 310.53,31.13 310.53,32.93 308.89,34.57 308.89,37.55 308.2,38.24 308.2,42.32 305.43,45.09 304.18,45.09 v2(303.63,44.54) 303.63,45.22 301.76,47.09 301.76,49.3 300,51.05 297.26,51.05 296.2,52.12 296.2,56.21 293.66,58.74 284.34,58.74 283,60.09 283,66.73 279.88,69.84 279.88,75.59 281.23,76.94 284.2,76.94 285.14,77.88 285.14,97.49 283.85,98.78 279.5,98.78 278.61,99.67 v2(275.31,99.67)
  BOTTOM w0.254: v2(275.31,99.67) 275.13,99.49 PU300.10
  vias: v2(179.81,90.85) v2(179.83,90.26) v2(179.82,89.67) v2(180.96,89.72) v2(180.96,89.11) v2(200.8,85.54) v2(201.42,85.55) v2(202.05,85.56) v2(202.66,85.57) v2(203.27,85.56) v2(203.89,85.54) v2(206.87,125.73) v2(207.23,125.26) v2(284.87,42.14) v2(284.88,41.5) v2(285.59,41.51) v2(286.26,41.51) v2(286.96,41.5) v2(287.62,41.51) v2(295.08,30.36) v2(295.07,29.76) v2(295.09,29.15) v2(295.07,28.55) v2(295.1,27.95) v2(295.39,27.42) v2(295.43,26.59) v2(295.75,30.36) v2(295.74,29.76) v2(295.76,29.15) v2(295.74,28.55) v2(295.77,27.95) v2(295.92,27.11) v2(296.08,26.5) v2(296.58,27.04) v2(296.72,26.43) v2(319.03,11.8) v2(319.22,10.94) v2(319.51,11.45) v2(319.83,10.95) v2(320.05,11.68) v2(323.75,22.04) v2(324.13,21.53) v2(324.3,22.24) v2(324.7,21.77) v2(325.85,30.01) v2(325.86,29.37) v2(325.91,28.77) v2(325.93,28.16) v2(326.5,28.8) v2(326.52,30.01) v2(326.53,29.4) v2(326.53,28.21) v2(327.17,21.52) v2(327.61,34.09) v2(327.6,22) v2(327.73,22.62) v2(327.85,21.46) v2(328.23,34.12) v2(328.85,34.14) v2(329.47,34.12) v2(330.07,34.13) v2(330.68,34.14) v2(340.96,41.65) v2(340.95,41.04) v2(341.1,40.46) v2(341.59,41.64) v2(341.63,41.04) v2(341.71,42.28) v2(341.79,40.45) v2(342.23,41.63) v2(342.39,42.26) v2(342.31,41.02) v2(342.89,41.62) v2(342.96,40.96) v2(343.52,41.64) v2(343.57,40.87) v3(322.99,27.27)
+3.3V_ALW_RP: length 20.7
  TOP w0.254: v2(309.7,31.58) 309.9,31.38 310.12,31.38 310.49,31 PU501.14
  TOP w0.508: PR513.2 v2(309.7,31.58)
  BOTTOM w0.508: v2(309.7,31.58) 308.64,32.64 307.7,32.64 306.97,33.38 306.97,34.31 306.59,34.68 302.49,34.68 300.61,32.8 v3(297.59,32.8) 295.78,32.8 v2(294.32,31.34)
+3.3V_ALW_UE1: length 12.9
  TOP w0.203: 134.33,28.85 134.33,29.98 v2(134.19,30.13)
  TOP w0.229: UE1.B7 134.33,28.85
  TOP w0.254: v2(126.58,26.79) 126.42,26.64 RE314.2 ; v2(135.24,28.06) 134.85,28.45 UE1.B7 ; CE13.1 128.25,24.03 128.44,23.83 129.74,23.83 UE1.H1
  TOP w0.33: UE1.M9 v2(136.73,20.05) ; UE1.K2 130.35,21.66 v2(130.32,21.66) ; UE1.G8 v2(135.13,24.85)
  TOP w0.381: v2(128.56,23.34) 128.54,23.32 128.29,23.32 127.84,23.77 CE13.1
  BOTTOM w0.109: v2(134.19,30.13) 134.19,29.77 v1(133.89,29.47)
  BOTTOM w0.254: CE15.1 135.08,24.9 v2(135.13,24.85) ; CE23.1 134.37,30.32 v2(134.19,30.13)
  BOTTOM w0.33: CE19.1 137.18,19.6 v2(136.73,20.05)
  BOTTOM w0.381: v2(130.32,21.66) 129.84,21.19 CE20.1
  vias: v2(142.85,20.57) v2(143.47,20.55)
+3.3V_ALW_UZ12:
  vias: v3(116.09,27.8)
+3.3V_ALWP: length 21.4
  TOP w0.254: v2(110.88,9.23) 110.88,9.69 111.51,10.32 PR106.2 111.88,10.22 111.88,9.73 112.04,9.57 PU100.14
  IN4 w0.254: v2(110.88,9.23) 110.88,4.9 109.14,3.16 100.49,3.16 98.83,4.82 v2(98.39,4.82)
  vias: v1(93.68,5.1)
+3.3V_CARD_SPI: length 19
  BOTTOM w0.109: 11.18,25.32 CR236.2
  BOTTOM w0.254: UR3.8 16.6,25.73 14.67,23.8 12.71,23.8 11.2,25.32 RR238.2 9.88,24.9 v3(9.88,23.7) 10.23,23.36 10.23,23 10.95,22.28 RR236.2 11.76,22.28 12.22,21.82 12.22,18.37 12.53,18.06 RR237.2 RR235.2
+3.3V_DGFF: length 28.4
  TOP w0.381: v2(186.4,87.71) 185.83,88.28 RV815.1 ; RV804.1 188.46,104.93 QV30.5 QV30.2 184.61,104.93 RV805.1 183.4,104.83 181.98,103.41 v2(181.98,102.51) ; UV61.5 183.01,89.29 182.73,89.56 v2(182.26,89.56) ; RV816.1 189.41,83.87 v2(187.97,83.87) ; v2(180.86,80.7) 180.96,80.8 RV803.1 ; v2(188.58,90.51) 188.31,90.51 187.92,90.12 RV807.1 187.78,90.12 RV806.1 ; v2(185.21,102.26) 185.71,102.76 CV809.1 187.45,102.76 187.89,102.32 UV62.5
  IN1 w0.381: v2(187.97,83.87) 186.73,82.63 182.79,82.63 v2(180.86,80.7)
  BOTTOM w0.381: 188.28,87.71 v2(186.4,87.71)
  vias: v2(170.33,98.97) v2(170.35,98.37) v2(170.39,83.35) v2(170.48,82.75) v2(170.94,98.97) v2(170.96,98.37) v2(171.04,83.29) v2(171.07,82.69) v2(178.07,111.35) v2(178.67,111.33) v2(181.39,102.5) v2(182.04,93.06) v2(182.04,92.47) v2(182.45,92.03) v3(190.63,88.13)
+3.3V_DGFF_PWR: length 1.1
  BOTTOM w0.109: v1(187.77,90.76) 187.53,91 CZ528.1
+3.3V_DSW: length 4.2
  TOP w0.381: v2(131.63,10.65) 131.63,10.92 131.26,11.29 130.52,11.29 130.43,11.2 RH440.1 129.49,11.2 RH439.1
  TOP w0.508: RH602.2 168.27,21.16 168.4,21.3 RH243.2 168.41,21.78 v2(168.26,21.92)
  vias: v1(168.76,21.76) v2(168.2,19.84) v2(168.39,16.54)
+3.3V_EC_PLL: length 5.3
  TOP w0.254: UE1.F1 129.52,25.25 129.24,25.53
  TOP w0.381: 129.24,25.53 128.17,26.61 CE18.1 127.8,26.98 127.31,27.47 CE17.1
  TOP w0.508: RE314.1 125.84,27.47 CE17.1
+3.3V_FUSE: length 0.5
  TOP w0.254: v2(178.83,22.23) 178.95,22.1 UH1.AT44
  vias: v3(179.53,22.53)
+3.3V_LAN: length 32.1
  TOP w0.381: UL2.5 195.64,134 195.52,134.12 195.52,134.75 ; JLOM1.B2 215.19,138.49 217.27,138.49 217.8,137.95 217.8,136.05 215.97,134.21 209.15,134.21 207.6,132.67 CL19.1
  TOP w0.508: RL29.1 v2(198.31,128.12) ; CL19.1 CL199.1 CL18.1 204.65,132.78 v2(204.65,134.65) 204.57,134.74 JLOM1.A1 ; RL30.1 v2(199.43,134.2)
  BOTTOM w0.381: RL50.1 182.08,119.44 181.39,118.75 v2(181.39,118.29) ; RL5.1 186.64,119.38 187.06,119.8 187.06,120.6 v2(186.62,121.04)
  BOTTOM w0.508: v2(186.62,121.04) 187.11,121.53 RL6.1
  vias: v2(181.77,123.65) v2(181.77,123.03) v2(186.3,131.65) v2(186.29,131.05) v2(196.21,134.75) v2(196.71,135.12) v2(203.11,124.34) v2(203.24,124.95) v3(199.65,127.56)
+3.3V_LAN_OUT: length 4.7
  TOP w0.109: v2(189.8,132.28) v3(189.8,132.99)
  BOTTOM w0.203: UL1.19 189.95,132.13 v2(189.8,132.28) ; UL1.29 v2(193.61,128.14) ; v2(188.2,131.68) 188.2,131.22 188.35,131.08 UL1.15
  vias: v2(185.84,126.41)
+3.3V_M_TPM: length 19
  TOP w0.109: v1(115.6,20.54) 115.98,20.92 v2(116.01,20.92)
  TOP w0.254: v2(116.01,20.92) 116.01,20.92 115.91,21.01 RZ367.1 ; RZ366.2 121.86,18.21 RZ369.2 ; v2(123.95,20.62) 123.95,20.18 123.76,19.99 123.76,18.46 123.71,18.41 123.71,17.06 CZ60.1 123.26,17.38 RZ369.2 ; CZ59.1 RZ368.2 RZ369.2
  IN3 w0.254: v2(123.95,20.62) 124.44,21.11 124.44,21.45 124.15,21.74 122.49,21.74 122.17,21.41 116.5,21.41 116.01,20.92 v2(116.01,20.92)
+3.3V_MMI_AUX: length 35.6
  TOP w0.381: v2(29.02,11.04) v2(29.02,7.33)
  IN1 w0.381: v2(14.37,17.64) 13.5,16.76 13.5,16.14 12.54,15.19 12.54,13.97 12.73,13.78 12.73,8.76 15.81,5.67 24.47,5.67 24.84,6.04 28.39,6.04 29.02,6.67 v2(29.02,7.33)
  BOTTOM w0.381: v2(14.37,17.64) 13.9,17.17 RR235.1 ; v2(29.02,7.33) 28.73,7.62 v3(28.08,7.62) 27.35,8.35 RR211.1
+3.3V_MV: length 2.5
  BOTTOM w0.109: v2(15.37,10.48) v3(14.44,10.48)
  BOTTOM w0.203: UR1.18 18.25,15.02 17.67,14.43
  vias: v2(14.53,14.05) v2(15.12,14.07) v2(15.96,10.47) v2(27.15,16.45) v2(27.53,18.21) v2(27.8,16.44) v2(28.14,18.2) v2(30,8.98) v2(30.6,8.98) v2(32.26,11.76) v2(32.34,11.16) v2(32.9,11.85) v2(32.97,11.24)
+3.3V_PGPPBC: length 1.3
  TOP w0.254: UH1.AN26 v2(180.65,30.11) ; UH1.AP26 179.81,30.74 v2(179.81,30.26)
  vias: v3(176.57,29.21)
+3.3V_PGPPEF: length 1.4
  TOP w0.254: v2(183.78,26.24) 184.13,26.6 UH1.AE35 ; v2(183.78,25.65) 184.18,25.65 UH1.AE36
  vias: v3(182.97,22.9)
+3.3V_PGPPG: length 0.5
  TOP w0.254: UH1.AN21 180.66,33.96 v2(180.66,33.96)
  vias: v3(176.01,33.57)
+3.3V_PGPPHK: length 1.4
  TOP w0.254: v2(186.13,26.25) 186.07,26.25 185.73,26.6 UH1.AC35 ; v2(186.08,25.66) 185.9,25.84 UH1.AC36
  vias: v3(187.54,20.38)
+3.3V_PHVC: length 3
  TOP w0.254: v2(176.9,39.01) 177.11,39.22 UH1.AW9
  BOTTOM w0.254: 174.76,39.54 175.04,39.54 175.11,39.61 175.51,39.61 175.83,39.29 176.61,39.29 v2(176.9,39.01)
  vias: v1(172.73,39.84)
+3.3V_PHVLDO: length 1.7
  TOP w0.254: UH1.BB7 176.64,39.99 176.7,39.93 UH1.AY8 177.44,39.93 v2(177.54,40.03)
  vias: v1(174.27,40.43)
+3.3V_PRTC: length 6.8
  TOP w0.508: RH297.2 164.89,19.33 164.98,19.43 v2(165.08,19.43)
  IN2 w0.508: v2(165.08,19.43) 165.08,18.62 165.79,17.91 166.21,17.91
  BOTTOM w0.356: CH33.1 171.96,17.13 CH65.1 171.59,17.63 v1(171.11,18.11)
  BOTTOM w0.508: v2(170.22,17.75) 170.41,17.75 170.78,18.11 v1(171.11,18.11)
+3.3V_PUSB2: length 4.9
  TOP w0.254: UH1.V23 v2(187.64,31.76)
  BOTTOM w0.109: RH302.2 191.26,33.92 191.49,34.15 192.63,34.15 192.88,33.9 193.32,33.9 193.46,34.04 194.88,34.04 v1(195.06,33.86)
+3.3V_RTC_LDO: length 305.6
  TOP w0.254: v2(339.97,14.97) 339.91,14.97 338.77,16.1 337.09,16.1 335.2,17.99 335.2,20.55 335.42,20.77 335.42,21.41 335.28,21.54 335.28,23.42 334.82,23.88 332.89,23.88 332.34,23.32 v2(331.97,23.32) ; v2(249.32,2.61) v3(250.28,2.61) 251.23,2.61 255.83,7.21 255.83,9.12 257.8,11.1 259.51,11.1 264.54,16.12 266.25,16.12 266.79,16.65 267.76,16.65 268.4,17.3 270.6,17.3 271.3,16.6 273.23,16.6 v2(273.62,16.99)
  IN1 w0.254: v2(331.97,23.32) 331.61,23.67 331.61,24.7 331.02,25.3 329.72,25.3 328.29,26.73 325.05,26.73 321.21,30.57 321.21,36.3 319.97,37.54 314.43,37.54 312.01,39.96 311.7,39.96 309.28,42.38 309.28,43.74 308.21,44.8 304.17,44.8 303.95,45.03 301.27,45.03 300.46,44.21 296.93,44.21 295.4,42.68 290.66,42.68 289.92,41.94 288.06,41.94 287.32,42.68 283.52,42.68 277.7,36.86 277.7,35.49 274.64,32.43 274.64,26.62 v2(274.7,26.55)
  IN3 w0.254: v2(273.62,16.99) 273.62,18.65 274.7,19.73 v2(274.7,26.55)
  IN4 w0.254: v2(111.69,12.36) 111.92,12.59 114.2,12.59 114.57,12.22 114.57,11.21 114.15,10.79 114.15,6.96 115.2,5.91 117.48,5.91 119.14,4.25 119.14,1.96 119.84,1.26 158.12,1.26 159.21,2.35 159.21,4.9 160.1,5.8 165.41,5.8 165.65,6.04 169.79,6.04 171.46,4.38 171.46,2.2 172.34,1.31 248.77,1.31 249.32,1.87 v2(249.32,2.61)
  BOTTOM w0.254: v2(339.97,14.97) 341.46,14.97 342.23,14.2 342.23,10.98 341.76,10.51 340.78,10.51 340.5,10.23 PD8.3 ; PR105.2 v2(111.69,12.36)
+3.3V_RUN: length 463.2
  TOP w0.203: UV66.1 71.26,35.98 71.35,35.88 72.52,35.88 72.87,36.24 ; UV8.30 189.15,121.7 v2(188.94,121.91) ; UV8.21 193.04,122.01 193.46,122.43 193.85,122.43 v2(194.35,122.93) ; v2(194.64,114.58) 194.27,114.95 UV8.5 ; UV8.57 191.84,112.15 192.25,111.75 v2(192.39,111.75) ; CV64.1 189.29,112.12 189.44,112.28 UV8.51 ; v2(151.86,45.89) 151.64,45.67 150.85,45.67 150.7,45.52 UV67.1
  TOP w0.25: RH90.1 RH214.1
  TOP w0.254: 57.51,29.98 58.18,29.98 58.64,30.44 58.64,30.87 59.27,31.5 59.27,31.51 ; RH324.1 183.62,15.26 182.77,14.41 ; RH402.1 160.62,24.73 160.38,24.97 160.38,25.61 160.88,26.11 v2(160.88,26.31) ; RH130.2 185.41,15.77 185.41,15.04 185.84,14.61 v2(185.85,14.61) 186.6,14.61 186.79,14.8 186.79,15.5 186.63,15.66 RH131.2 ; v2(184.52,15.22) 184.49,15.25 RH133.2 ; v2(163.64,44.32) 163.86,44.1 RH214.1 ; RH348.1 181.83,15.41 181.79,15.37 181.79,14.86 181.85,14.8 181.85,14.41
  TOP w0.305: v2(74.48,28.82) 75.07,29.41 RV855.2 ; JUSH1.8 179.6,3.71 179.49,3.82 179.49,5.69 v2(179.41,5.76)
  TOP w0.356: UV65.5 134.08,45.65 CV844.1 ; CH10.1 174.37,50.81 RH225.2
  TOP w0.381: RZ362.1 v2(116.6,26.14) ; v2(263.59,151.86) 263.89,151.57 PR1114.1 ; v2(105.79,37.97) CV815.1 ; CZ72.1 165.73,7.15 166.77,8.19 171.52,8.19 CZ67.1 171.82,8.25 172.39,7.68 173.21,7.68 174.21,8.67 175.15,8.67 v2(175.26,8.79) 175.26,9.15 179.08,12.98 180.35,12.98 180.67,13.29 180.67,13.87 v2(180.68,13.88) 180.95,13.88 181.48,14.41 182.77,14.41 ; CV64.1 187.44,112.45 v2(187.82,112.83) ; RH360.1 161.52,37.42 v2(161.29,37.66) ; 59.9,25.86 59.9,25.32 61.06,24.16 61.43,24.16 62.06,23.52 63.11,23.52 63.44,23.85 RV853.2 63.44,25.11 RV850.2 ; v2(160.83,32.39) 161.32,32.39 161.47,32.24 161.47,32.2 RH333.2 161.74,31.9 QH4.2 ; RT643.2 40.03,39.29 v2(41.13,40.38) ; v2(78.34,33.52) 78.34,33.61 77.75,34.19 RV8.1 ; v2(160.54,27.88) 160.54,27.72 160.8,27.46 161.5,27.46 162.07,28.03 RH374.2 162.07,28.59 161.74,28.92 QH4.5 ; v2(161.25,34.59) 161.32,34.66 161.87,34.66 RH361.1 ; CV844.1 133.42,45.67 v2(133.18,45.91) ; CV814.1 107.05,40.36 108.02,40.36 108.99,41.34 v2(108.99,41.78) ; UC3.5 172.6,50.52 172.89,50.81 CH10.1 ; RV893.2 148.16,34.23 147.68,33.75 145.76,33.75 RV865.2 RV864.2 RV867.2 RV866.2 v2(142.19,33.63) ; v2(80.47,11.45) 81.06,11.45 81.07,11.45 RN208.2 ; RV61.1 190.75,109.64 v2(190.98,109.4) ; v2(115.38,46.02) 115.38,43.67 115.67,43.39 116.08,43.39 116.62,42.85 116.62,41.51 v2(116.48,41.37) ; v2(195.28,109.66) 195.28,110.03 195.05,110.25 RV127.1 RV125.1 ; RZ508.1 299.62,52 RZ505.1 298.67,52.02 297.82,51.17 v2(296.27,51.17) ; RE557.2 115.94,14.54 v2(115.94,14.78) ; v2(136.9,44.78) 136.49,44.38 RV885.2 136.49,43.12 RV886.2 136.52,42.47 RV888.2 136.78,41.35 RV887.2 ; RV59.1 v2(188.88,107.57) ; RV326.1 77.54,28.81 77.55,28.8 77.55,28.27 v2(76.88,27.6) ; v2(160.88,26.31) 161.02,26.44 161.47,26.44 RH331.1
  TOP w0.508: v2(116.35,36.08) 117.03,36.76 CV813.1 ; v2(106.26,36.08) 106.5,35.84 CV816.1 ; RE67.2 115.49,19.6 114.94,20.15 v2(114.94,20.85) ; v2(191.96,107.62) 191.96,107.99 RV63.1 ; RV739.1 RV740.1 107.57,29.29 107.02,29.84 v2(107.02,30.55) ; v2(196.59,93.41) 196.89,93.11 RZ542.2 ; CV817.1 CV955.1 116.28,39.92 116.48,40.11 v2(116.48,41.37) ; RV869.2 155.78,39.25 156.4,39.87 156.4,40.59 v2(156.14,40.84) ; v2(196.42,111.36) 196.59,111.52 RV65.1 ; RD94.2 200.61,58.09 v2(200.2,58.09) ; v2(176.15,53.02) 174.79,51.66 174.79,50.89 RH225.2 ; v2(166.92,35.52) 166.93,35.53 167.31,35.53 RH373.2 167.66,35.88 RH378.1 ; v2(197.26,122.67) 196.99,122.4 RV126.1 ; RV57.1 187.81,110.1 v2(187.59,109.88)
  IN1 w0.508: v2(115.38,46.02) 115.38,46.26 113.82,47.82 113.82,48.67 112.53,49.96 102.56,49.96 100.4,47.79 v2(100.4,47.43)
  IN2 w0.381: v2(74.48,28.82) 74.84,28.47 76.01,28.47 v2(76.88,27.6) 76.88,26.7 77.92,25.66 80.49,25.66 80.95,26.12 83.36,26.12 83.8,25.68 83.8,25.26 84.07,25 84.07,23.93 83.8,23.66 83.8,17.78 82.74,16.72 80.56,16.72 80.18,16.34 80.18,11.74 v2(80.47,11.45) ; v2(116.48,41.37) 116.52,41.37 116.91,41.76 125.07,41.76 128.17,44.86 132.38,44.86 133.18,45.66 v2(133.18,45.91) 134.09,45.01 136.67,45.01 v2(136.9,44.78)
  IN3 w0.381: v2(165.68,28.08) 164.65,28.08 163.86,27.29 163.21,27.29 162.22,26.31 v2(160.88,26.31) ; 227.29,143.14 229.18,145.03 229.18,147.77 231.13,149.72 240.79,149.72 242.73,151.67 261.08,151.67 261.9,152.48 263.26,152.48 263.59,152.15 v2(263.59,151.86) ; v2(179.41,5.76) 179.41,6.46 177.08,8.79 v2(175.26,8.79)
  IN3 w0.457: v2(160.49,29.7) 160.54,29.65 v2(160.54,27.88)
  IN3 w0.508: 227.29,143.14 224.34,140.19 222.16,140.19 216.65,134.68 209.17,134.68 207.55,133.05 195.82,133.05 192.55,129.77 192.55,125.3 191.92,124.68 191.92,122.75 191.39,122.22 189.24,122.22 v2(188.94,121.91) ; v2(195.28,109.66) 195.28,102.63 194.11,101.47 194.11,97.03 195.43,95.71 195.43,94.57 195.95,94.05 195.95,93.68 196.22,93.41 v2(196.59,93.41)
  BOTTOM w0.203: UV64.49 114.66,41.34 114.87,41.56 115.33,41.56 115.8,41.09 116.2,41.09 v2(116.48,41.37) ; UV64.35 109.06,41.71 v2(108.99,41.78) ; UV64.26 106.22,38.57 105.79,38.14 v2(105.79,37.97) ; v2(116.35,36.08) 116.35,36.36 116.15,36.57 UV64.60 ; v2(106.26,36.08) 106.19,36.15 106.19,36.5 106.26,36.57 UV64.21
  BOTTOM w0.25: RH223.2 180.23,43.2 179.87,43.57
  BOTTOM w0.254: RH128.2 160.77,30.44 160.49,30.17 v2(160.49,29.7) ; CV882.1 154.7,46.57 RV862.2 ; RH222.2 181.84,43.66 181.31,44.19 v2(181.31,44.97) ; v2(179.85,43.57) 179.87,43.57 179.87,43.58 179.87,43.59 179.87,44.45 180.44,45.02 RH224.2 ; RH319.1 175.12,43.49 174.66,43.49 174.03,44.12 v2(174.03,44.3) ; RE547.2 136.39,34.84 136.39,35.27 136.46,35.34 v2(136.46,35.47)
  BOTTOM w0.305: v2(185.85,14.61) 185.84,14.61 185.26,15.19 185.26,15.91 RH134.2 ; v2(184.52,15.22) 184.52,15.55 184.12,15.94 RH132.2 ; JESPI.1 164.53,16.46 v2(164.51,16.49) 164.51,16.2 164.74,15.96 JESPI.2
  BOTTOM w0.356: 165.68,28.11 166.05,28.48 166.06,28.48 166.21,28.63 166.66,28.63 166.81,28.48 166.82,28.48 ; v2(188.94,121.91) CV62.1 ; v2(160.88,26.31) 161.2,26.31 161.4,26.51 RH123.2 ; 163.35,25.99 163.4,26.04 RH124.2 ; RH127.2 RH375.1
  BOTTOM w0.381: v2(160.54,27.88) 160.61,27.81 160.61,26.59 v2(160.88,26.31) ; v2(116.6,26.14) 116.6,28.17 RV825.2 117,28.58 RV828.2 ; CV60.1 194.28,122.86 v2(194.35,122.93) ; RH375.1 165.15,27.55 v2(165.68,28.08) 165.68,28.11 ; 166.82,28.48 167.85,28.48 168.45,29.08 RH267.2 168.88,29.3 169.86,30.28 172.81,30.28 RH355.1 RH339.1 172.99,31.38 172.93,31.44 RC370.2 ; v2(199.04,53.44) 199.27,53.44 200.26,54.42 RD48.1 ; RD46.1 201.2,55.39 200.91,55.67 v2(200.4,55.67) ; v2(114.94,20.85) 114.94,21.17 115.82,22.06 RZ89.1 ; RH124.2 164,25.75 164.23,25.52 166.03,25.52 166.28,25.77 RH126.2 ; CV61.1 193.13,111.75 v2(192.39,111.75) ; v2(115.38,46.02) 116.17,46.02 RV823.2 116.24,45.37 115.85,44.99 RV822.2 115.86,44.51 RV827.2 116.87,44.44 RV826.2 ; RH199.2 177.69,48.16 RH221.2 ; RV55.1 193.26,115.86 193.58,115.54 CV63.1 193.78,114.58 v2(194.64,114.58) ; v2(65.7,26.14) 66.24,26.14 66.85,26.76 RV891.2 ; v2(119.22,35.54) 119.06,35.7 RV824.2 ; v2(69.72,39.17) 70.32,38.57 RV849.2 ; 74.02,30.79 74.48,30.34 v2(74.48,28.82) ; RH123.2 161.86,26.18 162.14,25.9 163.27,25.9 163.35,25.99 ; RD85.2 200.99,58.97 RD88.2 200.45,58.35 v2(200.2,58.09) ; RH76.1 177.7,16.25 RC444.2 178.63,16.24 RT644.1 179.15,15.43 179.28,15.56 179.77,15.56 180.16,15.17 180.16,14.95 180.68,14.44 v2(180.68,13.88)
  BOTTOM w0.457: RH380.1 183.87,14.87 184.23,15.22 v2(184.52,15.22)
  BOTTOM w0.508: v2(198.4,60.7) 198.22,60.88 RD14.1 197.64,61.56 198,61.91 RD15.1 ; v2(77.05,53.99) 77.05,54.67 77.07,54.68 RZ504.1 ; RD23.1 201.02,41.48 v2(200.65,41.11) ; v2(344.48,11.43) 345.11,12.07 RN203.2 ; RV900.1 81.74,62.25 v2(81.73,62.23) 81.56,62.07 RV901.1 ; RD92.2 200.07,45.53 v2(199.92,45.69) ; RD24.1 v2(230.02,29.89) ; RV840.1 101.91,48.37 CZ509.1 100.75,48.36 100.4,48 v2(100.4,47.43) ; RD86.2 198.35,55.81 197.75,55.21 v2(197.75,55.05) ; RH350.2 166.98,35.58 v2(166.92,35.52) ; RD40.1 197.67,55.14 v2(197.75,55.05) ; RH221.2 177.61,46.79 v2(177.61,45.89) 177.55,45.83 RH628.2 ; RZ507.1 83.3,56.52 v2(83.47,56.35) ; RD17.1 281.61,70.59 281.61,69.36 283.94,67.03 289.02,67.03 v3(292.83,63.22) 295.12,60.93 v2(295.12,50.23) ; v2(197.75,55.05) 197.75,54.28 197.21,53.74 RD93.2 ; v2(193.93,58.97) 194.38,59.42 RD78.2 ; RD22.1 v2(200.81,36.2) ; v2(216.54,30.33) 215.17,30.33 214.52,30.98 214.52,32.42 RD16.2 ; FZ1.1 v2(77.14,63.25)
  vias: v2(34.79,13.89) v2(34.8,13.28) v2(35.38,13.91) v2(35.44,13.32) v2(42.59,29.29) v2(43.21,29.29) v2(55.83,34.98) v2(73.32,35.51) v2(73.62,34.99) v2(107,24.78) v2(107.41,25.21) v2(111.09,17.66) v2(111.67,17.66) v2(152.47,45.97) v2(156.54,41.3) v2(170.47,129.32) v2(170.52,128.6) v2(171.08,132.39) v2(171.08,129.32) v2(171.11,133.58) v2(171.11,132.97) v2(171.16,128.6) v2(171.13,47.67) v2(176.87,130.89) v2(177.35,131.24) v2(177.54,130.66) v2(180.78,107.21) v2(180.88,107.83) v2(181.44,107.19) v2(181.54,107.8) v2(186.35,81.69) v2(186.35,81.11) v2(186.94,81.69) v2(186.94,81.11) v2(196.33,67.6) v2(196.33,66.8) v2(198.65,60.14) v2(232.46,12.55) v2(233.08,12.55) v2(233.57,20.97) v2(233.8,12.54) v2(234.17,20.96) v2(234.41,12.54) v2(234.8,20.97) v2(235.03,12.56) v2(235.42,20.96) v2(235.65,12.56) v2(236.06,20.96) v2(236.3,12.55) v2(236.69,20.94) v2(236.9,2.61) v2(236.91,12.55) v2(236.95,3.24) v2(237.35,20.93) v2(237.57,2.6) v2(237.62,3.23) v2(238.02,20.93) v2(238.27,3.2) v2(238.33,2.57) v2(239,3.24) v2(238.99,2.6) v2(269.47,1.94) v2(270.09,1.94) v2(270.69,1.94) v2(271.32,1.94) v2(271.91,1.94) v2(292.21,45.41) v2(292.79,46.03) v2(292.8,45.32) v2(293.49,46.02) v2(293.45,45.34) v2(294.16,46.01) v2(294.11,45.35) v2(294.73,45.28) v2(294.83,46.01) v2(295.35,45.32) v2(334.12,19.48) v2(334.71,19.59) v2(336.23,32) v2(336.7,31.61) v2(345.86,45.37) v2(345.88,44.76) v2(345.9,44.13) v2(345.92,43.52) v2(346.53,45.36) v2(346.55,44.74) v2(346.57,44.12) v2(346.59,43.5)
+3.3V_RUN_AUDIO: length 12.4
  TOP w0.254: v2(329.93,19.78) 329.86,19.71 RA224.1
  TOP w0.381: v2(344.07,13.76) 343.86,13.97 CA67.1 342.5,13.97 CA68.1 342.48,14.46 342.62,14.6 LA12.1 342.36,15.24 342.36,16.62 LA14.1
  IN3 w0.254: v2(329.93,19.78) 330.43,19.27 331.47,19.27 332.45,20.25 333.02,20.25 v2(334.21,21.44)
  BOTTOM w0.109: v2(344.07,13.76) 344.07,13.39 v3(344.34,13.12)
  BOTTOM w0.381: v2(349.65,14.26) 349.91,14.51 RA219.1
  vias: v2(334.59,22.04)
+3.3V_RUN_AUDIO_DVDD: length 21.3
  TOP w0.203: RA18.1 341.15,24.44 341.34,24.63 UA1.3
  TOP w0.254: RA18.1 340.48,24.24 337.59,24.24 v2(336.95,23.6)
  TOP w0.381: v2(342.95,15.6) 343.47,15.08 LA12.2 343.53,14.92 CA56.1 345.06,14.23 CA55.1
  BOTTOM w0.203: v2(336.95,23.6) 337.28,23.92 338.01,23.92 338.78,23.14 v3(338.89,23.14) 339.55,23.14 341.39,21.3 CA226.1 341.81,20.97 342.19,20.59 342.19,16.04 342.63,15.6 v2(342.95,15.6)
+3.3V_RUN_AUDIO_IO: length 4.7
  TOP w0.203: CA10.1 344.31,18.3 345.16,19.15 UA1.18
  TOP w0.381: LA14.2 342.77,17.49 CA61.1 344.1,17.89 CA10.1
+3.3V_RUN_DIMM1: length 6.5
  BOTTOM w0.305: CD32.1 210.89,34.19 210.89,34.98 v1(210.73,35.14) 209.93,35.94 JDIMM1.255
  BOTTOM w0.508: RD16.1 212.71,33.1 CD33.1 211.05,34.03 CD32.1
+3.3V_RUN_DIMM2: length 5.6
  TOP w0.305: JDIMM2.255 209.93,44.98 209.63,44.69 208.33,44.69
  TOP w0.508: v2(205.49,45.07) 205.88,44.69 208.33,44.69
+3.3V_RUN_DIMM3: length 23.1
  IN3 w0.508: v2(208.78,49.22) 206.29,49.22 203.72,51.79 203.08,51.79 200.4,54.47 200.15,54.47 199.6,55.02 199.6,55.11 196.58,58.12 v2(196.4,58.12)
  BOTTOM w0.127: v1(196.93,58.83) 196.4,58.3 v2(196.4,58.12)
  BOTTOM w0.305: v2(208.78,49.22) 208.78,49.41 209.93,50.56 JDIMM3.255
  BOTTOM w0.508: RD93.1 196.75,55.55 196.7,55.61 CD99.1 196.7,57.27 196.68,57.29 CD98.1 196.68,57.84 v2(196.4,58.12)
+3.3V_RUN_DIMM4: length 3.3
  TOP w0.109: v1(199.24,59.97) 199.46,60.19 200.68,60.19 200.96,60.47 202.33,60.47
+3.3V_RUN_PWR:
  vias: v3(342.31,45.31)
+3.3V_RUN_R: length 70.9
  TOP w0.254: v2(99.2,42.35) 99,42.55 JEDP1.10
  IN1 w0.508: v2(75.95,63.25) 75.95,56.56 68.56,49.17 68.56,47.78 68.39,47.62 68.39,45.87 68.73,45.53 69.45,45.53 70.59,46.66 74.68,46.66 75.85,45.5 75.85,41.24 75.59,40.98 75.59,37.63 76.45,36.77 82.24,36.77 82.78,37.3 86.05,37.3 86.88,36.47 93.52,36.47 94.63,37.58 94.63,40.45 94.4,40.68 94.4,42.52 94.86,42.98 98.78,42.98 99.2,42.56 v2(99.2,42.35)
  BOTTOM w0.109: v2(99.2,42.35) 99.2,42.97 v3(99.4,43.17)
  BOTTOM w0.508: v2(75.95,63.25) 75.68,62.98 RZ551.1
+3.3V_RUN_R_F: length 5.5
  BOTTOM w0.127: v1(73.98,59.29) QZ1.3
  BOTTOM w0.508: FZ1.2 RZ551.2 75.68,60.39 76.12,59.95 QZ1.3
+3.3V_SPI: length 200.8
  TOP w0.254: RH335.1 166.32,13.33 168.24,11.41 172.45,11.41 174.61,13.58 174.61,15.51 v2(174.56,15.56) ; RH30.1 v2(175.56,15.53) ; RH601.1 187.82,15.89 187.82,15.9 RH615.1 188.23,15.34 v2(188.12,15.23) 188.12,14.33 v2(187.76,13.97)
  TOP w0.381: v2(128.47,36.13) 128.44,36.11 126.37,36.11 125.57,35.31 123,35.31 122,36.31 118.86,36.31 118.59,36.04 117.4,36.04 116.7,35.35 115.05,35.35 114.3,34.6 114.3,32.68 114.84,32.13 115.78,32.13 116.63,31.28 116.63,30.51 116.26,30.14 CH270.1 116.74,29 UC6.8
  IN1 w0.254: v2(170.04,54.56) 171.79,54.56 173.75,56.52 v2(188.83,56.52)
  IN2 w0.254: v2(175.56,15.53) 175.69,15.66 180.94,15.66 182.63,13.97 187.76,13.97 v2(187.76,13.97) ; v2(128.47,36.13) 128.44,36.13 128.19,36.39 128.19,37.15 128.46,37.42 128.46,39.03 130.8,41.36 134.69,41.36 v2(135.03,41.03)
  BOTTOM w0.254: v2(188.83,56.52) 189.5,55.85 193.81,55.85 194.48,55.19 195.04,55.19 196.05,54.17 196.05,52.98 196.48,52.55 197.38,52.55 v3(198.36,51.57) 199.37,50.56 199.37,45.38 199.89,44.86 199.89,44.11 200.42,43.58 200.79,43.58 200.97,43.4 200.97,42.16 199.16,40.35 199.16,38.81 198.75,38.4 198.75,37.76 199.89,36.63 199.89,31.19 203.54,27.54 203.54,26.82 204.03,26.33 205.36,26.33 206.96,24.73 206.96,23.01 207.69,22.28 207.69,22.04 208.63,21.11 208.63,17.39 206.72,15.48 201.81,15.48 199.72,13.39 197.04,13.39 196.67,13.76 193.3,13.76 192.53,14.53 188.43,14.53 188.12,14.84 v2(188.12,15.23) ; RH185.2 166.22,59.55 167.05,59.55 JSPI1.15 168.3,58.3 168.5,58.3 168.63,58.17 168.63,55.97 v2(170.04,54.56) ; v2(135.03,41.03) 135.2,41.19 UC5.8 136.11,41.19 136.38,41.47 CH9.1 ; RH600.1 157.94,28.7 157.94,32.77 158.33,33.16 158.33,35.63 161.8,39.09 161.8,40.92 164.9,44.03 164.9,44.68 170.36,50.13 170.36,52.38 v2(170.44,52.46)
  BOTTOM w0.381: v2(174.56,15.56) 175.53,15.56 v2(175.56,15.53)
+3.3V_SSD3: length 7.2
  BOTTOM w0.109: v2(92.66,39.59) v3(91.85,39.59)
  BOTTOM w0.381: 85.89,44.15 85.26,43.52 85.26,41.01 85.7,40.57 87.08,40.57 87.5,40.16 RN37.2
  vias: v2(73.34,50.29) v2(73.95,50.29) v2(82.19,51.08) v2(82.14,46.02) v2(82.17,45.41) v2(82.67,50.66) v2(82.77,46.02) v2(82.76,45.42) v2(83.14,50.28) v2(89.36,32.54) v2(89.37,31.96) v2(89.95,32.54) v2(89.95,31.96) v2(93.26,39.57) v2(93.41,40.22) v2(93.84,39.82)
+3.3V_SSD3_PWR:
  vias: v3(91.61,28.57)
+3.3V_SSD4: length 1
  BOTTOM w0.109: v2(312.04,15.17) v3(311.09,15.17)
  vias: v2(312.05,14.53) v2(312.06,13.92) v2(312.05,13.25) v2(312.63,15.18) v2(312.64,14.54) v2(312.66,13.91) v2(312.65,13.28) v2(334.14,15.21) v2(334.14,14.58) v2(334.77,15.21) v2(334.77,14.58) v2(337.48,15.48) v2(337.48,14.88) v2(337.48,14.27) v2(338.1,15.48) v2(338.07,14.87) v2(338.08,14.25) v2(338.68,14.27) v2(338.71,15.48) v2(338.7,14.86)
+3.3V_SSD4_PWR:
  vias: v3(316.08,13.8)
+3.3V_SSD5: length 1.5
  BOTTOM w0.109: CN299.1 86.23,16.59 v3(86.98,15.84)
  vias: v2(84.51,5.38) v2(85.11,5.57) v2(85.2,23.58) v2(85.21,19.43) v2(85.4,5.04) v2(85.73,5.59) v2(85.81,23.56) v2(85.98,19.42) v2(86.31,5.13) v2(86.45,23.54) v2(86.64,19.42)
+3.3V_SSD5_PWR:
  vias: v3(92.62,24.08)
+3.3V_TBT: length 2.5
  TOP w0.109: 41.76,29.85 41.76,29.52 42.98,28.3 v3(42.98,27.89)
+3.3V_TBT_ANA: length 1.8
  TOP w0.109: CT302.1 26.36,36.77 26.8,36.34 v2(27.41,36.34)
  BOTTOM w0.102: UT1.E16 v2(27.41,36.34)
+3.3V_TBT_ANA_PCIE: length 17.5
  TOP w0.381: RT554.2 25.88,38.42 25.65,38.65 CT301.1
  TOP w0.508: RT554.2 25.66,38.04 25.1,37.48 v3(24.72,37.48) 24.13,36.9 24.13,35.84 24.81,35.16 26.16,35.16 27.67,33.65 v2(27.67,32.46)
  IN3 w0.254: 31.3,35.17 31.3,35.69 30.66,36.34 v2(30.01,36.34)
  IN3 w0.508: 31.3,35.17 31.3,34.56 29.2,32.46 v2(27.67,32.46)
  BOTTOM w0.254: UT1.L16 v2(30.01,36.34)
+3.3V_TBT_ANA_USB2: length 2.1
  TOP w0.109: v2(29.36,36.34) 28.94,36.76 28.35,36.76 28.13,36.99 CT300.1
  BOTTOM w0.102: UT1.H18 v2(29.36,36.34)
+3.3V_TBT_FLASH_R: length 29.9
  TOP w0.254: v2(38.5,36.05) 37.98,35.53 RT2.2 37.77,35.42 RT3.2 ; v2(37.72,45.37) 37.72,44.68 v1(37.98,44.42) 37.98,43.99 38.8,43.17 39.47,43.17 39.54,43.11 RT1.2 39.55,43.02 39.55,42.51 39.35,42.31 UT2.8 ; RT578.1 45.09,34.78 RT4.2 43.61,35.81 42.84,35.81 42.67,35.98 41.85,35.98 41.51,36.32 v2(39.98,36.32)
  TOP w0.381: CT1.1 38.35,45.88 37.92,45.45 37.8,45.45 v2(37.72,45.37)
  IN2 w0.254: v2(38.5,36.05) 38.79,36.34 38.79,37.71 39.35,38.27 39.35,40.18 37.25,42.28 36.75,42.28 35.58,43.45 35.58,45.08 35.94,45.45 37.64,45.45 v2(37.72,45.37)
  BOTTOM w0.254: v2(38.5,36.05) 38.5,36.2 RT9.1 39.29,36.32 v2(39.98,36.32)
+3.3V_TBT_LC: length 16.8
  TOP w0.254: v2(36.74,33.92) 36.38,33.92 35.85,34.46 RT8.2 ; v2(33.91,40.89) 34.36,40.44 34.97,40.44 34.98,40.43 CT303.1
  IN3 w0.254: v2(33.91,40.89) 33.91,40.5 34.14,40.26 34.57,40.26 35.04,39.79 35.04,38.55 35.04,35.14 36.26,33.92 v2(36.74,33.92)
  BOTTOM w0.254: v2(33.91,40.89) 33.91,40.89 UT1.V6 ; v2(36.74,33.92) 37.64,33.92 37.9,33.66 RT7.2 RT6.2 38.07,34.53 RT5.2 37.87,35.66 37.87,36.49 RT9.2
+3.3V_TBT_S0: length 3.1
  TOP w0.254: CT328.1 v2(27.4,40.88) ; CT327.1 30.56,41.44 v2(30,40.88)
  BOTTOM w0.109: v2(28.67,44.83) 28.75,44.92 v1(28.75,45.46)
  BOTTOM w0.203: UT1.E6 27.73,41.22 v2(27.4,40.88)
  BOTTOM w0.254: UT1.L6 v2(30,40.88)
  vias: v2(28.67,44.22) v2(39.55,31.55)
+3.3V_TBT_SX: length 25.3
  TOP w0.254: CT314.1 27.62,36.9 28.18,36.34 v2(28.71,36.34) ; v2(24.74,43.53) 25.81,43.53 RT11.2 ; v2(33.91,50.81) v1(33.91,49.15) 33.91,46.47 33.21,45.78 33.21,45.39 32.18,44.37 31.73,44.37 31.51,44.15 RT16.2 RT17.2 ; CT315.1 32.74,40.26 32.74,40.76 v2(32.61,40.89)
  TOP w0.381: RT591.2 36.9,39.93 v2(37.06,40.09) 37.16,40.19 37.16,40.56 37.78,41.18 RT372.2
  IN1 w0.381: v2(37.06,40.09) 36.79,39.82 35.46,39.82 34.98,40.3 33.19,40.3 v2(32.61,40.89)
  BOTTOM w0.203: UT1.R6 v2(32.61,40.89)
  BOTTOM w0.254: UT1.F18 v2(28.71,36.34) ; RT20.2 36.06,47.24 36.55,47.73 v2(36.79,47.73) ; RT613.2 38.61,44.05 37.9,43.34 37.18,43.34 v2(36.78,42.94)
+3.3V_TP: length 24.5
  TOP w0.305: JKBTP1.12 288.16,11.51 v2(287.81,11.16)
  TOP w0.381: RZ19.1 RZ18.1 274.73,8.16 v2(273.86,7.29) 273.9,7.26 RZ21.1
  IN2 w0.381: v2(273.86,7.29) 273.86,5.58 v2(274.83,4.62)
  BOTTOM w0.356: 287.63,12.25 288.08,12.69 CZ90.1 288.38,11.74 v2(287.81,11.16)
  BOTTOM w0.508: 287.63,12.25 284.96,12.25 284.27,11.55 281.46,11.55 281.12,11.21 279.94,11.21 279.32,10.58 v3(279.32,7.99) 279.32,5.91 279.13,5.72 v2(279.13,5.5)
+3.3V_VDD_PIC: length 89.1
  TOP w0.254: v2(47.66,28.56) 47.66,28.86 47.32,29.21 46.52,29.21 45.94,29.79 45.94,30.8 46.57,31.44 46.57,33.02 46.4,33.2 RT578.2 ; v2(47.69,26.13) 47.69,26.3 47.34,26.65 45.55,26.65 44.69,25.79 PR39.1
  TOP w0.305: JIO1.74 47.05,2.5 v2(47.28,2.73) 47.55,2.46 JIO1.72
  TOP w0.381: v2(65.08,25.29) 64.52,24.74 v2(64.52,22.83) ; v2(57.22,16.77) 57.22,17.09 PR71.1
  IN3 w0.381: v2(57.22,16.77) 56.69,16.25 56.69,14.77 56.19,14.27 v2(55.91,14.27) 55.91,10.94 53.76,8.79 v2(53.76,7.54) ; v2(65.08,25.29) 64.88,25.1 59.34,25.1 59.26,25.02 55.6,25.02 55.46,25.16 50.59,25.16 49.62,26.13 v2(47.69,26.13)
  IN4 w0.381: v2(57.22,16.77) 57.22,19.22 58.86,20.86 63.5,20.86 64.52,21.88 v2(64.52,22.83)
  IN4 w0.508: v2(53.76,7.54) 53.76,6.79 50.68,3.7 48.25,3.7 v2(47.28,2.73)
  BOTTOM w0.109: RT564.1 v3(65.77,19.7)
  BOTTOM w0.254: UT10.5 44.6,26.65 45.06,27.11 46.15,27.11 46.51,27.46 CT370.2 ; v2(47.66,28.56) 47.66,28.45 47.24,28.03 46.82,28.03 CT370.2 ; v2(47.69,26.13) 47.69,26.35 47.23,26.8 47.23,27.01 CT370.2
  BOTTOM w0.381: PR72.1 55.91,13.08 v2(55.91,14.27) ; v2(57.22,16.77) 56.91,17.07 PR57.1 ; v2(43.26,25.95) 43.26,26.44 43.47,26.65 UT10.5 ; v2(64.52,22.83) 64.52,22.03 65.3,21.24 65.52,21.24 RT564.1 ; v2(65.08,25.29) 65.03,25.34 CT371.2 64.03,25.57 UT12.5 62.75,25.57 62.52,25.8 62.52,26.27 60.88,27.91 60.88,29.29 RT569.2
+3.3V_VDD_PICP: length 5.5
  TOP w0.109: v3(33.42,24.57) 33.42,24.82 v2(33.75,25.16)
  TOP w0.508: QT2.1 33.93,25.34 v2(33.75,25.16)
  BOTTOM w0.508: v2(33.75,25.16) 35.46,25.16 RT542.2
+3.3V_WLAN: length 3.1
  BOTTOM w0.109: v3(319,22.69) 319.72,21.97 319.72,20.65 CZ542.1
  vias: v2(315.84,19.58) v2(315.82,18.89) v2(316.57,19.57) v2(316.58,18.87) v2(317.28,19.56) v2(317.26,18.84) v2(335.92,20.09) v2(335.92,19.5) v2(335.95,18.9) v2(336.52,20.08) v2(336.55,19.48)
+3.3V_WLAN_PWR:
  vias: v1(323.78,24.96)
+3.3V_WWAN: length 0.9
  BOTTOM w0.109: v2(294.01,15.46) v3(293.13,15.46)
  vias: v2(283.68,9.94) v2(284.29,9.95) v2(288.65,9.82) v2(289.23,9.82) v2(294.02,14.86) v2(294.63,15.46) v2(294.63,14.86) v2(307.2,8.83) v2(309.26,10.56) v2(309.84,10.55) v2(310,9.94) v2(310.43,10.53) v2(310.59,9.94) v2(312.23,16.29) v2(312.86,16.3) v2(313.23,15.75) v2(313.49,16.3) v2(313.91,15.69) v2(314.12,16.27) v2(330.36,24.57) v2(330.36,23.98) v2(330.36,23.39) v2(331,23.98) v2(331.01,24.57) v2(331.02,23.36)
+3.3V_WWAN_PWR: length 2.3
  TOP w0.109: v1(328.14,18.41) 328.14,18.72 328.63,19.21 328.63,20.04 328.31,20.36
+3.3VB_1.8V: length 3.3
  TOP w0.109: 124.35,2.84 124.35,2.58 123.9,2.14 v3(121.46,2.14)
+3.3VB_2.5V: length 2.1
  TOP w0.109: PC406.1 289.64,44.72 v3(289.88,44.96)
+5V_ALW: length 305.4
  TOP w0.203: v2(87.45,26.82) UZ9.4
  TOP w0.305: JIO1.80 45.56,1.66 v2(45.56,2.93) ; JPB1.2 318.89,44.25 v2(318.66,44.02)
  TOP w0.33: CZ64.1 193.78,7.68 CZ69.1
  TOP w0.356: CT342.1 49.46,32.97 v2(48.94,33.49) ; v2(53.31,28.98) 53.22,28.88 CT343.1 ; v2(54.15,39.51) 54.15,39.92 CT358.1
  TOP w0.381: CT356.1 48.34,32.83 v2(48.34,33.63) ; CT357.1 53.94,38.68 53.94,38.69 54.15,38.9 v2(54.15,39.51)
  TOP w0.508: CZ69.1 192.86,7.43 v2(192.73,7.3) ; v2(6.05,19.27) 6.42,18.9 6.42,16 7.23,15.19 7.23,12.1 8.17,11.16 8.99,11.16 10.97,9.17 14.71,9.17 15.36,8.53 26.95,8.53 29.54,5.93 v2(29.82,5.93) ; v2(201.17,5.73) 200.65,6.25 PR203.1 PR204.2
  IN1 w0.254: v2(54.15,39.51) 54.15,39.83 54.45,40.12 66.5,40.12 67.92,41.54 71.23,41.54 72,42.31 73.01,42.31 75.01,40.31 v2(75.01,39.64)
  IN1 w0.381: v2(318.66,44.02) 318.39,43.75 317.82,43.75 317.61,43.95 315.31,43.95 314.54,44.72 311.37,44.72 303.02,53.07 300.72,53.07 299.79,52.13 295.68,52.13 292.18,48.63 289.64,48.63 288.88,47.87 283.42,47.87 v2(281.15,45.6)
  IN1 w0.508: v2(45.56,2.93) 44.83,3.66 44.16,3.66 40.55,7.28 36.39,7.28 35.05,5.93 v2(29.82,5.93)
  IN2 w0.381: v2(203.23,5.53) v2(203.84,5.53) 203.99,5.53 205.84,7.38 206.95,7.38 208.86,9.29 208.86,11.47 212.71,15.32 212.71,17.55 213.1,17.94 213.1,22.84 218.7,28.44 248.45,28.44 249.3,29.29 266.08,29.29 270.39,33.6 276.49,33.6 282.03,39.14 282.03,45 281.44,45.6 v2(281.15,45.6)
  IN2 w0.508: v2(58.44,16.6) 58.26,16.6 57.81,16.15 52.96,16.15 v2(52.26,15.45)
  IN4 w0.508: v2(52.26,15.45) 51.95,15.13 51.95,9.28 52.38,8.85 52.38,6.44 50.38,4.45 46.89,4.45 45.56,3.12 v2(45.56,2.93)
  BOTTOM w0.109: v3(59.91,18.69) 59.6,18.38 v2(59.6,18.02) ; v2(45.56,2.93) 45.56,3.59 v3(45.42,3.74) ; v2(47.35,34.09) 47.35,34.37 48.17,35.2 v3(48.17,35.49)
  BOTTOM w0.254: UT5.L9 52.19,32.21 v2(51.48,32.21) ; v2(53.31,28.98) 53.37,28.93 UT5.J2 ; JCCG1.7 54,38.69 54.15,38.85 v2(54.15,39.51)
  BOTTOM w0.305: UR4.3 6.48,19.71 v2(6.05,19.27)
  BOTTOM w0.508: v2(313.05,12.35) 314.15,12.35 314.75,12.95 314.75,21.53 317.45,24.23 317.45,26.15 320.7,29.4 320.7,34.18 319.88,35 318.88,35 317.69,36.2 317.69,43.05 v2(318.66,44.02)
  vias: v2(47.2,33.51) v2(47.79,33.35) v2(47.93,34.1) v2(58.05,15.4) v2(58.41,17.66) v2(58.43,14.91) v2(58.52,15.8) v2(58.88,15.32) v2(58.98,18.02) v2(58.96,17.42) v2(59.02,16.82) v2(59.02,16.21) v2(59.3,14.9) v2(59.36,26.74) v2(59.49,15.56) v2(59.58,27.28) v2(59.61,17.37) v2(59.61,16.77) v2(59.6,16.18) v2(59.73,27.85) v2(59.95,26.73) v2(60.17,27.27) v2(60.29,28.05) v2(96.5,34.43) v2(97.13,34.43) v2(97.13,33.84) v2(149.09,13.85) v2(149.63,14.06) v2(180.16,4.56)
+5V_ALW2: length 2.8
  BOTTOM w0.254: PU101.15 66.33,14.48 66.19,14.34 65.56,14.34 v1(65.54,14.37) 65.29,14.61 65.29,15.2 PC127.1
+5V_ALW_R: length 100
  TOP w0.203: UZ40.4 v2(339.94,41.71) ; v2(325.93,21.74) 325.99,21.79 UZ44.4 ; v2(206.87,127.29) 206.5,126.91 UZ7.4
  TOP w0.254: UZ58.4 320.51,14.4 320.51,16.13 321.68,17.3 327.04,17.3 327.43,17.7 327.43,18.64 v2(328.16,19.36) ; v2(349.06,37.1) 349.38,37.41 UI2.1 ; v2(246.76,138.65) 246.76,138.87 245.79,139.84 245.39,139.84 ; v2(330.82,28.09) 330.82,28.34 330.31,28.85 UZ23.4 ; v2(229.82,135.08) 229.81,135.07 PU1203.15 ; v2(349.08,48.25) 349.08,47.86 349.27,47.67 349.44,47.67 349.61,47.83 UI1.1 ; v2(245.47,137.71) 245.25,137.49 PU1201.15 ; PU1202.15 v2(237.72,137.49) ; v2(351.93,37) 352.21,36.72 RI67.2 ; PU1200.15 v2(253.15,137.6)
  TOP w0.305: UZ21.3 190.71,91.2 v2(190.49,91.42) ; UZ26.3 276.43,80.08 276.23,79.88 ; v2(192.85,91.67) 192.83,91.67 192.49,92.01 UZ19.3
  TOP w0.381: PR1170.1 266.69,138.33 v2(266.6,138.33)
  TOP w0.508: 276.23,79.88 276.18,79.84 275.73,79.84 275.41,79.52 275.41,78.76 276.98,77.19 284.64,77.19 285.99,75.83 v2(285.99,74) ; PR1151.1 262.53,137.77 v2(263.1,137.2) ; RI13.2 v2(349.52,44.37)
  IN1 w0.254: v2(229.82,135.08) 229.68,135.08 229.35,135.41 229.35,137.26 v2(229.7,137.6)
  IN1 w0.381: v2(190.49,91.42) 190.74,91.67 v2(192.85,91.67)
  IN2 w0.508: v2(285.99,74) 283.53,74 282.81,73.29 274.55,73.29
  IN3 w0.254: v2(237.72,137.49) 237.51,137.49 237.19,137.81 237.19,139.58 v2(237.47,139.86) ; v2(253.44,141.13) 253.66,140.91 253.66,138.11 v2(253.15,137.6)
  IN3 w0.381: v2(189.13,94.93) 189.4,94.66 189.4,93.54 190.49,92.45 v2(190.49,91.42) 190.49,90.79 190.08,90.38 190.08,85.01 188.03,82.95 186.45,82.95 183.87,80.37 183.2,80.37 182.35,79.52 182.35,76.61 v2(182.85,76.11)
  BOTTOM w0.109: v2(266.6,138.33) v3(265.74,138.33)
  BOTTOM w0.254: v2(330.82,28.09) 331.11,27.8 UZ45.4 ; v2(325.93,21.74) 325.93,20.47 327.04,19.36 v2(328.16,19.36) ; UZ43.4 v2(182.85,76.11)
  vias: v2(178.98,96.24) v2(179.22,93.95) v2(179.23,93.34) v2(179.73,88.51) v2(179.74,87.9) v2(179.73,87.29) v2(180.96,87.46) v2(180.96,86.29) v2(180.96,85.69) v2(219.09,130.61) v2(269.85,131.41) v2(277.96,142.6) v2(277.96,141.92) v2(278.6,142.6) v2(278.6,141.92) v2(279.23,142.6) v2(279.23,141.92) v2(292.23,56.17) v2(292.22,55.51) v2(292.24,39.72) v2(292.22,38.78) v2(292.35,37.84) v2(292.35,36.82) v2(292.64,56.66) v2(292.89,55.48) v2(292.93,56.09) v2(292.92,39.72) v2(292.9,38.78) v2(293.03,37.84) v2(293.03,36.82) v2(293.68,39.75) v2(293.72,38.79) v2(293.74,37.82) v2(293.74,36.84) v2(294.43,39.77) v2(294.4,38.76) v2(294.44,37.83) v2(294.42,36.84) v2(327.15,28.15) v2(327.23,27.54) v2(327.88,28.08) v2(337.19,41.1) v2(337.22,41.75) v2(337.79,41.12) v2(337.85,41.76) v2(338.46,41.74) v2(338.43,41.1) v2(339.07,41.71) v2(339.07,41.1) v2(351.54,41.22) v2(351.53,40.58) v2(352.07,51.73) v2(352.14,41.11) v2(352.35,40.48) v2(352.57,51.35) v2(352.5,39.57) v2(352.7,50.7) v2(352.92,50.09) v2(352.91,49.46)
+5V_ALW_RP: length 24.5
  TOP w0.254: PR506.2 309.81,42.3 309.81,41.77 309.19,41.16 PU500.14
  TOP w0.381: PR506.2 310.36,42.49 v2(310.36,42.05)
  BOTTOM w0.508: v2(310.36,42.05) 310.36,42.41 308.53,44.24 306.83,44.24 305.87,45.2 301.68,45.2 300.64,44.16 299.47,44.16 297.62,42.32 v3(295.19,42.32) 294.11,42.32 v2(292.54,40.75)
+5V_ALWP: length 8.6
  BOTTOM w0.254: v2(62.8,18.33) 62.51,18.04 62.51,14.84 63.04,14.3 PR114.2 64.8,14.3 65.14,13.96 66.48,13.96 66.55,14.03 PU101.14
  vias: v2(62.33,18.78) v2(63.29,18.81) v2(63.68,18.34) v2(64.09,18.88) v3(64.47,18.31)
+5V_DGFF:
  vias: v2(169.95,101.41) v2(170.02,91.64) v2(170.02,91.03) v2(170.47,101.7) v2(170.47,101.1) v2(170.43,85.88) v2(170.41,85.24) v2(170.62,91.61) v2(170.76,86.41) v2(171.08,92.6) v2(171.08,91.99) v2(171.07,85.91) v2(171.07,85.28) v2(171.1,101.7) v2(171.11,101.1) v3(180.42,81.94)
+5V_DGFF_PWR: length 1.8
  BOTTOM w0.109: 186.15,84.65 187.47,84.65 v1(187.81,84.99)
+5V_HDD: length 2.1
  BOTTOM w0.102: v2(324.02,31.49) v3(323.27,31.49)
  BOTTOM w0.508: v2(345.87,31.18) 345.38,30.69 RN1.1
  vias: v2(324.03,30.59) v2(324.66,31.49) v2(324.64,30.59) v2(345.26,17.13) v2(345.82,16.33) v2(345.84,15.73)
+5V_HDD_UZ23: length 1.1
  TOP w0.109: 326.16,32 v3(326.16,33.11)
+5V_RUN: length 59.4
  TOP w0.254: JKBTP1.5 291.66,12.18 291.66,13.38 v2(291.64,13.4)
  TOP w0.305: v2(178.81,3.86) 178.81,3.62 179.1,3.33 JUSH1.7
  IN1 w0.508: v2(291.64,13.4) 291.64,13.86 291.28,14.22 289.33,14.22 285.56,17.99 281.99,17.99 281.24,18.74 v2(281.24,19.99)
  IN2 w0.381: v2(178.81,3.86) 179.21,3.46 183.06,3.46 183.77,4.17 189.76,4.17 190.79,5.21 v2(192.7,5.21)
  IN2 w0.508: v2(211.64,15.21) 211.64,15.06 208.09,11.51 208.09,9.39 206.8,8.1 204.32,8.1 203.18,6.96 198.64,6.96 196.88,5.21 v2(192.7,5.21)
  IN3 w0.508: v2(280.63,22.09) 280.63,20.61 v2(281.24,19.99)
  BOTTOM w0.356: v2(291.64,13.4) 291.64,12.95 CZ92.1
  vias: v2(79.08,44.18) v2(79.42,53.8) v2(79.67,44.04) v2(79.75,54.32) v2(80.08,53.79) v2(81.82,26.67) v2(82.41,26.67) v2(170.45,130.18) v2(171.06,130.18) v2(171.67,130.88) v2(210.55,93.82) v2(210.52,93.21) v2(211.12,93.69) v2(280.85,58.97) v2(281.28,58.47) v2(281.69,57.96) v2(291.96,51.51) v2(291.96,50.81) v2(291.95,50.01) v2(292.58,50.03) v2(292.6,51.51) v2(292.64,50.81) v2(297.93,52.86) v2(298.64,52.89) v2(299.33,52.89) v2(299.68,54.21) v2(299.68,53.45) v2(303.97,47.74) v2(303.98,46.82) v2(304.41,47.28) v2(331.75,44.19) v2(331.9,43.59) v2(332.4,44.18) v2(332.55,43.58) v2(333.02,44.17) v2(333.67,44.15) v2(341.2,37.91) v2(341.67,38.38) v2(342.09,38.88) v2(342.55,39.28) v3(78.83,53.84)
+5V_RUN_AUDIO: length 1.8
  BOTTOM w0.109: v2(344.54,32.01) 344.54,31.09 v3(343.94,30.5)
+5V_RUN_CHG: length 3.4
  TOP w0.109: 295.71,55.14 294.26,55.14 v3(292.9,53.77)
+5V_RUN_PVDD_L: length 6.4
  TOP w0.203: 345.8,28.19 345.8,27.98 345.96,27.82 UA1.41
  TOP w0.508: 343.59,30.2 344.08,30.69 344.83,30.69 345.32,30.2 345.32,29.02 345.8,28.54 345.8,28.19
  vias: v3(342.04,27.89)
+5V_RUN_PWR:
  vias: v3(337.42,45.5)
+5V_TSP_+3.3V_TSP: length 13.5
  TOP w0.381: JTS1.6 77.14,36.13 77.09,36.08 v2(77.09,33.44) 77.48,33.05 CV850.1
  TOP w0.457: v2(78.32,28.03) 78.32,29.17 FV3.1
  IN2 w0.381: v2(77.09,33.44) 77.01,33.37 77.01,32.73 76.26,31.98 76.26,30.49 78.32,28.43 v2(78.32,28.03)
  BOTTOM w0.109: v2(78.32,28.03) 78.32,27.68 v3(77.81,27.18)
+5V_TSP_+3.3V_TSP_F: length 4.2
  TOP w0.109: QV8.1 79.03,28.39 FV3.2 80.28,29.38 v1(81.27,28.39)
+5V_USB_PWR1: length 1
  BOTTOM w0.109: v2(349.1,52.81) 349.1,53.22 v3(349.51,53.62)
  vias: v2(348.46,52.78) v2(348.49,52.16) v2(349.08,51.36) v2(349.11,52.16) v2(356.09,50.74) v2(356.52,50.27) v2(356.65,51.13) v2(357.05,50.61) v2(357.04,49.97)
+5V_USB_PWR2: length 1.2
  BOTTOM w0.109: v2(357.04,27.35) 356.46,26.76 v3(356.14,26.76)
  vias: v2(348.37,41.88) v2(348.43,41.02) v2(348.84,41.5) v2(348.93,42.22) v2(349.38,41.78) v2(352,31.78) v2(352.6,34.37) v2(352.6,33.75) v2(352.6,33.15) v2(352.6,32.53) v2(356.57,28.02) v2(357.2,28.03) v2(357.8,28.05) v2(357.8,27.34)
+5V_VBUS1:
  vias: v2(38.09,11.71) v2(38.14,12.47) v2(38.76,12.56) v2(38.7,11.84) v2(39.23,12.17) v2(39.31,12.87) v2(41.48,32.04) v2(41.81,33.1) v2(41.82,32.52) v2(42.12,32.01) v2(42.41,33.1) v2(42.45,32.52) v3(37.1,11.93)
+5V_VBUS2: length 3
  BOTTOM w0.109: PQ2104.5 35.77,20.63 v3(35.77,19.13)
  vias: v2(33.5,23.52) v2(33.8,24.07) v2(34.09,23.54) v2(34.38,24.07) v2(34.67,23.54) v2(34.97,24.07) v2(53.74,25.96) v2(54.27,25.72) v2(54.85,25.71) v2(55.44,25.89) v2(55.92,26.22) v2(55.95,25.57)
+13.5VB_BATT: length 25.7
  TOP w0.254: PD701.2 281.34,41.22 279.41,39.29 279.41,22.21 280.65,20.96 280.65,18.14 281.13,17.67
  vias: v2(270.88,13.31) v2(271.13,12.78) v2(271.51,13.32) v2(271.77,12.76) v2(271.79,12.16) v2(272.16,13.31) v2(272.41,12.77) v2(272.41,12.17) v2(272.83,13.31) v2(273.07,12.75) v2(273.08,12.16) v2(273.47,13.32) v2(273.69,12.77) v2(273.7,12.17) v2(274.3,12.73) v2(274.38,12.15) v2(280.14,15.46) v2(280.14,14.85) v2(280.56,14.37) v2(280.74,15.45) v2(281.15,14.98) v2(281.15,14.34) v2(281.34,15.56) v2(281.79,14.98) v2(281.79,14.34) v2(281.98,15.56) v2(282.42,14.98) v2(282.42,14.34) v2(282.61,15.56) v2(283.06,14.98) v2(283.06,14.34) v3(281.71,16.95)
+13.5VB_BATT_C: length 4
  TOP w0.109: 269.01,5.99 269.27,5.73 270.98,5.73 v3(272.35,4.36)
  vias: v2(264.62,9.57) v2(264.66,8.94) v2(265.23,9.56) v2(265.3,8.94) v2(265.88,9.55) v2(265.92,8.95) v2(265.95,8.34) v2(268.32,9.63) v2(268.34,8.95) v2(268.34,8.34) v2(268.96,9.62) v2(268.97,8.92) v2(268.98,8.33) v2(269.6,9.63) v2(269.65,8.92) v2(269.65,8.31) v3(265.44,6.03) v3(265.51,7.83)
+13.5VB_CHG:
  vias: v2(287.99,16.7) v2(288.01,18.53) v2(288.01,17.95) v2(288.01,17.33) v2(288.63,18.56) v2(288.64,17.93) v2(288.63,17.34) v2(288.65,16.71) v2(289.27,18.54) v2(289.27,17.95) v2(289.28,17.33) v2(289.27,16.72) v2(289.29,16.07) v2(289.95,18.54) v2(289.97,17.92) v2(305.02,15.69) v2(305.03,15.06) v2(305.04,14.47) v2(305.04,13.88) v2(305.05,13.29) v2(305.65,15.71) v2(305.66,15.08) v2(305.65,14.5) v2(305.67,13.9) v2(305.66,13.31) v2(306.25,15.71) v2(306.26,15.08) v2(306.29,14.5) v2(306.27,13.91) v2(306.29,13.32) v3(288.57,14.47)
+19.5V_DC_IN: length 43.4
  TOP w0.305: v2(49.32,2.79) 49.55,2.55 JIO1.64
  IN1 w0.254: v2(43.26,5.48) 46.62,5.48 v2(49.32,2.79)
  IN3 w0.254: v2(39.75,14.14) 39.7,14.19 37.15,14.19 36.65,14.69 35.36,14.69 v2(35.34,14.67)
  IN4 w0.254: v2(43.26,5.48) 41.43,7.31 41.43,12.46 v2(39.75,14.14) ; v2(35.34,14.67) 36.15,14.67 36.2,14.72 36.2,18.43 35.87,18.76 35.87,24.73 34.86,25.74 33.43,25.74 v2(33.04,25.36)
  BOTTOM w0.109: v2(49.32,2.79) 49.32,3.24 v3(48.83,3.73) ; v3(43.73,4.93) 43.73,5.01 v2(43.26,5.48) 43.26,6.16 43.49,6.39 v3(44.64,6.39)
  BOTTOM w0.254: DT63.2 33.95,26.13 33.18,25.36 v2(33.04,25.36)
