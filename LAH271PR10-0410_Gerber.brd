# Allegro board LAH271PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CPU_DP3_P3: length 66.4
  TOP w0.076: v2(219.45,111.2) 219.56,111.31 219.71,111.31 219.81,111.21 219.81,110.83 UC1.C33
  TOP w0.109: JDGFF4.B2 176.47,135.55 176.43,135.51 176.43,135.43 176.78,135.08 177.16,135.08 177.83,135.75 178.66,135.75 179.07,135.33 179.07,135.02 179.32,134.77 v2(179.39,134.77)
  IN4 w0.102: v2(219.45,111.2) 219.38,111.27 219.38,111.73 218.97,112.14 218.76,112.14 216.86,114.04 215.24,114.04 213.59,112.39 207.01,112.39 206.4,112.99 200.79,112.99 199.81,113.97 199.81,114.77 198.52,116.06 198.52,116.72 196.34,118.9 196.34,121.34 195.32,122.37 195.32,129.34 195.14,129.52 195.14,131.26 192.87,133.52 187.04,133.52 186.19,132.68 180.63,132.68 178.9,134.41 178.9,134.88 179.04,135.03 179.27,135.03 179.39,134.91 v2(179.39,134.77)
CPU_EDP_HPD: length 108.8
  TOP w0.109: UH1.AN6 180.27,40.7 v2(179.95,40.37)
  IN2 w0.081: v2(179.95,40.37) 179.03,39.46 178.51,39.46 178.23,39.74 177.82,39.74 177.67,39.59 175.05,39.59 174.63,39.17 174.63,38.46 173.47,37.3 170.98,37.3 170.68,37 170.68,36.2 170.34,35.86 168.84,35.86 168.49,35.51 168.49,34.93 167.44,33.88 164.58,33.88 163.6,32.9 163.6,30.84 162.46,29.7 161.92,29.7 161.01,28.79 160.31,28.79 159.94,28.43 159.66,28.43 159.53,28.3 158.57,28.3 158.33,28.06 157.77,28.06 157.33,27.63 154.88,27.63 154.65,27.39 153.42,27.39 152.61,26.59 149.33,26.59 148.41,25.67 148.41,25.21 146.36,23.16 145.98,23.16 144.63,21.81 143.22,21.81 143.06,21.98 141.01,21.98 140.81,21.77 140.47,21.77 140.13,21.44 140.13,19.74 139.64,19.24 139.37,19.24 138.56,18.43 138.45,18.43 137.32,17.3 136.03,17.3 135.84,17.49 133.79,17.49 133.34,17.95 132.21,17.95 131.8,17.54 130.21,17.54 129.53,16.85 125.96,16.85 125.92,16.89 121.5,16.89 120.82,17.56 119.93,17.56 118.13,19.36 117.08,19.36 116.68,19.77 115.49,19.77 115.25,20.01 114.13,20.01 112.78,21.35 112.78,21.76 v2(112.5,22.04)
  BOTTOM w0.109: UV64.3 114.26,35.24 114.96,34.54 115.04,34.54 116.77,32.81 116.77,30.53 v1(113.67,27.44) 113.21,26.98 113.21,23.57 112.5,22.87 v2(112.5,22.04) ; v2(179.95,40.37) 179.8,40.52 179.8,41.97 178.73,43.04 178.73,44.32 178.09,44.97 178.09,45.96 RH1.2
CPU_VIDALERT#: length 14.8
  TOP w0.076: UC1.BH31 254.28,109.66 v2(254.6,109.98)
  BOTTOM w0.102: RC153.2 260.48,117.8 v1(260.48,116.16) 260.48,112.62 259.89,112.03 259.28,112.03 257.83,110.58 257.33,110.58 257.13,110.79 256.62,110.79 255.73,109.9 254.69,109.9 v2(254.6,109.98)
CPU_XDP_HOOK6: length 5.6
  TOP w0.109: RC144.1 277.38,92.84 278.35,92.84 RC115.1 279.52,92.32 v1(279.96,92.76) 280.28,93.08 280.83,93.08 281.16,92.75 JXDP1.46
CPU_XDP_PRDY#: length 48.8
  TOP w0.076: T189.1 260.87,107.52 259.49,106.14 258.36,106.14 UC1.BP27
  TOP w0.109: v2(260.76,106.65) 260.8,106.61 RC314.1 261.46,107.27 261.2,107.52 T189.1 ; v2(283.78,80.11) 284.12,80.45 JXDP1.5
  IN1 w0.102: v2(260.76,106.65) 262.01,106.65 263.61,105.05 264.53,105.05 266.14,103.43 266.14,102.49 266.78,101.86 266.78,98.19 269.16,95.81 270.14,95.81 270.98,94.98 274.91,94.98 276.22,93.68 277.39,93.68 279.74,91.32 279.74,88.72 280.49,87.98 280.67,87.98 281.64,87.01 281.64,85.83 282.75,84.72 283.75,84.72 284.23,84.24 284.23,80.56 v2(283.78,80.11)
CPU_XDP_PREQ#: length 53.3
  TOP w0.076: UC1.BL30 256.28,108.52 259.77,108.52
  TOP w0.109: 259.77,108.52 260.01,108.52 260.19,108.69 262.54,108.69 262.77,108.46 263.08,108.46 264.49,107.05 264.49,106.09 RC138.2 265.19,105.19 v2(265.76,104.63) ; JXDP1.3 284.21,79.85 v2(283.83,79.47)
  IN1 w0.102: v2(283.83,79.47) 284.53,80.18 284.53,84.26 283.84,84.95 282.84,84.95 281.87,85.92 281.87,87.11 281.39,87.59 281.39,90.02 277.43,93.98 276.26,93.98 275.03,95.21 271.07,95.21 270.24,96.04 269.25,96.04 267.01,98.29 267.01,101.95 266.42,102.54 266.42,103.48 265.76,104.14 v2(265.76,104.63)
  BOTTOM w0.109: T190.1 283.8,79.51 v2(283.83,79.47) 283.83,78.04 RC315.1
CPU_XDP_PRS: length 3.8
  TOP w0.109: RC127.1 279.63,99.1 279.72,99.01 280.33,99.01 v1(280.63,98.72) 281.68,97.67 JXDP1.60
CPU_XDP_TCLK: length 40.5
  TOP w0.076: v2(258.79,107.04) 258.79,107.15 UC1.BR28
  TOP w0.109: JXDP1.57 283.35,96.05 282.81,96.59 282.81,97.73 v2(282.27,98.26) 282.27,98.66 282.71,99.09 RC139.1 283.11,99.09 RC143.1
  IN1 w0.102: v2(282.27,98.26) 282.27,97.49 280.72,95.94 276.13,95.94 273.14,98.94 271.21,98.94 269.67,100.47 269.48,100.47 269.13,100.83 269.13,102.37 269.32,102.56 269.32,103.73 268.07,104.97 268.07,106.47 267.53,107.01 264.67,107.01 264.52,107.15 262.11,107.15 261.33,107.93 259.68,107.93 v2(258.79,107.04)
  BOTTOM w0.109: T181.1 259.25,107.5 v2(258.79,107.04)
CPU_XDP_TDI: length 45.7
  TOP w0.076: UC1.BL32 255.78,110.3 255.39,109.9 v2(255.39,109.3)
  TOP w0.109: v2(282.82,95.7) 282.77,95.75 JXDP1.56 281.29,95.75 281.07,95.98 279.44,95.98 RC229.1
  IN1 w0.102: v2(282.82,95.7) 283.09,95.96 283.09,98.51 282.69,98.9 281.81,98.9 281.35,98.44 278.02,98.44 275.9,100.56 271.54,100.56 270.28,101.82 270.28,104.09 269.01,105.36 269.01,107.04 267.72,108.33 266.76,108.33 266.18,108.91 266.18,109.58 265.48,110.29 261.18,110.29 260.09,109.2 259.37,109.2 258.75,108.58 255.63,108.58 255.39,108.81 v2(255.39,109.3)
  BOTTOM w0.109: T185.1 282.84,95.72 v2(282.82,95.7)
CPU_XDP_TDO: length 33.8
  TOP w0.102: 261.27,108.24 261.27,108.25 260.47,108.25 259.99,107.77 259.51,107.77 UC1.BT28
  TOP w0.109: JXDP1.52 281.25,94.55 280.67,95.13 278.65,95.13 CC306.1 277.81,95 277.19,95 RC230.1 276.9,95.44 276.56,95.79 273.42,95.79 v2(273.34,95.86) ; 261.27,108.24 261.43,108.24 262.01,107.66 263.42,107.66 264.25,106.82 264.25,105.97 264.76,105.47 264.76,105.03 265.06,104.73 RC135.1 265.65,103.41 266.73,103.41 v2(267.34,102.79) 267.49,102.65 T184.1
  IN1 w0.102: v2(273.34,95.86) 273.15,95.67 270.93,95.67 270.33,96.27 269.35,96.27 267.34,98.27 v2(267.34,102.79)
CPU_XDP_TMS: length 34.5
  TOP w0.076: 259.68,108.13 259.55,108.13 259.27,107.85 258.29,107.85 UC1.BP28
  TOP w0.102: 259.68,108.13 260.01,108.13 260.31,108.44 262.47,108.44 v2(262.85,108.06)
  TOP w0.109: JXDP1.58 281.15,96.35 280.95,96.55 v2(280.95,96.79) 279.56,98.18 RC228.1
  IN1 w0.102: v2(262.85,108.06) 262.98,107.93 264.5,107.93 264.94,107.49 267.73,107.49 268.56,106.67 268.56,105.17 269.83,103.9 269.83,101.63 270.79,100.67 271.37,100.08 275.63,100.08 277.73,97.98 279.75,97.98 v2(280.95,96.79)
  BOTTOM w0.109: T180.1 v2(262.85,108.06)
CPU_XDP_TRST#: length 205.8
  TOP w0.089: 260.12,109.46 258.33,109.46 UC1.BP30
  TOP w0.109: JXDP1.54 281.29,95.15 v2(280.98,95.46) 280.88,95.36 277.82,95.36 RC136.1 CC308.1 ; v2(177.31,49.5) 177.31,48.72 179.95,46.08 179.95,44.5 180.45,44 180.45,42.47 180.62,42.31 180.62,42.08 180.93,41.76 UH1.AM4 ; v2(265.06,108) 264.61,108 262.77,109.85 260.81,109.85 260.42,109.46 260.12,109.46
  IN1 w0.102: v2(265.06,108) 265.06,108.17 265.4,108.51 266.26,108.51 266.75,108.02 267.53,108.02 268.78,106.76 268.78,105.27 270.05,104 270.05,101.72 271.47,100.31 275.73,100.31 277.82,98.21 281.45,98.21 281.9,98.67 282.58,98.67 282.84,98.4 282.84,97.33 v2(280.98,95.46) 281.75,94.69 281.75,93.21 284.19,90.77 284.19,89.73 284.98,88.94 284.98,79.3 283.64,77.96 281.99,77.96 v2(281.54,78.42)
  BOTTOM w0.109: v2(281.54,78.42) 280.56,78.42 280.19,78.05 276.31,78.05 273.28,75.02 254.32,75.02 253.59,75.75 209.3,75.75 203.16,81.89 198.42,81.89 197.87,81.34 195.05,81.34 193.41,79.69 193.41,79.02 191.56,77.18 191.56,75.3 190.85,74.58 190.85,71.72 189.44,70.31 189.44,66.03 185.46,62.06 185.46,61.16 183.94,59.63 v3(183.63,59.63) 183.01,59.63 181.13,57.75 181.13,55.59 178.46,52.91 178.46,52.29 177.31,51.14 v2(177.31,49.5) ; v2(265.06,108) 265.34,107.72 T179.1
CS_1.2V: length 5.3
  TOP w0.203: PU200.13 203.58,9.1 203.99,8.69 204.55,8.69 v1(204.69,8.83) 204.74,8.83 205.73,7.84 206.29,7.84 PR201.2
CSCOMP_2PH: length 25.2
  TOP w0.203: PC1124.1 PC1125.1 270.81,142.75 270.73,142.83 270.73,143.29 PR1141.1 PR1139.2 268.56,143.67 v2(268.31,143.67) 267.8,143.67 267.35,144.13 PU1100.31
  BOTTOM w0.254: v2(268.31,143.67) v1(269.03,143.67) 269.43,143.67 271.07,142.03 271.07,138.47 270.26,137.65 266.13,137.65 263.66,135.17 263.26,135.17 262.22,134.13 262.22,133.47 PH1102.1
CSCOMP_4PH: length 27.6
  TOP w0.109: v2(254.1,131.2) 254.69,131.2 v1(255.02,130.87)
  TOP w0.203: PU1100.8 259.18,144.53 258.6,143.95 257.9,143.95 PC1122.2 PC1121.1 256.77,145.04 PR1138.1 255.01,145.05 PR1140.1
  TOP w0.254: PH1101.1 v2(254.1,131.2) ; v2(254.16,145.09) PR1140.1
  IN4 w0.254: v2(254.1,131.2) 255.02,132.12 255.02,133.08 258.02,136.08 258.02,143.49 256.42,145.09 v2(254.16,145.09)
CSN_1PH: length 89
  TOP w0.203: PL1800.3 215.76,123.92 216.48,123.2 v2(216.48,121.46)
  TOP w0.254: v2(216.48,121.46) 216.48,120.84 PH1100.1
  IN1 w0.254: v2(243.33,152.9) 243.33,152.2 239.75,148.62 235.28,148.62 227.07,140.41 223.07,140.41 216.63,133.96 214.41,133.96 213.65,133.2 209.33,133.2 208.12,131.99 208.12,126.24 208.86,125.5 208.86,124.29 209.21,123.95 210.49,123.95 211.69,122.74 211.69,121.07 212.68,120.09 216.09,120.09 216.54,120.54 216.54,121.41 v2(216.48,121.46)
  IN4 w0.254: v2(262.09,151.87) 261.88,151.67 244.23,151.67 243.33,152.57 v2(243.33,152.9)
  BOTTOM w0.109: v1(261.86,152.66) 262.09,152.43 v2(262.09,151.87)
  BOTTOM w0.203: v2(262.09,151.87) 262.1,151.87 262.1,151.26 PR1169.1
CSN_1PH_R: length 6.8
  TOP w0.203: PC1102.1 PC1104.1 v2(262.1,149.53) 262.4,149.23 262.4,148.81 262.58,148.63 PU1100.48
  BOTTOM w0.109: v1(261.06,150.66) 261.42,150.31 PR1169.2
  BOTTOM w0.203: PC1137.1 261.88,149.32 v2(262.1,149.53) 262.13,149.57 PR1169.2
CSON_1: length 13.3
  TOP w0.254: PR728.1 285.92,25.03 PC720.1 286.03,24.18 PC719.2 286.44,23.39 286.05,22.99 286.05,21.9 v2(285.9,21.75) ; v2(285.47,14.93) 285.18,15.22 PR715.3
  BOTTOM w0.254: v2(285.47,14.93) 284.99,15.41 284.99,17.42 286.05,18.47 v1(286.05,20.13) 286.05,21.6 v2(285.9,21.75)
CSOP_1: length 12.3
  TOP w0.254: PR715.2 285.88,15.22 v2(285.47,15.63) ; PC718.2 287.32,25.07 PR727.1 287.29,24.25 PC719.1 287.36,23.76 286.45,22.85 286.45,21.91 v2(286.6,21.76)
  BOTTOM w0.254: v2(285.47,15.63) 285.47,16.39 v1(285.96,16.88) 286.58,17.49 286.58,21.74 v2(286.6,21.76)
CSP1_2PH: length 6
  TOP w0.203: 267.81,141.23 267.81,142.18 267.06,142.93 PU1100.28
  TOP w0.254: 267.81,141.23 v2(267.81,141.14)
  BOTTOM w0.109: v1(269.99,140.91) PR1160.1
  BOTTOM w0.254: v2(267.81,141.14) 267.81,141.77 PC1132.2 267.88,141.81 268.78,140.91 PR1160.1
CSP1_4PH: length 5.3
  TOP w0.203: PU1100.11 259.74,143.33 v1(258.7,142.28) 257.88,141.46 PC1131.2 v2(257.27,140.82)
  BOTTOM w0.203: PR1154.2 257.18,140.73 v2(257.27,140.82)
CSP2_4PH: length 7.3
  TOP w0.203: v2(257.24,139.68) PC1133.2 258.45,140.25 259.11,140.25 259.48,140.62 259.48,142.59 259.81,142.93 PU1100.12
  BOTTOM w0.109: v2(257.24,139.68) 257.58,139.68 v1(257.93,140.02)
  BOTTOM w0.203: v2(257.24,139.68) 257.13,139.56 PR1161.2
CSP3_4PH: length 8.1
  TOP w0.203: v2(257.27,138.41) PC1135.2 258.51,139.04 259.54,139.04 259.95,139.45 259.95,140.55 259.81,140.69 259.81,142.36 259.98,142.53 PU1100.13
  BOTTOM w0.109: v2(257.27,138.41) v1(257.93,138.41)
  BOTTOM w0.203: v2(257.27,138.41) 257.23,138.37 PR1163.2
CSP4_4PH: length 15.3
  TOP w0.203: PU1100.26 265.78,141.53 266.72,140.58 v2(266.76,140.58)
  IN2 w0.203: v2(257.32,141.99) 263.09,141.99 263.7,141.39 265.95,141.39 v2(266.76,140.58)
  BOTTOM w0.203: PC1136.2 v1(256.85,143.22) 256.49,142.86 PR1164.2 v2(257.32,141.99)
CSP_1PH: length 94.6
  TOP w0.203: PC1102.2 PC1104.2 v2(263.01,149.67) 262.7,149.36 262.7,148.95 262.98,148.67 PU1100.47
  IN1 w0.254: v2(241.98,152.92) 241.98,151.85 239.46,149.33 234.98,149.33 226.78,141.12 222.78,141.12 216.33,134.68 214.12,134.68 213.35,133.91 209.04,133.91 207.41,132.28 207.41,125.94 208.15,125.2 208.15,124 208.91,123.23 210.19,123.23 210.98,122.45 210.98,120.78 212.38,119.38 216.38,119.38 217.25,120.24 217.25,120.64 217.81,121.2 v2(218.07,121.2)
  IN4 w0.254: v2(241.98,152.92) 243.94,150.95 261.73,150.95 v2(263.01,149.67)
  BOTTOM w0.109: v1(263.93,150.98) 263.25,150.3 PR1101.2
  BOTTOM w0.203: v2(263.01,149.67) 263.02,149.68 PR1101.2 ; PR1102.1 v2(218.07,121.2)
CSREF_2PH: length 25.2
  TOP w0.203: v2(268.56,141.85) 268.56,142.21 268.09,142.67 267.78,142.67 267.13,143.33 PU1100.29
  TOP w0.254: v2(264.23,133.84) 263.49,134.57 262.56,134.57 v3(259.87,131.88) 259.05,131.07 PR1703.2
  IN4 w0.254: v2(264.23,133.84) 264.23,133.85 267.31,136.93 267.31,139.57 268.56,140.82 v2(268.56,141.85)
  BOTTOM w0.203: PC1126.1 267.58,144.43 267.58,142.99 PC1132.1
  BOTTOM w0.254: PC1132.1 268.29,142.72 268.56,142.45 v2(268.56,141.85)
CSREF_4PH: length 55.3
  TOP w0.109: PC1135.1 v1(258.79,137.1)
  TOP w0.203: v2(259.17,143.4) 259.5,143.73 PU1100.10 ; PC1131.1 v2(258.79,141.48) ; PC1133.1 v2(259.41,139.68) ; v2(259.41,138.41) PC1135.1
  IN4 w0.254: v2(259.17,143.4) 259.17,141.86 v2(258.79,141.48) 258.79,140.3 v2(259.41,139.68) v2(259.41,138.41) 258.93,137.93 258.93,134.59 252.97,128.63 251.44,128.63 v2(251.03,128.23) 250.57,128.23 250.14,127.8 246.67,127.8 v2(245.77,126.9) 244.78,127.9 239.26,127.9 v2(238.23,126.87) 237.16,127.94 235.2,127.94 233.75,126.49 229.68,126.49 v2(228.83,125.64)
  BOTTOM w0.203: v2(259.17,143.4) 259.62,143.85 PC1123.2 258.7,144.17 PC1136.1
  BOTTOM w0.254: PR1215.2 228.83,125.29 v2(228.83,125.64) ; PR1207.2 245.35,127.33 v2(245.77,126.9) ; v2(238.23,126.87) 237.88,127.21 PR1214.2 ; PR1203.2 v2(251.03,128.23)
CSSN_1: length 3.7
  TOP w0.203: PR704.1 60.86,9.98 60.64,10.2 60.64,10.63 PR702.1 60.68,11.17 60.68,12.21 60.93,12.46 PR700.3
CSSN_2: length 280.4
  TOP w0.203: PR704.2 60.81,9.06 60.66,8.91 60.66,8.61 v2(60.85,8.42) ; PU700.1 288.67,32.55 288.85,32.74 289.29,32.74 290.1,33.55 290.98,33.55 PC701.2 292.04,34.61 PC702.1 292.03,35.03 291.55,35.03 v2(291.34,34.82) ; v2(252.99,11.7) 253.08,11.79 253.08,12.81 261.73,21.46 267.72,21.46 268.25,20.93 268.25,20.65 v2(268.57,20.32)
  IN1 w0.203: v2(252.99,11.7) 253.12,11.83 253.12,11.84 253.13,11.84 253.13,12.02 253.13,12.11 252.96,12.27 252.67,12.27 252.51,12.11 252.51,11.78 251.3,10.56 248.1,10.56 247.38,9.84 238.48,9.84 237.06,11.26 228.9,11.26 228.34,11.82 219.65,11.82 219.15,11.31 211.78,11.31 208.72,8.25 208.23,8.25 207.41,7.43 206.23,7.43 205.3,6.5 199.98,6.5 197.47,3.99 192.01,3.99 191.93,3.9 190.24,3.9 190.1,3.76 184.04,3.76 182.82,2.54 178.9,2.54 177.22,4.22 173.67,4.22 169.83,8.05 165.44,8.05 164.66,7.28 161.07,7.28 157.79,10.56 156.76,10.56 155.96,11.36 155.16,11.36 154.59,10.79 152.33,10.79 151.53,9.99 149.22,9.99 148.4,10.8 143.82,10.8 143.18,10.16 141.71,10.16 140.38,8.83 140.38,8.09 139.77,7.48 138.94,7.48 138.58,7.84 135.65,7.84 134.55,6.74 130.84,6.74 130.22,6.12 127.55,6.12 125.45,8.22 124.07,8.22 121.3,5.45 120.46,5.45 120.03,5.02 117.09,5.02 113.89,1.82 101.28,1.82 100.34,2.76 96.62,2.76 95.33,4.06 95.33,5.46 93.64,7.15 90.68,7.15 89.84,6.31 78.41,6.31 76.18,8.54 75.03,8.54 74.81,8.77 72.38,8.77 71.85,9.3 71.85,10.91 71.59,11.17 69.44,11.17 67.87,12.73 62.6,12.73 60.68,10.81 60.68,8.59 v2(60.85,8.42) ; v2(268.57,20.32) 268.57,20.56 268.7,20.69 274.32,20.69 279.64,26.01 279.64,31.06 281.25,32.67 285.61,32.67 285.97,32.31 288.09,32.31 290.78,35.01 291.15,35.01 v2(291.34,34.82)
CSSP_1: length 3.7
  TOP w0.203: PR703.1 60.12,9.98 60.31,10.16 60.31,10.63 PR702.2 60.35,11.26 60.35,12.2 60.09,12.46 PR700.2
CSSP_2: length 280.7
  TOP w0.203: PU700.2 288.27,32.76 288.62,33.12 289.17,33.12 289.94,33.89 290.4,33.89 PC701.1 290.64,34.2 PC700.2 290.89,35.04 v2(291.33,35.49) ; PR703.2 60.17,9.06 60.33,8.9 60.33,8.57 v2(60.19,8.42) ; v2(253.59,11.7) 253.41,11.88 253.41,12.67 261.87,21.13 267.59,21.13 267.92,20.8 267.92,20.51 v2(267.73,20.32)
  IN1 w0.203: v2(60.19,8.42) 60.35,8.59 60.35,10.95 62.46,13.06 68.01,13.06 69.57,11.5 71.73,11.5 72.18,11.05 72.18,9.44 72.52,9.1 74.94,9.1 75.17,8.87 76.32,8.87 78.55,6.64 89.7,6.64 90.54,7.48 93.78,7.48 95.66,5.59 95.66,4.19 96.76,3.09 100.47,3.09 101.42,2.15 113.75,2.15 116.95,5.35 119.89,5.35 120.32,5.78 121.16,5.78 123.93,8.55 125.59,8.55 127.69,6.45 130.09,6.45 130.7,7.07 134.41,7.07 135.51,8.17 138.72,8.17 139.08,7.81 139.63,7.81 140.05,8.22 140.05,8.97 141.58,10.49 143.04,10.49 143.68,11.13 148.54,11.13 149.35,10.32 151.39,10.32 152.19,11.12 154.45,11.12 155.06,11.72 156.07,11.72 156.9,10.89 157.92,10.89 161.21,7.61 164.52,7.61 165.3,8.38 169.97,8.38 173.81,4.55 177.36,4.55 179.03,2.87 182.69,2.87 183.91,4.09 189.96,4.09 190.11,4.24 191.79,4.24 191.88,4.32 197.33,4.32 199.84,6.83 205.16,6.83 206.1,7.76 207.27,7.76 208.09,8.58 208.58,8.58 211.64,11.64 219.01,11.64 219.51,12.15 228.48,12.15 229.03,11.6 237.19,11.6 238.62,10.17 247.24,10.17 247.97,10.89 251.16,10.89 252.16,11.89 252.16,12.23 252.54,12.6 253.1,12.6 253.46,12.25 253.46,12.02 253.46,11.83 v2(253.59,11.7) ; v2(291.33,35.49) 291.18,35.34 290.64,35.34 287.95,32.64 286.1,32.64 285.75,33 281.11,33 279.31,31.2 279.31,26.15 274.18,21.02 268.56,21.02 267.87,20.32 v2(267.73,20.32)
CSSUM_2PH: length 9.5
  TOP w0.203: PU1100.30 267.25,143.73 267.89,143.09 268.2,143.09 269.1,142.2 ; PR1144.2 271.86,143.04 v1(271.86,142.05) 271.86,141.8 271.54,141.48 PC1125.2 PC1124.2
  TOP w0.254: 269.1,142.2 269.1,141.34 PR1145.1 269.55,141.11 PC1124.2
CSSUM_4PH: length 11.9
  TOP w0.109: v1(256.17,136.75) 256.55,137.12 PR1148.2
  TOP w0.203: PR1148.2 PR1146.2 PR1143.2 PR1149.2 255.89,142.67 PR1142.2 PC1121.2 PC1122.1 258.39,143.26 259.25,144.13 PU1100.9
CV2_ON: length 57.8
  TOP w0.109: RE539.2 145.6,16.11 145.32,15.84 v3(145.29,15.84) 144.71,15.84 v2(144.41,16.13) ; v2(187.6,3.26) JUSH1.24
  IN3 w0.081: v2(187.6,3.26) 186.79,2.44 181.14,2.44 178.56,5.03 175.2,5.03 171.79,8.44 165.87,8.44 164.69,7.26 160.36,7.26 157.57,10.05 156.5,10.05 155.89,9.45 144.99,9.45 144.16,10.27 144.16,15.88 v2(144.41,16.13)
CV2_ON_R: length 34.9
  TOP w0.102: UE1.H8 v2(135.93,23.25)
  TOP w0.109: v2(143.09,18.2) 143.32,17.96 v1(144.16,17.96) RE539.1 145.92,17.96 146.19,17.7 146.19,17.28 146.68,16.79 RE736.2
  BOTTOM w0.102: v2(135.93,23.25) 135.93,23.5 136.34,23.91 136.34,25.03 136.53,25.22 136.9,25.22 137.12,25.43 137.12,26.59 137.39,26.86 137.76,26.86 137.91,27.02 137.91,27.43 140.05,29.57 140.67,29.57 141.89,30.8 143.85,30.8 144.49,31.44 145.04,31.44 145.86,30.61 145.86,28.15 146.87,27.14 146.87,26.37 145.22,24.71 145.22,23.06 144.51,22.35 144.51,19.87 143.09,18.44 v2(143.09,18.2)
DAT_TP_SIO_I2C_CLK: length 221.7
  TOP w0.102: UE1.C12 v2(139.13,28.05)
  TOP w0.109: CZ80.1 RZ22.2 RZ347.1 279.37,7.47 v3(279.6,7.25) 280.17,6.68 280.17,5.32 278.64,3.8 v2(278.64,3.58)
  IN2 w0.081: v2(211.89,7.27) 212.34,7.72 212.34,9.72 211.76,10.31 211.76,11.32 213.25,12.81 219.74,12.81 220.42,13.49 230.57,13.49 231.14,14.06 238.54,14.06 238.93,13.67 252.15,13.67 252.47,13.99 260.32,13.99 261.08,14.75 264.75,14.75 265.51,13.99 265.51,12.69 267.68,10.52 267.68,7.8 269.89,5.59 273.17,5.59 275.06,3.69 278.54,3.69 v2(278.64,3.58)
  IN4 w0.102: v2(139.13,28.05) 138.39,28.05 138,28.44 134.52,28.44 133.72,29.23 130.91,29.23 130.5,28.82 130.5,28.06 129.3,26.86 127.99,26.86 126.51,25.38 125.75,25.38 124.88,24.5 124.88,24.18 122.71,22.02 122.71,20.32 122,19.61 120.21,19.61 119.73,19.13 119.73,18.32 121.23,16.82 121.23,15.47 126.14,10.56 129.02,10.56 130.02,9.56 134.28,9.56 134.77,9.07 136.65,9.07 136.96,9.38 140.69,9.38 141.87,10.56 145.69,10.56 147.01,11.87 147.8,11.87 149.4,13.47 151.47,13.47 151.95,12.99 152.78,12.99 152.97,13.19 153.56,13.19 153.76,12.99 155.62,12.99 156.36,12.26 158.11,12.26 159.24,11.12 159.24,10.77 161.21,8.8 165.22,8.8 165.77,8.25 171.52,8.25 174.82,4.96 177.77,4.96 178.33,4.39 179.1,4.39 179.87,3.63 182.59,3.63 183.32,4.35 193.45,4.35 193.6,4.2 205.6,4.2 205.89,3.92 209.14,3.92 210.02,4.8 210.02,6.61 210.68,7.27 v2(211.89,7.27)
DAT_TP_SIO_R: length 14.8
  TOP w0.109: RZ18.2 275.72,8.39 RZ22.1 277.05,8.86 280.4,8.86 v1(280.56,9.02) 280.71,9.17 280.71,10.08 280.98,10.36 285.37,10.36 285.46,10.28 286.73,10.28 286.82,10.36 286.83,10.36 287.33,10.86 287.33,11.26 287.66,11.6 JKBTP1.13
DCIN1_EN: length 89.4
  TOP w0.102: UE1.K4 v2(131.93,21.65)
  TOP w0.109: JIO1.8 63.55,2.33 65.15,3.93 65.15,4.38 v2(65.01,4.52)
  IN3 w0.081: v2(131.93,21.65) 132.33,21.25 132.33,19.72 130.66,18.05 130.66,17.92 129.69,16.95 127.12,16.95 125.97,15.8 122.12,15.8 121.51,15.19 104.43,15.19 104.14,14.9 95.33,14.9 92.87,12.44 88.95,12.44 88.06,11.55 81.66,11.55 80.43,10.32 80.43,8.6 80.23,8.4 80.23,7.49 79.59,6.85 78.14,6.85 77.18,7.81 77.18,10.57 76.12,11.63 70.78,11.63 69.73,10.58 67.4,10.58 66.71,9.88 66.54,9.88 65.83,9.17 65.83,8.56 65.54,8.28 65.54,7.79 64.89,7.13 64.89,4.64 v2(65.01,4.52)
DCIN2_EN: length 137.3
  TOP w0.102: v2(138.33,20.85) UE1.L12
  TOP w0.109: v2(46.94,18.29) 46.61,17.96 v1(45.9,17.96) 45.81,18.05 45.81,19.75 45.84,19.78 45.84,19.99 PR36.1
  IN2 w0.081: v2(46.94,18.29) 47.09,18.14 53.11,18.14 54.73,19.77 57.26,19.77 58.57,21.08 58.57,21.82 58.79,22.04 59.22,22.04 59.44,21.82 59.44,21.76 60.47,20.72 63.51,20.72 63.97,21.18 75.96,21.18 76.91,22.13 76.91,23.66 77.7,24.45 80.13,24.45 81.12,23.46 82.58,23.46 82.98,23.06 82.98,18.2 82.33,17.55 80.21,17.55 79.35,16.69 79.35,10.6 80.51,9.44 80.51,8.72 80.75,8.48 81.41,8.48 82.27,7.61 v2(82.27,7.17)
  IN3 w0.081: v2(138.33,20.85) 138.33,19.49 137.49,18.66 137.49,18.28 138.4,17.37 138.4,13.14 137.79,12.53 137.79,11.89 135.98,10.07 134.95,10.07 134.54,9.67 130.16,9.67 128.52,8.02 127.43,8.02 125.92,9.53 122.25,9.53 120.92,10.87 119.41,10.87 118.97,10.42 111.32,10.42 109.83,11.92 96.2,11.92 93.12,8.83 93.12,8.28 92.8,7.96 91.95,7.96 91.19,7.21 83.18,7.21 83,7.03 82.41,7.03 v2(82.27,7.17)
DCIN3_EN: length 98
  TOP w0.102: UE1.J6 v2(133.53,22.45)
  TOP w0.109: v1(66.31,12.03) 66.41,11.93 v2(66.99,11.93)
  IN2 w0.081: v2(66.99,11.93) 66.49,12.42 64.72,12.42 61.16,15.98 61.16,17.03 60.01,18.18 60.01,18.19 59.77,18.43 58.51,18.43 57.39,17.3 v2(55.87,17.3)
  IN3 w0.081: v2(66.99,11.93) 67.2,12.13 76.27,12.13 77.56,10.83 78,10.83 78.29,10.54 78.6,10.54 78.94,10.2 78.94,8.91 79.42,8.44 79.61,8.44 79.91,8.73 79.91,10.3 79.7,10.51 79.7,11.75 80.84,12.9 84.31,12.9 85.21,12 87.87,12 88.76,12.89 92.68,12.89 95.15,15.36 103.96,15.36 104.24,15.65 121.32,15.65 122.62,16.95 126.46,16.95 126.93,17.41 127.34,17.41 128.72,18.8 129.38,18.8 130.24,19.65 131.08,19.65 131.54,20.11 131.54,21.8 131.8,22.06 133.08,22.06 133.47,22.45 v2(133.53,22.45)
  BOTTOM w0.109: v2(55.87,17.3) 55.04,17.3 54.21,18.14 53.72,18.14 53.34,18.52 PR54.1
DDR4_DRAMRST#_PCH: length 168
  TOP w0.089: v2(175.92,21.16) 175.82,21.06 UH1.BB46
  TOP w0.109: v2(249.62,67.95) 249.55,67.95 v1(247.76,66.16) 247.56,65.97 239.34,65.97 235.45,69.85 213.05,69.85 202.9,80 202.58,80 v2(202.15,80.43)
  IN2 w0.081: v2(202.15,80.43) 202.67,80.43 204.7,82.46 v2(204.7,83.4)
  IN3 w0.081: v2(181.24,60.02) 180.24,60.02 174.19,53.98 172.95,53.98 166.76,47.78 166.76,46.61 164.88,44.73 164.88,43.99 164.08,43.19 164.08,40.94 164.81,40.21 164.81,38.59 166.08,37.32 167.16,37.32 168.12,36.36 168.12,34.84 168.59,34.37 170.23,34.37 171.7,32.9 173.46,32.9 174.31,32.05 177.81,32.05 178.18,31.68 178.43,31.68 178.61,31.51 178.61,31.11 178.4,30.9 177.52,30.9 177.07,30.45 177.07,29.77 177.41,29.43 178.18,29.43 178.56,29.04 178.56,27.47 178.92,27.1 179.16,27.1 179.68,26.59 179.68,24.47 179.24,24.03 179.24,23.7 179.48,23.46 179.48,21.84 178.46,20.83 176.25,20.83 v2(175.92,21.16)
  BOTTOM w0.102: v2(249.62,67.95) 249.84,67.95 250.52,67.26 CD5.1
  BOTTOM w0.109: CD5.1 RD77.1 251.41,65.62 RD4.2 251.54,65.59 RD76.1 ; v2(181.24,60.02) 182.4,60.02 187.79,65.42 187.79,70.05 189.53,71.79 189.53,76.82 194.76,82.04 197.3,82.04 198.66,83.4 v2(204.7,83.4)
DDR_A_ACT#: length 69
  TOP w0.076: UC1.AU3 246.14,88.61 246.14,86.97 245.72,86.55 245.72,84.9 v2(246.12,84.51)
  TOP w0.211: JDIMM2.114 247.18,38.47 247.83,39.12 248.33,39.12 248.5,39.29 248.5,39.54 248.33,39.71 247.83,39.71 247.65,39.88 247.65,40.83 247.39,41.09 v2(247.09,41.09)
  IN4 w0.188: v2(246.12,84.51) 247.41,83.21 247.41,80.87 248.14,80.14 248.14,78.65 248.79,77.99 248.79,75.63 250.83,73.6 250.83,73.3 250.66,73.13 250.13,73.13 249.96,72.97 249.96,72.73 250.13,72.56 250.66,72.56 250.83,72.4 250.83,68.66 250.08,67.91 250.08,67.7 250.25,67.53 250.64,67.53 250.8,67.37 250.8,67.13 250.64,66.97 250.03,66.97 249.86,66.8 249.86,66.35 249.67,66.15 249.5,66.15 249.21,66.45 249.01,66.45 248.64,66.08 248.64,65.9 249.08,65.46 249.08,63.63 248.69,63.25 248.69,62.87 248.86,62.7 249.03,62.7 249.2,62.54 249.2,62.3 249.03,62.13 248.86,62.13 248.69,61.97 248.69,61.73 248.86,61.56 249.03,61.56 249.2,61.4 249.2,61.16 249.03,61 248.86,61 248.69,60.83 248.69,60.53 248.03,59.87 247.81,59.87 247.66,60.02 247.43,60.02 247.24,59.83 247.24,59.25 247.74,58.75 247.74,58.2 248.12,57.82 248.12,57.38 248.64,56.85 248.64,53.82 248.16,53.34 248.16,42.46 247.09,41.38 v2(247.09,41.09)
  BOTTOM w0.211: JDIMM1.114 247.18,45.13 247.71,44.59 247.71,41.84 247.09,41.21 v2(247.09,41.09)
DDR_A_ALERT#: length 66.8
  TOP w0.076: UC1.AU5 246.47,89.58 246.47,87.47 246.52,87.42 246.52,86.4
  TOP w0.102: v2(246.81,85.2) 246.81,86.11 246.52,86.4
  TOP w0.211: JDIMM2.116 246.68,38.42 247.31,39.06 247.31,39.26 247.17,39.4 246.75,39.4 246.3,38.95 246.09,38.95 245.97,39.06 245.97,39.43 246.35,39.8 246.35,40.74 246.46,40.86 246.65,40.86 v2(247.04,40.47)
  IN4 w0.188: v2(247.04,40.47) 247.05,40.47 248.53,41.96 248.53,50.33 249.05,50.84 249.05,57.15 248.53,57.67 248.53,59.2 250.16,60.83 250.16,65.32 251.65,66.81 251.65,73.94 249.61,75.97 249.61,78.18 248.96,78.83 248.96,80.75 248.52,81.19 248.52,82.87 246.81,84.58 v2(246.81,85.2)
  BOTTOM w0.211: v2(247.04,40.47) 246.66,40.85 246.66,41.27 247.4,42.01 247.4,44.41 246.68,45.14 JDIMM1.116
DDR_A_BA0: length 71.5
  TOP w0.076: v2(239.08,86.34) 238.82,86.61 238.82,89.69 UC1.AH5
  TOP w0.211: v2(235.72,41.32) 235.52,41.52 235.35,41.52 235.18,41.35 235.18,39.93 236.18,38.94 JDIMM2.150
  IN4 w0.076: 236.17,78.12 236.17,78.47 237.84,80.13 237.84,84.33 238.47,84.96 238.47,85.74 v2(239.08,86.34)
  IN4 w0.188: 236.17,78.12 236.17,75.77 232.37,71.97 232.37,71.73 232.71,71.39 232.71,71.16 232.5,70.95 232.25,70.95 231.94,71.26 231.69,71.26 231.52,71.09 231.52,70.84 231.78,70.58 231.78,69.05 231,68.27 231,66.65 229.81,65.46 229.81,63.74 228.91,62.84 228.91,61.14 229.81,60.24 229.81,59.09 231.12,57.77 231.12,54.01 231.67,53.46 231.67,52.28 233.16,50.79 233.16,48.02 235.92,45.26 235.92,44.69 235.73,44.51 235.48,44.51 235.23,44.25 235.23,41.81 234.61,41.2 234.61,40.07 234.78,39.91 235.02,39.91 235.19,40.07 235.19,41.05 235.45,41.32 v2(235.72,41.32)
  BOTTOM w0.211: JDIMM1.150 236.18,41.77 v2(235.72,41.32)
DDR_A_BA1: length 69.8
  TOP w0.076: v2(239.08,84.44) 238.32,85.2 UC1.AH1
  TOP w0.211: v2(237.18,43.59) 237.18,43.97 237.37,44.16 237.82,44.16 237.96,44.02 237.96,43.36 238.12,43.2 238.51,43.2 238.68,43.37 238.68,44.61 238.38,44.92 237.64,44.92 237.43,45.13 JDIMM2.145
  IN4 w0.076: 237.23,78.12 237.23,78.59 238.39,79.74 238.39,83.75 v2(239.08,84.44)
  IN4 w0.188: v2(237.18,43.59) 236.98,43.79 236.98,45.7 235.4,47.28 235.4,50.05 232.73,52.72 232.73,57.67 230.87,59.54 230.87,65.02 231.04,65.2 231.29,65.2 231.46,65.02 231.46,62.08 231.64,61.91 231.88,61.91 232.06,62.08 232.06,67.83 232.84,68.61 232.84,69.79 233.77,70.72 233.77,71.87 237.23,75.33 237.23,78.12
  BOTTOM w0.211: JDIMM1.145 237.43,39 236.78,39.64 236.78,43.2 v2(237.18,43.59)
DDR_A_BG0: length 67.9
  TOP w0.076: UC1.AU1 245.86,87.02 245.45,86.6 245.45,84.62 245.95,84.11 246.76,84.11 248.63,82.24 v2(249.43,82.24)
  TOP w0.211: v2(249.03,40.81) 249.03,41.92 247.8,43.15 247.8,44.27 246.93,45.14 JDIMM2.115
  IN4 w0.188: v2(249.03,40.81) 248.57,40.36 248.57,39.7 248.42,39.55 248.09,39.55 247.9,39.74 247.9,40.53 249.03,41.65 249.03,43.28 249.68,43.93 249.68,45.12 249.5,45.3 249.5,57.8 249.69,57.99 249.69,59.08 250.98,60.37 250.98,64.98 252.47,66.47 252.47,74.28 250.44,76.31 250.44,78.52 249.79,79.17 249.79,80.95 249.43,81.31 v2(249.43,82.24)
  BOTTOM w0.211: JDIMM1.115 246.93,39.15 247.46,39.68 247.46,40.16 247.92,40.63 247.92,41.43 248.1,41.61 248.36,41.61 248.52,41.44 248.52,40.96 248.68,40.81 v2(249.03,40.81)
DDR_A_BG1: length 69.6
  TOP w0.076: v2(250.32,81.34) 248.88,81.34 v1(247.48,82.73) 246.45,83.76 245.99,83.76 245.19,84.56 245.19,86.78 245.58,87.17 245.58,87.95 UC1.AU2
  TOP w0.211: JDIMM2.113 247.43,45.17 248.1,44.5 248.1,43.43 249.49,42.04 249.49,40.06 v2(249.06,39.63)
  IN4 w0.188: v2(250.32,81.34) 250.32,79.39 250.98,78.73 250.98,76.53 253,74.5 253,66.25 251.51,64.76 251.51,60.15 250.36,59 250.36,57.75 250.53,57.58 250.53,53.76 250.02,53.25 250.02,43.53 249.49,43 249.49,40.06 v2(249.06,39.63)
  BOTTOM w0.211: JDIMM1.113 247.43,39.2 247.81,39.58 247.81,40.08 248.2,40.47 248.43,40.47 248.58,40.33 248.58,39.44 248.41,39.27 248.41,39 248.58,38.83 249.33,38.83 249.63,39.13 249.63,39.47 249.46,39.63 v2(249.06,39.63)
DDR_A_CB0: length 71.3
  TOP w0.076: UC1.BA2 248.38,87.99 248.63,87.73 248.63,87.73 248.66,87.7 248.66,87.26 249.93,85.98 249.93,84.66 249.99,84.6
  TOP w0.152: v2(250.86,82.82) 250.86,83.38 250.41,83.82 250.41,84.18 249.99,84.6 ; JDIMM2.87 253.93,45.17 254.28,44.81 254.46,44.81 254.65,44.63 254.65,44.41 254.38,44.15 254.38,42.95 253.89,42.46 253.89,42.24 254.06,42.07 254.3,42.07 v2(254.85,42.62)
  IN2 w0.114: v2(250.86,82.82) 251.03,82.99 251.47,82.99 253.09,81.38 253.09,80.34 262.18,71.24 262.18,66.39 262.04,66.25 261.71,66.25 261.57,66.11 261.57,65.84 261.71,65.7 262.07,65.7 262.21,65.56 262.21,65.29 262.07,65.15 261.66,65.15 261.52,65.01 261.52,64.75 261.66,64.61 262.04,64.61 262.21,64.44 262.21,64.18 262.09,64.06 261.66,64.06 261.52,63.92 261.52,63.66 261.66,63.52 262.04,63.52 262.18,63.38 262.18,63.11 262.04,62.97 261.71,62.97 261.57,62.83 261.57,59.41 261.21,59.05 261.21,45.86 260.23,44.87 257.02,44.87 254.85,42.7 v2(254.85,42.62)
  BOTTOM w0.152: JDIMM1.87 253.93,38.52 255.23,39.83 255.23,42.24 v2(254.85,42.62)
DDR_A_CB1: length 69.4
  TOP w0.076: UC1.BA1 248.38,87.25 249.74,85.88 249.74,84.47 249.82,84.4
  TOP w0.152: v2(254.82,41.35) 255.42,40.75 255.42,40.23 254.97,39.78 254.31,39.78 253.68,39.15 JDIMM2.88 ; 249.82,84.4 250.12,84.1 250.12,83.53 v2(250.42,83.22)
  IN2 w0.114: v2(254.82,41.35) 255.62,42.16 255.62,42.95 257.18,44.51 260.4,44.51 261.58,45.68 261.58,58.49 262.6,59.5 262.6,60.22 262.46,60.36 262.25,60.36 262.11,60.5 262.11,60.76 262.25,60.9 262.46,60.9 262.6,61.04 262.6,61.31 262.46,61.45 262.25,61.45 262.11,61.59 262.11,61.86 262.25,61.99 262.46,61.99 262.6,62.13 262.6,71.41 253.56,80.44 253.56,81.42 251.77,83.22 v2(250.42,83.22)
  BOTTOM w0.14: v2(254.82,41.35) 254.41,41.76 254.41,43.53 253.82,44.12
  BOTTOM w0.152: 253.82,44.12 253.68,44.27 JDIMM1.88
DDR_A_CB2: length 73.4
  TOP w0.076: UC1.AY4 247.52,89.54 v2(247.2,89.21)
  TOP w0.152: JDIMM2.105 249.43,45 249.58,44.84 250.21,44.84 250.37,44.69 250.37,44.48 250.27,44.38 249.68,44.38 249.53,44.23 249.53,43.71 249.65,43.59 249.82,43.59 250.1,43.87 250.32,43.87 250.48,43.72 250.48,43.5 250.24,43.26 250.24,43 250.42,42.82 250.63,42.82 v2(251.12,43.31)
  IN2 w0.114: v2(247.2,89.21) 248.67,87.74 248.67,83.6 248.2,83.13 248.2,80.95 258.18,70.97 258.18,70.78 257.99,70.59 257.79,70.59 256.73,71.65 256.53,71.65 256.34,71.46 256.34,71.26 258.2,69.4 258.2,58.52 257.62,57.94 257.62,51.84 254.64,48.86 252.61,48.86 251.82,48.07 251.82,47.38 250.65,46.21 250.65,43.78 v2(251.12,43.31)
  BOTTOM w0.152: v2(251.12,43.31) 251.55,42.88 251.55,41.43 250.97,40.86 250.97,39.76 250.15,38.93 249.98,38.93 249.43,38.37 JDIMM1.105
DDR_A_CB3: length 74.3
  TOP w0.076: UC1.AY5 247.52,90.19 v2(247.2,89.86)
  TOP w0.152: v2(252.82,39.88) 251.68,41.03 251.68,43.93 250.43,45.18 JDIMM2.101
  IN2 w0.076: v2(247.2,89.86) 248.99,88.07 248.99,84.29 249.03,84.24 249.03,83.76
  IN2 w0.114: 249.03,83.76 249.03,83.53 248.56,83.05 248.56,81.5 258.57,71.49 258.57,58.37 257.99,57.79 257.99,53.13 258.13,52.99 258.43,52.99 258.57,52.85 258.57,52.59 258.43,52.45 258.13,52.45 257.99,52.31 257.99,51.64 252.27,45.91 252.04,45.91 251.55,45.42 251.55,40.81 252.48,39.88 v2(252.82,39.88)
  BOTTOM w0.152: JDIMM1.101 250.43,38.77 250.66,39.01 250.89,39.01 251.11,38.79 251.41,38.79 251.63,39.01 251.63,39.23 251.39,39.48 251.39,39.73 251.84,40.19 251.84,41.06 252.03,41.25 252.26,41.25 252.43,41.08 252.43,40.27 v2(252.82,39.88)
DDR_A_CB4: length 73.6
  TOP w0.076: UC1.BA5 248.9,89.67 248.9,88.05 248.99,87.96 248.99,87.46 250.27,86.17 250.27,84.89 250.97,84.2
  TOP w0.152: v2(252.84,43.17) 253.27,42.73 253.27,39.46 252.68,38.87 JDIMM2.92 ; v2(252.14,81.59) 252.14,83.03 250.97,84.2
  IN2 w0.114: v2(252.14,81.59) 252.14,80.59 261.7,71.03 261.7,70.3 261.56,70.16 261.29,70.16 261.15,70.03 261.15,69.76 261.29,69.62 261.6,69.62 261.74,69.48 261.74,69.21 261.6,69.07 261.29,69.07 261.15,68.93 261.15,68.67 261.29,68.53 261.6,68.53 261.74,68.39 261.74,68.12 261.6,67.98 261.29,67.98 261.15,67.84 261.15,67.57 261.29,67.43 261.6,67.43 261.74,67.29 261.74,66.82 261,66.07 260.77,66.07 260.62,65.92 260.62,65.71 260.77,65.55 261,65.55 261.15,65.4 261.15,59.51 260.84,59.2 260.84,50.64 260.1,49.89 260.1,46.3 259.24,45.44 255.64,45.44 253.37,43.17 v2(252.84,43.17)
  BOTTOM w0.152: JDIMM1.92 252.68,45.07 252.9,44.84 253.14,44.84 253.32,44.67 253.32,44.45 253.19,44.33 252.44,44.33 252.09,44.67 251.81,44.67 251.56,44.42 251.56,44.18 252.06,43.67 252.33,43.67 v2(252.84,43.17)
DDR_A_CB5: length 74.1
  TOP w0.076: UC1.BA4 248.67,89.24 248.67,88 248.82,87.85 248.82,87.39 250.1,86.11 250.1,84.83 250.69,84.24 250.69,84.03
  TOP w0.152: v2(252.81,43.91) 253.25,43.47 253.25,43.32 253.71,42.86 253.92,42.86 254.08,43.01 254.08,43.23 253.51,43.8 253.51,44.01 253.67,44.17 253.92,44.17 254.1,44.35 254.1,44.56 253.94,44.72 253.36,44.72 253.13,44.49 252.9,44.49 252.73,44.67 252.73,44.89 252.93,45.09 JDIMM2.91 ; v2(251.71,82.01) 251.71,83 250.69,84.03
  IN2 w0.114: v2(251.71,82.01) 251.71,80.43 260.23,71.91 260.23,70.67 260.37,70.53 260.63,70.53 260.77,70.39 260.77,70.12 260.63,69.99 260.37,69.99 260.23,69.85 260.23,69.58 260.37,69.44 260.63,69.44 260.77,69.3 260.77,69.03 260.63,68.89 260.37,68.89 260.23,68.75 260.23,68.49 260.37,68.35 260.63,68.35 260.77,68.21 260.77,67.94 260.63,67.8 260.37,67.8 260.23,67.66 260.23,67.39 260.37,67.25 260.86,67.25 261,67.11 261,66.85 260.86,66.71 260.37,66.71 260.23,66.57 260.23,59.45 260.47,59.2 260.47,50.87 259.71,50.11 259.71,46.59 258.92,45.81 254.73,45.81 254.01,45.09 254.01,44.41 253.51,43.91 v2(252.81,43.91)
  BOTTOM w0.152: v2(252.81,43.91) 253.8,42.92 253.8,39.56 252.93,38.68 JDIMM1.91
DDR_A_CB6: length 71.8
  TOP w0.076: v2(247.2,87.26) 247.52,87.59 UC1.AY1
  TOP w0.152: v2(250.05,39.45) 250.46,39.86 250.46,40.46 250.61,40.61 250.77,40.61 250.9,40.48 250.9,39.63 250.25,38.98 249.81,38.98 249.57,39.22 249.05,39.22 248.92,39.09 248.92,38.9 249.06,38.76 249.5,38.76 249.68,38.58 JDIMM2.104
  IN2 w0.076: v2(247.2,87.26) 247.93,86.53 247.93,84.26
  IN2 w0.114: 247.93,84.26 247.93,83.84 247.45,83.36 247.45,80.66 253.83,74.27 253.83,72.73 257.47,69.1 257.47,58.83 256.88,58.25 256.88,53.86 255.46,52.44 253.26,52.44 249.92,49.1 249.92,42.54 250.49,41.96 250.49,39.78 250.17,39.45 v2(250.05,39.45)
  BOTTOM w0.152: JDIMM1.104 249.68,42.77 250.45,41.99 250.45,39.85 v2(250.05,39.45)
DDR_A_CB7: length 69.2
  TOP w0.076: UC1.AY2 247.52,88.24 v2(247.2,87.91)
  TOP w0.152: JDIMM2.100 250.68,38.55 251.14,39.01 v2(251.14,41.84)
  IN2 w0.076: v2(247.2,87.91) 248.3,86.81 248.3,86.48
  IN2 w0.114: v2(251.14,41.84) 250.28,42.69 250.28,48.95 253.41,52.07 256.21,52.07 257.25,53.11 257.25,58.1 257.83,58.68 257.83,69.25 254.43,72.65 254.43,72.85 254.62,73.04 254.82,73.04 255.89,71.96 256.09,71.96 256.28,72.15 256.28,72.35 247.82,80.81 247.82,83.25 248.3,83.73 248.3,86.48
  BOTTOM w0.152: JDIMM1.100 250.68,42.17 251,41.84 v2(251.14,41.84)
DDR_A_CKE0: length 66.3
  TOP w0.076: v2(244.68,87.26) 245.01,87.59 UC1.AT1
  TOP w0.168: v2(250.05,40.63) 250.52,41.11 250.52,42.11 250.03,42.6 249.51,42.6 248.59,43.51 248.59,44.67 248.43,44.83 JDIMM2.109
  IN4 w0.076: 251.98,79.8 251.47,80.32 251.47,81.05 248.17,84.35 248.17,84.6 245.51,87.26 v2(244.68,87.26)
  IN4 w0.152: 251.98,79.8 252.44,79.35 252.44,76.85 254.26,75.02 254.26,65.6 253.78,65.12 253.78,62.55 253.45,62.22 253.45,60.26 252.05,58.86 252.05,51.8 251.2,50.94 251.2,48.5 251.54,48.16 251.54,41.67 251.23,41.37 251.23,38.89 250.34,38 250.1,38 249.89,38.21 249.89,38.5 250.58,39.19 250.58,40.1 v2(250.05,40.63)
DDR_A_CKE1: length 64.3
  TOP w0.076: v2(244.68,87.91) 245.01,88.24 UC1.AT2
  TOP w0.168: v2(249.16,35.22) 248.18,36.2 JDIMM2.110
  IN4 w0.076: 252.28,80.16 251.77,80.68 251.77,81.05 248.43,84.39 248.43,84.65 245.17,87.91 v2(244.68,87.91)
  IN4 w0.152: v2(249.16,35.22) 249.81,35.87 249.81,36.45 249.95,36.59 249.95,36.81 249.81,36.95 249.59,36.95 249.46,37.08 249.46,37.38 249.62,37.54 250.86,37.54 251.93,38.61 251.93,50.96 252.41,51.44 252.41,58.57 254.87,61.03 254.87,64.5 254.72,64.65 254.72,75.21 252.89,77.04 252.89,79.55 252.28,80.16
DDR_A_CKE2: length 67.7
  TOP w0.168: UC1.AT3 v2(244.68,88.56)
  IN4 w0.076: v2(244.68,88.56) 244.81,88.56 248.68,84.69 248.68,84.46 252.66,80.48
  IN4 w0.152: 252.66,80.48 253.35,79.79 253.35,77.23 255.18,75.4 255.18,64.84 255.32,64.69 255.32,60.84 253.33,58.84 253.33,55.09 252.96,54.72 252.96,49.13 252.39,48.56 252.39,38.32 252,37.94 252,37.72 252.18,37.54 252.18,37.33 252,37.15 251.78,37.15 251.61,37.32 251.39,37.32 251.21,37.14 251.21,36.93 251.39,36.75 251.39,36.54 251.21,36.36 250.99,36.36 250.82,36.53 250.6,36.53 250.27,36.2 250.27,35.1 v2(249.2,34.03)
  BOTTOM w0.165: JDIMM1.109 248.43,34.69 249.08,34.03 v2(249.2,34.03)
DDR_A_CKE3: length 65.9
  TOP w0.076: v2(250.77,80.9) 248.51,80.9 244.93,84.48 244.93,86.94 245.41,87.42 245.41,89.95 245.17,90.19 UC1.AT5
  IN4 w0.152: v2(250.01,41.84) 250.69,42.52 250.69,44.13 251.12,44.56 251.12,44.81 250.97,44.96 250.78,44.96 250.63,45.11 250.63,45.34 250.78,45.49 250.97,45.49 251.12,45.65 251.12,45.87 250.97,46.03 250.78,46.03 250.63,46.18 250.63,46.41 250.78,46.56 250.97,46.56 251.08,46.67 251.08,46.84 250.67,47.25 250.67,51.76 250.83,51.92 251.28,51.92 251.42,52.06 251.42,52.27 251.26,52.42 250.95,52.42 250.8,52.58 250.8,52.81 250.95,52.96 251.55,52.96 251.7,53.11 251.7,57.81 251.55,57.96 251.27,57.96 251.11,58.12 251.11,58.34 251.27,58.5 251.55,58.5 251.7,58.65 251.7,59.2 252.47,59.97 252.47,60.16 252.32,60.31 252.32,60.57 252.45,60.7 252.82,60.7 252.98,60.86 252.98,62.43 253.32,62.78 253.32,62.98 253.18,63.12 252.63,63.12 252.48,63.27 252.48,63.5 252.63,63.65 252.82,63.65 252.98,63.81 252.98,64.31 252.71,64.57 252.71,64.83 253.81,65.92 253.81,74.83 251.98,76.66 251.98,78.73 250.95,79.76 250.95,80.73 v2(250.77,80.9)
  BOTTOM w0.168: JDIMM1.110 248.18,45.04 248.63,44.59 248.63,42.62 249.41,41.84 v2(250.01,41.84)
DDR_A_CLK0: length 70.7
  TOP w0.076: UC1.AG1 237.69,87.7 237.69,87.88 237.63,87.95 237.35,87.95 237.23,87.82 237.23,87.26 237.34,87.15
  TOP w0.109: v2(240.96,43.13) 240.78,43.13 240.7,43.05 240.7,42.81 240.63,42.74 240.44,42.74 240.33,42.84 240.33,43.33 241.17,44.16 241.17,44.7 241.43,44.96 JDIMM2.137 ; 237.34,87.15 237.34,83.18 240.1,80.42 241.65,80.42 241.77,80.55 241.77,80.64 v2(241.72,80.69)
  IN4 w0.102: v2(241.72,80.69) 241.52,80.48 241.22,80.48 240.93,80.2 240.93,78.68 240.55,78.29 240.55,73.99 238.07,71.52 238.07,70.31 237.9,70.14 237.33,70.14 237.05,69.86 237.05,69.36 237.32,69.1 237.99,69.1 238.09,68.99 238.09,68.72 237.99,68.61 237.68,68.61 237.46,68.39 237.46,67.98 237.72,67.72 237.99,67.72 238.09,67.62 238.09,67.14 237.85,66.9 237.6,66.9 237.02,67.47 237.02,68.34 236.82,68.55 236.43,68.55 236.2,68.31 236.2,67.03 237.1,66.13 237.1,65.82 236.83,65.55 236.83,65.09 237.07,64.85 237.07,64.55 236.83,64.31 236.83,63.96 237.1,63.69 237.1,63.33 237.02,63.26 236.43,63.26 236.21,63.03 236.21,62.63 236.41,62.42 237,62.42 237.1,62.33 237.1,62.07 237.01,61.99 236.69,61.99 236.49,61.79 236.49,61.13 236.98,60.64 237.3,60.64 237.47,60.47 237.47,60.33 237.16,60.03 237.16,59.76 237.56,59.36 237.56,59.05 237.5,58.98 237.37,58.98 237.19,59.16 236.84,59.16 236.63,58.95 236.63,58.4 237.2,57.83 237.2,56.61 237.42,56.4 237.42,56.24 237.2,56.02 237.2,55.71 237.6,55.31 237.6,53.72 237.18,53.3 237.18,53 240.14,50.04 240.14,49.91 239.96,49.72 239.96,49.4 240.14,49.22 240.14,48.41 240.79,47.76 240.79,46.95 240.7,46.86 240.53,46.86 240.27,46.61 240.27,46.07 240.47,45.88 240.95,45.88 241.04,45.79 241.04,43.75 241.38,43.4 241.38,42.99 241.3,42.92 241.17,42.92 v2(240.96,43.13)
DDR_A_CLK1: length 68.9
  TOP w0.076: 239.55,87.28 239.59,87.32 239.59,87.91 239.78,88.1 239.96,88.1 UC1.AK2
  TOP w0.109: 239.55,87.28 239.55,83.06 240.64,81.96 v2(241.72,81.96) ; JDIMM2.138 241.18,38.44 240.92,38.7 240.92,38.95 240.65,39.22 239.56,39.22 238.93,39.85 238.93,40.52 239.11,40.7 239.36,40.7 239.45,40.61 239.45,40.38 239.53,40.3 v2(239.72,40.3)
  IN4 w0.102: v2(239.72,40.3) 239.89,40.47 240.01,40.47 240.39,40.09 240.71,40.09 241.33,40.71 241.33,41.13 241.05,41.4 240.78,41.4 240.6,41.22 240.45,41.22 240.35,41.31 240.35,43.52 240.55,43.72 240.55,45.25 240.34,45.47 240.06,45.47 239.73,45.79 239.73,46.68 240.19,47.13 240.19,47.6 239.62,48.18 239.62,48.98 239.16,49.44 239.16,50.27 236.27,53.15 236.27,53.26 236.58,53.57 236.58,57.58 235.96,58.19 235.96,58.35 236.12,58.51 236.12,58.88 235.9,59.1 235.39,59.1 235.31,59.17 235.31,59.46 235.43,59.58 236.42,59.58 236.64,59.8 236.64,60.25 236.42,60.47 235.42,60.47 235.33,60.56 235.33,60.81 235.47,60.95 235.75,60.95 235.97,61.17 235.97,61.88 235.66,62.19 235.66,63.21 236.3,63.85 236.3,64.5 235.95,64.85 235.95,66.09 235.66,66.37 235.66,68.66 236.54,69.53 236.54,70.69 236.64,70.8 236.78,70.8 236.93,70.65 237.25,70.65 237.56,70.96 237.56,71.28 237.41,71.43 237.41,71.58 240.03,74.19 240.03,78.49 240.44,78.9 240.44,80.57 240.97,81.11 240.97,82.11 241.12,82.26 241.53,82.26 241.72,82.07 v2(241.72,81.96)
DDR_A_CLK2: length 69
  TOP w0.076: UC1.AL3 240.83,88.76 240.91,88.69 241.08,88.69 241.41,88.36 241.41,87.38 241.27,87.25 241.27,86.31 241.5,86.08 241.93,86.08 241.98,86.13 241.98,86.2 v2(241.73,86.46)
  IN4 w0.102: v2(240.72,35.43) 241.28,36 241.28,37.14 241.06,37.36 239.14,37.36 239.04,37.46 239.04,37.74 239.14,37.84 241.03,37.84 241.25,38.06 241.25,38.51 241.03,38.73 240.15,38.73 240.04,38.83 240.04,39.11 240.15,39.21 240.88,39.21 241.93,40.26 241.93,42.26 242.14,42.48 242.14,43.91 241.92,44.12 241.92,46.38 241.65,46.65 241.65,49.19 241.34,49.5 241.34,50.46 238.61,53.19 238.61,56.84 238.82,57.05 238.82,58.19 238.51,58.51 238.51,60.74 238.14,61.11 238.14,65.89 239.02,66.76 239.02,71.03 241.47,73.47 241.47,77.89 241.84,78.26 241.84,78.73 242.5,79.39 242.5,85.98 242.19,86.29 241.9,86.29 v2(241.73,86.46)
  BOTTOM w0.109: v2(240.72,35.43) 241.02,35.73 241.29,35.73 241.55,35.99 241.55,36.49 241.3,36.75 241.3,36.89 241.43,37.02 JDIMM1.137
DDR_A_CLK3: length 67.5
  TOP w0.076: 240.3,86.9 240.3,86.91 240.31,86.92 240.32,86.92 240.39,86.98 240.39,87.79 UC1.AL2
  TOP w0.109: 240.3,86.9 240.3,84.85 241.16,83.99 241.6,83.99 v2(241.72,83.87)
  IN4 w0.102: v2(241.72,83.87) 241.72,83.79 241.62,83.68 241.48,83.68 241.35,83.81 241.35,84.24 241.3,84.3 240.62,84.3 240.21,83.89 240.21,81.45 239.75,80.99 239.75,79.08 239.31,78.64 239.31,74.49 235.82,71 235.82,69.88 234.88,68.94 234.88,66.08 235.21,65.75 235.21,65.23 234.96,64.99 234.21,64.99 234.11,64.89 234.11,64.61 234.21,64.51 235.02,64.51 235.31,64.22 235.31,63.88 235.05,63.62 234.21,63.62 234.11,63.51 234.11,63.24 234.21,63.13 234.71,63.13 234.94,62.9 234.94,62.56 234.39,62.01 234.39,61.88 234.73,61.54 234.73,61.21 234.45,60.93 234.25,60.93 234.11,60.79 234.11,60.59 234.25,60.45 234.44,60.45 234.66,60.23 234.66,59.78 234.44,59.56 234.25,59.56 234.15,59.46 234.15,59.22 234.27,59.1 234.43,59.1 234.62,58.9 234.62,58.68 234.97,58.33 234.97,57.8 235.4,57.36 235.4,53 238.44,49.96 238.44,49.61 238.19,49.37 237.62,49.37 237.52,49.26 237.52,48.99 237.61,48.89 238.26,48.89 238.56,48.59 238.56,48.25 238.35,48.04 238,48.04 237.92,47.96 237.92,47.7 238.05,47.57 238.81,47.57 239.02,47.36 239.02,45.49 239.83,44.69 239.83,44.34 239.22,43.73 239.22,42.84 239.3,42.75 239.5,42.75 v2(239.72,42.97)
  BOTTOM w0.109: JDIMM1.138 241.18,45.13 240.2,44.15 239.66,44.15 238.98,43.47 238.98,42.75 239.17,42.56 239.3,42.56 239.4,42.65 239.4,42.89 239.48,42.97 v2(239.72,42.97)
DDR_A_CLK#0: length 70.7
  TOP w0.076: 237.1,87.15 237.1,87.18 237.07,87.2 237.07,87.89 237.29,88.1 237.45,88.1 UC1.AG2
  TOP w0.109: 237.1,87.15 237.1,83.08 240,80.18 241.6,80.18 v2(241.72,80.06) ; v2(240.96,42.5) 240.34,42.5 240.09,42.74 240.09,43.43 240.93,44.26 JDIMM2.139
  IN4 w0.102: v2(240.96,42.5) 241.17,42.71 241.39,42.71 241.58,42.91 241.58,43.49 241.24,43.83 241.24,45.88 241.03,46.08 240.55,46.08 240.48,46.16 240.48,46.52 240.61,46.66 240.79,46.66 240.99,46.86 240.99,47.85 240.35,48.49 240.35,49.3 240.17,49.48 240.17,49.64 240.35,49.82 240.35,50.12 237.39,53.08 237.39,53.22 237.8,53.64 237.8,55.4 237.4,55.8 237.4,55.94 237.62,56.15 237.62,56.48 237.4,56.7 237.4,57.91 236.83,58.49 236.83,58.87 236.92,58.96 237.1,58.96 237.28,58.78 237.58,58.78 237.76,58.96 237.76,59.44 237.37,59.84 237.37,59.94 237.67,60.24 237.67,60.55 237.38,60.84 237.07,60.84 236.69,61.21 236.69,61.7 236.78,61.79 237.1,61.79 237.3,61.99 237.3,62.41 237.09,62.63 236.5,62.63 236.41,62.71 236.41,62.95 236.52,63.05 237.1,63.05 237.3,63.25 237.3,63.77 237.03,64.04 237.03,64.23 237.27,64.47 237.27,64.94 237.03,65.18 237.03,65.46 237.3,65.73 237.3,66.22 236.4,67.12 236.4,68.23 236.52,68.34 236.73,68.34 236.82,68.26 236.82,67.39 237.51,66.69 237.94,66.69 238.3,67.06 238.3,67.71 238.08,67.93 237.8,67.93 237.66,68.07 237.66,68.31 237.76,68.41 238.08,68.41 238.3,68.63 238.3,69.08 238.08,69.3 237.4,69.3 237.25,69.45 237.25,69.78 237.41,69.94 237.99,69.94 238.27,70.22 238.27,71.43 240.75,73.91 240.75,78.2 241.14,78.59 241.14,80.12 241.3,80.28 241.57,80.28 241.72,80.13 v2(241.72,80.06)
DDR_A_CLK#1: length 69
  TOP w0.076: UC1.AK1 240.15,87.64 240.15,87.86 240.06,87.95 239.84,87.95 239.74,87.85 239.74,87.34 239.79,87.29 239.79,87.28
  TOP w0.109: v2(239.72,40.94) 239.01,40.94 238.69,40.62 238.69,39.75 239.46,38.98 240.55,38.98 240.68,38.85 JDIMM2.140 ; v2(241.72,82.6) 241.69,82.63 241.49,82.63 241.43,82.57 241.43,82.28 241.36,82.2 240.75,82.2 239.79,83.16 239.79,87.28
  IN4 w0.102: v2(241.72,82.6) 241.59,82.47 241.04,82.47 240.77,82.19 240.77,81.19 240.24,80.66 240.24,78.99 239.82,78.57 239.82,74.28 237.21,71.66 237.21,71.34 237.36,71.19 237.36,71.05 237.16,70.85 237.02,70.85 236.87,71 236.56,71 236.33,70.78 236.33,69.62 235.46,68.74 235.46,66.29 235.74,66 235.74,64.77 236.1,64.41 236.1,63.93 235.46,63.29 235.46,62.1 235.77,61.8 235.77,61.25 235.67,61.15 235.39,61.15 235.13,60.9 235.13,60.47 235.34,60.27 236.34,60.27 236.44,60.16 236.44,59.88 236.34,59.78 235.35,59.78 235.11,59.54 235.11,59.09 235.3,58.89 235.82,58.89 235.91,58.8 235.91,58.59 235.76,58.44 235.76,58.11 236.37,57.49 236.37,53.65 236.07,53.35 236.07,53.07 238.96,50.18 238.96,49.35 239.41,48.9 239.41,48.09 239.99,47.52 239.99,47.22 239.53,46.76 239.53,45.7 239.97,45.26 240.26,45.26 240.35,45.17 240.35,43.81 240.15,43.6 240.15,41.23 240.36,41.01 240.68,41.01 240.87,41.2 240.97,41.2 241.12,41.04 241.12,40.79 240.62,40.29 240.48,40.29 240.09,40.68 239.86,40.68 239.72,40.81 v2(239.72,40.94)
DDR_A_CLK#2: length 69
  TOP w0.076: UC1.AK3 240.8,88.58 240.84,88.53 241.02,88.53 241.15,88.4 241.25,88.3 241.25,87.45 241.12,87.31 241.12,86.25 241.44,85.93 241.52,85.93 v2(241.72,85.73)
  IN4 w0.102: v2(241.72,85.73) 241.64,85.8 241.64,85.98 241.75,86.08 242.11,86.08 242.29,85.9 242.29,79.48 241.63,78.82 241.63,78.35 241.26,77.98 241.26,73.56 238.82,71.11 238.82,66.85 237.94,65.97 237.94,61.02 238.3,60.66 238.3,58.42 238.62,58.11 238.62,57.13 238.41,56.92 238.41,53.11 241.14,50.38 241.14,49.42 241.45,49.11 241.45,46.57 241.72,46.29 241.72,44.04 241.94,43.82 241.94,42.56 241.73,42.35 241.73,40.35 240.79,39.41 240.06,39.41 239.84,39.19 239.84,38.75 240.06,38.53 240.95,38.53 241.05,38.42 241.05,38.14 240.95,38.04 239.06,38.04 238.84,37.82 238.84,37.37 239.06,37.15 240.98,37.15 241.08,37.05 241.08,36.08 240.91,35.91 240.57,35.91 240.5,35.97 240.5,36.1 v2(240.72,36.31)
  BOTTOM w0.109: v2(240.72,36.31) 240.72,36.08 240.82,35.97 241.19,35.97 241.31,36.09 241.31,36.39 241.05,36.65 241.05,36.86 240.93,36.99 JDIMM1.139
DDR_A_CLK#3: length 67.6
  TOP w0.076: 240.54,86.9 240.54,87.73 240.77,87.96 240.94,87.96 241.01,87.89 241.01,87.76 UC1.AL1
  TOP w0.109: v2(241.72,84.5) 241.72,84.39 241.57,84.23 241.26,84.23 240.54,84.95 240.54,86.9
  IN4 w0.102: v2(241.72,84.5) 240.54,84.5 240.01,83.97 240.01,81.53 239.55,81.08 239.55,79.16 239.11,78.72 239.11,74.57 235.61,71.08 235.61,69.96 234.68,69.03 234.68,65.99 235.01,65.67 235.01,65.32 234.88,65.19 234.13,65.19 233.91,64.97 233.91,64.52 234.13,64.3 234.94,64.3 235.11,64.13 235.11,63.96 234.97,63.82 234.13,63.82 233.91,63.6 233.91,63.15 234.13,62.93 234.62,62.93 234.74,62.81 234.74,62.64 234.19,62.09 234.19,61.79 234.52,61.46 234.52,61.29 234.37,61.14 234.17,61.14 233.91,60.88 233.91,60.51 234.17,60.25 234.36,60.25 234.46,60.15 234.46,59.87 234.36,59.77 234.17,59.77 233.94,59.55 233.94,59.13 234.19,58.89 234.34,58.89 234.42,58.82 234.42,58.59 234.76,58.24 234.76,57.72 235.2,57.28 235.2,52.91 238.24,49.88 238.24,49.7 238.11,49.57 237.54,49.57 237.31,49.35 237.31,48.9 237.53,48.68 238.17,48.68 238.35,48.5 238.35,48.33 238.27,48.25 237.92,48.25 237.71,48.04 237.71,47.62 237.97,47.36 238.73,47.36 238.82,47.27 238.82,45.41 239.63,44.6 239.63,44.43 239.01,43.82 239.01,42.76 239.22,42.55 239.56,42.55 239.72,42.39 v2(239.72,42.31)
  BOTTOM w0.109: v2(239.72,42.31) 239.07,42.31 238.74,42.65 238.74,43.57 239.56,44.39 240.1,44.39 240.68,44.97 JDIMM1.140
DDR_A_CS#0: length 66.2
  TOP w0.076: v2(234.62,89.86) 234.95,90.19 UC1.AD5
  TOP w0.168: v2(235.72,42.75) 236.06,42.75 236.43,43.11 JDIMM2.149
  IN2 w0.127: v2(234.62,89.86) 235.13,89.86 237.19,87.8 237.19,67.83 237.03,67.67 236.79,67.67 236.63,67.83 236.63,72.21 236.47,72.37 236.24,72.37 236.07,72.21 236.07,67.44 237.19,66.32 237.19,62.4 239.25,60.34 239.25,57.22 239.9,56.57 239.9,46.92 235.73,42.75 v2(235.72,42.75)
DDR_A_CS#1: length 68
  TOP w0.076: UC1.AE2 235.81,88 236.08,87.72 236.08,87.44 235.97,87.33 235.97,86.36 236.1,86.23 236.1,85.48 v2(236.66,84.92)
  TOP w0.168: JDIMM2.157 234.43,44.95 234.08,44.61 233.55,44.61 232.03,43.09 v2(231.75,43.09)
  IN2 w0.127: v2(231.75,43.09) 236.33,47.68 236.33,48.16 237.55,49.38 237.55,55.41 236.62,56.34 236.62,58.8 234.23,61.19 234.23,68.29 233.13,69.39 233.13,80.53 233.3,80.7 233.53,80.7 233.69,80.53 233.69,76.26 233.86,76.1 234.09,76.1 234.25,76.26 234.25,80.88 234.59,81.22 234.59,81.44 234.25,81.78 234.25,81.99 234.43,82.17 234.65,82.17 234.99,81.83 235.21,81.83 235.38,82.01 235.38,82.23 235.04,82.57 235.04,82.78 235.22,82.96 235.44,82.96 235.78,82.62 236,82.62 236.17,82.79 236.17,83.03 235.67,83.53 235.67,83.92 v2(236.66,84.92)
