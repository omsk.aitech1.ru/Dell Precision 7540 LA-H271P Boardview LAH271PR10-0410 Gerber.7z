# Allegro board LAH271PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+19.5V_DC_IN_SS: length 284.8
  TOP w0.109: JIO1.68 v2(48.55,2.79)
  TOP w0.254: v2(265.91,19.83) 262.49,19.83 253.18,10.52 250.94,10.52 246.83,14.62 244.22,14.62 v2(243.31,15.53) ; PD700.3 281.91,38.04 v2(282.13,37.82)
  IN1 w0.254: v2(282.13,37.82) 282.13,37.34 280.44,35.65 280.44,34.72 277.43,31.71 277.43,25.47 273.96,21.99 267.62,21.99 265.91,20.28 v2(265.91,19.83)
  IN3 w0.254: v2(243.31,15.53) 242.71,16.13 232.3,16.13 228.72,12.55 212.82,12.55 209.15,8.88 209.15,5.89 208.39,5.14 207.12,5.14 206.53,4.54 184.22,4.54 183.52,3.84 180.19,3.84 178.67,5.36 178.26,5.36 176.29,7.33 173.32,7.33 171.9,8.75 165.7,8.75 164.54,7.58 160.52,7.58 157.75,10.36 156.37,10.36 155.78,9.76 145.23,9.76 v2(145.12,9.87)
  IN4 w0.254: v2(48.55,2.79) 49.98,1.36 66.51,1.36 67.47,2.32 67.47,4.14 70.42,7.09 73.61,7.09 75.2,5.5 v2(75.2,1.5)
  BOTTOM w0.109: v3(47.12,3.62) 47.72,3.62 v2(48.55,2.79)
  BOTTOM w0.254: v2(145.12,9.87) 144.96,9.71 142.5,9.71 142.05,9.26 142.05,7.85 141.54,7.34 140.64,7.34 138.98,5.68 138.98,3.21 137.12,1.35 120.59,1.35 120.13,1.8 120.13,3.01 118.72,4.43 112.86,4.43 110.36,1.93 100.85,1.93 100.36,2.43 92.76,2.43 91.72,1.39 75.31,1.39 v2(75.2,1.5)
+19.5V_SDC_IN: length 296.3
  TOP w0.254: v2(48.04,15.74) 48.04,15.75 48.04,16.29 48.71,16.96 48.71,17.91 49.31,18.52 PQ20.3 50.23,18.18 52.41,18.18 PR29.1 ; PR26.1 52.63,17.57 PR29.1 ; PR707.1 v2(288.67,35.83) ; PR29.1 PC12.1 ; PR706.2 v2(285.83,36.69) ; v2(265.39,27.03) 251.26,12.9 v2(250.34,12.9)
  IN1 w0.254: v2(48.04,15.74) 48.05,15.74 48.47,15.32 50.48,15.32 50.88,14.91 51.74,14.91 52.33,14.32 52.48,14.32 54.71,12.09 59.34,12.09 61.72,14.47 65.86,14.47 66.31,14.91 69.92,14.91 72.02,12.81 73.47,12.81 73.82,12.46 75.88,12.46 77.87,10.47 79.18,10.47 79.84,11.13 79.84,11.88 80.7,12.73 83.74,12.73 84.39,12.08 92.34,12.08 93.37,11.05 107.71,11.05 110.67,8.1 114.45,8.1 115.22,7.33 116.65,7.33 117.5,6.49 119.45,6.49 119.89,6.93 119.89,7.38 120.34,7.83 120.34,8.5 120.75,8.92 122.45,8.92 123.2,9.67 126.34,9.67 127.12,8.9 128.3,8.9 129.02,8.18 133.95,8.18 135.05,9.29 137.99,9.29 138.5,9.79 139.29,9.79 141.11,11.61 142.55,11.61 143.19,12.25 149.33,12.25 150.62,13.54 151.97,13.54 152.43,14.01 154.04,14.01 154.95,13.09 156.3,13.09 156.74,12.66 158.65,12.66 158.87,12.43 159.32,12.43 162.02,9.74 166.23,9.74 166.39,9.58 170.55,9.58 173,7.13 176.42,7.13 177.63,5.92 178.56,5.92 179.26,5.22 187.16,5.22 190.21,8.27 195.33,8.27 195.83,7.77 198.91,7.77 201.6,10.47 201.6,10.95 203.34,12.69 205,12.69 205.91,13.6 210.13,13.6 210.84,12.89 218.56,12.89 219.02,13.34 231.15,13.34 231.35,13.54 242.56,13.54 243.15,12.95 250.28,12.95 v2(250.34,12.9)
  IN2 w0.254: v2(285.83,36.69) 285.52,36.38 281.42,36.38 277.73,32.68 270.82,32.68 265.39,27.25 v2(265.39,27.03)
  BOTTOM w0.254: v2(288.67,35.83) 287.82,36.69 v2(285.83,36.69) ; 50.68,13.09 50.68,14.85 49.87,15.66 48.13,15.66 48.05,15.74 v2(48.04,15.74) 48.04,15.75 48.04,17.35 v3(48.08,17.38) 48.11,17.35 48.41,17.35 48.68,17.07 49.87,17.07 PR44.1 PC19.1 PR47.1 52.86,17.06 PQ25.3
  vias: v2(44.34,8.08) v2(44.59,7.55) v2(45.05,8.11) v2(45.3,7.57) v2(45.68,8.11) v2(46.06,7.57) v2(46.32,8.11) v2(46.7,7.57) v2(46.95,8.11) v2(47.36,7.62) v2(47.72,8.11) v2(48.1,7.6) v2(48.48,8.11) v2(48.86,7.62) v2(49.24,8.11) v2(49.62,7.6) v2(50,8.11) v2(50.38,7.62)
+19.5V_SDC_IN_CR: length 5.1
  BOTTOM w0.381: PR733.1 58.61,10.8 59.23,11.42 PQ705.3 58.55,12.56 57.83,11.84 PR731.1 57.76,10.98 v2(57.89,10.85)
  vias: v3(58.38,9.21)
+19.5VB: length 53.9
  TOP w0.381: PR109.2 114.51,11.47 v2(114.07,11.9) ; v2(194.11,3.03) 194.11,3.22 194.58,3.68 RZ85.1
  TOP w0.508: PR510.2 v2(313.28,44.13)
  IN2 w0.381: v2(62.96,11.54) 62.96,13.34 62.5,13.8 60.39,13.8 59.41,12.82 51.65,12.82 51.23,13.24 v2(51.23,13.56)
  IN4 w0.381: v2(114.07,11.9) 114.07,11.4 113.64,10.96 113.64,6.81 115.03,5.43 117.31,5.43 118.53,4.2 v2(118.53,3.25)
  IN4 w0.508: v2(42.01,7.85) 42.01,7.62 44.35,5.29 50.14,5.29 51.74,6.89 51.74,8.59 51.23,9.1 v2(51.23,13.56)
  BOTTOM w0.508: QT10.3 37.57,9.44 39.02,9.44 39.94,8.52 39.94,8.51 40.6,7.85 v2(42.01,7.85)
  vias: v2(62.05,10.98) v2(62.05,10.39) v2(62.05,9.81) v2(62.05,9.22) v2(62.64,10.98) v2(62.64,10.39) v2(62.64,9.81) v2(62.64,9.22) v2(63.22,10.98) v2(63.22,10.39) v2(63.22,9.81) v2(63.22,9.22) v2(63.81,10.98) v2(63.81,10.39) v2(63.81,9.81) v2(63.81,9.22) v2(64.33,10.69) v2(64.33,10.1) v2(64.33,9.52) v2(73.18,9.78) v2(73.81,10.42) v2(73.8,9.78) v2(74.16,10.96) v2(74.4,9.78) v2(74.42,10.39) v2(74.79,10.96) v2(75.07,10.38) v2(75.06,9.78) v2(75.34,54.82) v2(75.59,9.33) v2(75.92,54.82) v2(83.4,3.1) v2(83.69,2.6) v2(84.01,3.1) v2(84.37,2.57) v2(84.81,3.12) v2(85.11,2.61) v2(85.43,3.11) v2(85.79,2.59) v2(86.04,3.12) v2(86.4,2.6) v2(86.68,3.12) v2(86.78,37.57) v2(87.06,38.12) v2(87.07,2.58) v2(87.37,37.57) v2(87.45,3.11) v2(87.75,2.61) v2(88.06,3.11) v2(88.42,2.58) v2(88.67,3.11) v2(89.04,2.59) v2(89.31,3.11) v2(89.7,2.57) v2(93.17,25.33) v2(93.77,25.32) v2(94.36,25.33) v2(96.02,8.96) v2(96.57,9.21) v2(97.27,9.16) v2(116.96,2.33) v2(117.47,1.99) v2(117.98,2.37) v2(118.49,2.02) v2(118.54,2.62) v2(140.53,4.03) v2(140.5,3.41) v2(141.12,4.01) v2(141.13,3.41) v2(141.71,3.99) v2(141.72,3.39) v2(163.38,3.53) v2(163.37,2.79) v2(163.38,2.14) v2(173.81,2.37) v2(173.9,2.96) v2(174.4,2.37) v2(174.49,2.96) v2(181.05,6.23) v2(181.82,6.21) v2(182.62,6.19) v2(183.36,6.19) v2(184.16,6.18) v2(184.96,6.18) v2(185.8,6.19) v2(198.94,3.31) v2(199.54,3.32) v2(200.18,3.32) v2(200.78,3.32) v2(201.41,3.32) v2(202.02,3.32) v2(202.64,3.32) v2(203.27,3.32) v2(203.88,3.32) v2(204.51,3.32) v2(213.49,4.6) v2(213.75,5.15) v2(214.11,4.6) v2(214.35,5.15) v2(279.41,100.13) v2(280.02,138.32) v2(280.02,137.68) v2(280.02,137.05) v2(280.02,136.41) v2(280.02,135.78) v2(280.02,135.14) v2(280.03,100.12) v2(280.01,99.42) v2(280.63,138.32) v2(280.63,137.69) v2(280.63,137.05) v2(280.63,136.42) v2(280.63,135.78) v2(280.63,135.15) v2(280.68,100.1) v2(280.66,99.4) v2(311.65,18.56) v2(311.62,17.9) v2(311.62,17.24) v2(312.39,18.53) v2(312.39,17.93) v2(312.4,17.18) v2(313.16,18.64) v2(313.13,17.93) v2(313.2,17.21) v2(313.89,23.06) v2(313.87,17.98) v2(313.9,23.71) v2(314.57,23.02) v2(314.63,23.68) v2(314.71,32.48) v2(314.72,31.88) v2(315.32,32.47) v2(315.32,31.88) v2(315.31,23.68) v2(315.31,23.03) v2(315.91,32.49) v2(315.93,31.85) v2(316.53,32.48) v2(316.56,31.89) v2(317.2,32.48) v2(317.23,31.89) v3(276.34,121.25) v3(277.52,133.68) v3(277.55,129.24)
+19.5VB_CHARGER:
  vias: v2(304.76,19.16) v2(305.4,19.16) v3(303.94,22.75)
+19.5VB_CPU: length 4.4
  TOP w0.508: PR1150.1 261.33,138.46 v2(261.33,137.9)
  IN1 w0.381: v2(260.51,134.59) 260.51,137.08 v2(261.33,137.9)
  vias: v2(209.95,131.81) v2(210.58,131.8) v2(211.22,131.78) v2(211.86,131.78) v2(212.53,131.78) v2(221.44,136.57) v2(222.19,136.55) v2(222.81,137.18) v2(222.9,136.54) v2(223.53,137.16) v2(230.68,138.26) v2(230.68,137.62) v2(231.39,138.26) v2(231.39,137.62) v2(233.64,144.5) v2(233.64,143.74) v2(234.41,143.51) v2(235.17,143.51) v2(236.06,143.51) v2(236.82,143.51) v2(237.96,144) v2(238.72,143.62) v2(239.34,138.54) v2(239.34,137.91) v2(239.49,143.62) v2(239.49,139.12) v2(240.13,139.12) v2(240.25,143.62) v2(241.01,143.62) v2(241.77,143.62) v2(242.41,144) v2(246.93,138.01) v2(247.24,144.57) v2(247.22,143.9) v2(247.51,139.62) v2(247.86,144.61) v2(247.87,143.95) v2(247.9,143.31) v2(247.82,139.11) v2(248.54,143.32) v2(249.13,143.32) v2(249.76,143.33) v2(250.36,143.35) v2(250.98,143.36) v2(268.56,136.12) v2(268.56,135.49) v2(268.56,134.85) v2(268.56,134.22) v2(269.19,136.12) v2(269.19,135.49) v2(269.19,134.85) v2(269.19,134.22) v2(269.22,125.8) v2(269.63,122.87) v2(269.66,122.18) v2(269.66,121.35) v2(269.83,136.12) v2(269.83,135.49) v2(269.83,134.85) v2(269.83,134.22) v2(270.43,122.16) v2(270.47,121.34) v3(211.1,132.66)
+19.5VB_DGFF:
  vias: v3(95.35,16.62)
+19VB_1.2V: length 21.7
  TOP w0.109: PC203.1 219.57,10.83 v1(218.96,10.23)
  TOP w0.508: PR207.1 198.48,10.32 v2(198.13,9.97)
  BOTTOM w0.254: v2(213.45,7.26) 213.45,8.97 211.05,11.38 205.24,11.38 203.84,9.97 v2(198.13,9.97)
+19VB_1V: length 1.7
  TOP w0.109: 146.78,3.14 146.78,2.02 v3(147.18,1.62)
  vias: v2(142.94,4.92) v2(143.54,4.91)
+19VB_3V:
  vias: v3(114.18,4.72)
+19VB_3VR: length 1.9
  TOP w0.109: PC528.1 318.62,27.29 v1(319.76,28.44)
+19VB_5V: length 0.9
  TOP w0.109: v2(71.36,10.42) 71.55,10.42 v3(72.06,10.93)
  vias: v2(71.29,9.07) v2(71.34,9.78)
+19VB_5VR:
  vias: v3(316.78,35.98)
+19VB_IO: length 1.7
  BOTTOM w0.109: 279.82,97.97 v1(281.5,97.97)
+20V_TBTA_VBUS: length 119.5
  TOP w0.254: v2(45.24,23.58) 45.05,23.77 42.83,23.77 41.95,24.64 39.64,24.64 39.44,24.83 37.06,24.83 36.42,24.19 36.42,21.87 35.53,20.98 35.53,19.85 v2(35.32,19.63)
  TOP w0.305: v2(43.53,7.84) 43.53,7.11 46.64,4 51.01,4 51.55,3.46 JIO1.56
  TOP w0.381: v2(74.12,23.11) 74.12,24.2 RT565.1
  TOP w0.508: v2(16.12,30.03) 16.12,33.25 14.31,35.05 v2(14.31,35.73)
  IN1 w0.305: 29.84,21.81 v2(29.59,21.56) 29.15,21.12 28.43,21.12 27.21,22.34 23.39,22.34 22.83,22.91 21.8,22.91 17.51,27.19 17.51,28.63 v2(16.12,30.03)
  IN1 w0.381: 29.84,21.81 29.91,21.88 30.56,21.88 31.36,21.08 33.36,21.08 34.81,19.63 v2(35.32,19.63)
  IN2 w0.254: v2(56,27.43) 56.24,27.67 57.3,27.67 57.81,27.16 58.07,27.16 58.32,26.91 58.32,26.16 60.27,24.21 60.94,24.21 61.6,23.55 61.6,22.46 61.89,22.16 62.25,22.16 62.88,22.79 62.88,23.11 63.29,23.52 73.71,23.52 v2(74.12,23.11)
  IN4 w0.254: v2(50.93,27.32) 51.15,27.54 52.47,27.54 52.51,27.58 55.84,27.58 v2(56,27.43)
  IN4 w0.305: v2(45.24,23.58) 45.24,22.75 46.34,21.65 46.34,17.02 42.37,13.05 42.37,9.91 43.53,8.75 v2(43.53,7.84)
  BOTTOM w0.109: v2(16.12,30.03) v3(16.12,28.62) ; v2(16.12,30.03) 16.12,30.86 v3(16.64,31.39) ; v2(16.12,30.03) 17.13,30.03 v3(17.36,29.8)
  BOTTOM w0.203: v2(56,27.43) 55.87,27.56 UT5.D1
  BOTTOM w0.305: v2(45.24,23.58) 45.84,24.17 46.14,24.17 47.58,25.61 47.94,25.61 48.52,26.18 49.05,26.18 50.19,27.32 v2(50.93,27.32)
  BOTTOM w0.381: DT62.2 30.52,22.29 29.79,21.56 v2(29.59,21.56)
  vias: v2(6.69,48.74) v2(6.69,45.81) v2(8.35,48.26) v2(8.37,45.75) v2(8.31,41.89) v2(8.79,42.47) v2(8.94,48.26) v2(8.97,45.73) v2(8.92,41.89) v2(9.48,42.1) v2(9.47,41.5) v2(9.52,48.26) v2(9.57,45.69) v2(10,45.27) v2(9.98,41.79) v2(10.11,48.26) v2(10.17,41.22) v2(10.24,40.62) v2(10.48,44.92) v2(10.69,48.26) v2(10.64,39.22) v2(10.77,40.11) v2(10.82,40.7) v2(11.08,44.91) v2(11.1,39.63) v2(11.28,48.26) v2(11.44,40.7) v2(11.52,40.11)
+20V_TBTB_VBUS: length 168.4
  TOP w0.254: RT566.1 46.49,40.71 v2(45.71,41.48)
  TOP w0.305: v2(35.21,19.05) 35.09,19.05 34.71,19.43 34.71,19.99 35.1,20.38 35.1,21.16 35.99,22.05 35.99,24.36 36.91,25.28 v1(38.65,25.28) 39.62,25.28 39.8,25.1 42.24,25.1 v2(42.37,24.97) 42.68,25.28 43.41,25.28 43.81,25.67 43.81,26.36 44.15,26.7 44.63,26.7 45.29,27.36 47.74,27.36 v2(47.96,27.15) ; JIO1.60 50.52,1.68 50.52,2.28 50.8,2.56 50.8,3.2 50.5,3.5 46.29,3.5 42.71,7.08 v2(42.71,7.83)
  TOP w0.381: v2(32.57,53.22) 33.96,51.82 35.23,51.82 35.59,51.47 v2(35.59,51.03)
  IN1 w0.305: v2(12.42,29.23) 12.8,29.61 14.49,29.61 21.62,22.47 22.65,22.47 23.21,21.91 26.96,21.91 28.23,20.63 29.38,20.63 30.08,21.34 v2(30.34,21.34)
  IN1 w0.381: v2(35.21,19.05) 34.7,19.05 34.57,19.19 31.52,19.19 30.67,20.04 30.67,21.01 v2(30.34,21.34)
  IN3 w0.305: v2(42.37,24.97) 42.08,24.68 42.08,23.76 46.4,19.44 46.4,13.87 42.71,10.19 v2(42.71,7.83)
  IN3 w0.381: v2(32.57,53.22) 30.02,54.42 28.91,54.98 26.68,54.98 26.16,54.46 22.95,54.46 22.03,55.38 ; 22.03,55.38 v2(16.52,60.89) ; 22.03,55.38 21.39,54.74 18.87,54.74 16.91,52.77 16.91,48.9 15.25,47.25 15.25,46.73 14.3,45.78 14.3,43.88 14.58,43.6 14.58,41.18 13.18,39.78 13.18,39.3 10.78,36.9 8.82,36.9 7.25,35.34 7.25,31.32 9.35,29.23 v2(12.42,29.23)
  IN4 w0.254: v2(35.59,51.03) 36.76,51.03 37.49,50.3 38.85,50.3 39.37,49.78 39.37,49.32 40.59,48.1 40.59,46.22 44.39,42.42 45.09,42.42 45.71,41.8 v2(45.71,41.48)
  BOTTOM w0.203: 50.05,27.94 50.97,27.94 52.06,29.03 UT5.L3
  BOTTOM w0.25: v2(47.96,27.15) 47.96,26.92 48.21,26.66 48.77,26.66 50.05,27.94
  BOTTOM w0.305: v2(30.34,21.34) 30.68,21.68 31.4,21.68 DT60.2
  vias: v2(6.69,64.94) v2(6.69,62.01) v2(8.35,64.27) v2(8.43,61.91) v2(8.94,64.27) v2(9.02,61.9) v2(9.52,64.27) v2(9.55,61.65) v2(9.97,61.23) v2(10.1,64.27) v2(10.4,60.82) v2(10.69,64.25) v2(10.8,60.39) v2(11.18,63.89) v2(15.55,62.67) v2(15.55,62.08) v2(15.65,61.47) v2(15.93,60.94) v2(16.07,63.02) v2(16.07,62.39) v2(16.25,61.46) v2(16.59,62.07) v2(16.6,62.69) v2(16.84,61.42) v2(17.12,62.97) v2(17.12,62.36) v2(17.3,61.8)
+20V_VBUS_1: length 12.5
  TOP w0.381: PQ2101.3 36.86,11.74 36.86,11.3 37.06,11.1 v2(37.06,11.09) 37.07,11.09 37.51,10.65 PR2100.1
  IN1 w0.381: v2(42.22,18.26) 41.91,17.94 39.82,17.94 38.28,16.4 38.28,13.46 37.06,12.23 v2(37.06,11.09)
  vias: v2(11.19,33.18) v2(11.25,32.59) v2(11.35,31.95) v2(11.41,31.32) v2(11.43,30.68) v2(11.69,33.7) v2(11.8,33.09) v2(11.91,32.51) v2(11.94,30.35) v2(12.03,31.92) v2(12.08,31.27) v2(12.4,30.73) v2(12.59,30.13) v2(31.53,16.42) v2(32.51,16.26) v2(32.92,15.8) v2(33.17,16.44) v2(33.51,15.95) v2(41.67,18.52) v2(42.22,18.89) v2(42.8,19.14) v2(42.81,18.26) v2(43.38,19.62) v2(43.39,18.89) v2(43.41,18.26) v2(44.05,19.61) v2(44.03,18.88) v2(44.04,18.26) v2(44.59,19.17) v2(44.6,18.51) v2(49.49,20.78) v2(50.1,20.78) v3(13.11,31.3)
+20V_VBUS_2: length 3.7
  TOP w0.381: PR2104.1 38.65,19.13 38.24,19.54 PQ2105.3 38.77,20.26 39.26,20.74 v2(39.95,20.74)
  vias: v1(48.16,20.45) v2(15.27,30.69) v2(15.3,30.08) v2(15.61,29.54) v2(24.28,56.8) v2(24.34,57.39) v2(24.7,56.33) v2(24.87,56.9) v2(25.03,55.29) v2(25.12,55.92) v2(25.31,56.5) v2(25.58,55.51) v2(25.73,56.08) v2(26.01,55.08) v2(26.31,56.21) v2(26.31,55.61) v2(26.86,55.89) v2(27.35,55.54) v2(39.94,20.08) v2(39.94,19.47) v2(40.52,20.32) v2(40.5,19.68) v2(40.88,20.9) v2(41.14,20.34) v2(41.14,19.68) v2(41.52,20.9) v2(41.76,20.34) v2(41.76,19.68) v2(42.14,20.9) v2(42.39,20.34)
+20V_VBUS_DC_SS1: length 281.5
  TOP w0.254: PD4.2 49.69,14.01 v2(50.15,14.01) ; v2(254.06,12.11) 262.27,20.32 v2(266.89,20.32) ; v2(282.72,37.85) 283.21,38.35 PD700.2
  IN1 w0.254: v2(266.89,20.32) 266.94,20.32 268.11,21.49 274.11,21.49 278.88,26.25 278.88,32.61 280.82,34.56 280.82,35.44 282.72,37.33 v2(282.72,37.85) ; v2(50.15,14.01) 50.27,14.13 51.37,14.13 51.72,13.78 51.72,13.13 53.51,11.33 59.66,11.33 62.01,13.68 66.19,13.68 66.66,14.15 69.57,14.15 71.68,12.05 73.16,12.05 73.54,11.67 75.6,11.67 76.72,10.55 76.72,9.51 77.13,9.1 78.08,9.1 78.45,9.46 80.27,9.46 80.86,10.05 82.82,10.05 83.89,11.12 91.96,11.12 94.88,8.19 94.88,6.98 96.09,5.77 96.09,4.37 96.71,3.76 100.42,3.76 101.6,2.58 113.57,2.58 116.71,5.73 119.76,5.73 120.18,6.14 121.02,6.14 123.79,8.91 125.73,8.91 127.22,7.42 134.26,7.42 135.37,8.52 138.31,8.52 138.81,9.03 139.61,9.03 141.43,10.85 142.89,10.85 143.53,11.49 148.79,11.49 149.61,10.67 151.19,10.67 151.54,11.03 151.54,11.72 152.04,12.22 152.83,12.22 153.01,12.04 153.44,12.04 153.61,12.21 156.11,12.21 157.07,11.25 158.07,11.25 160.34,8.97 165.91,8.97 166.07,8.82 170.21,8.82 173.9,5.12 178.24,5.12 180.06,3.3 182.33,3.3 183.47,4.45 189.7,4.45 189.95,4.69 190.9,4.69 191.99,5.78 193.12,5.78 194.22,4.68 197.11,4.68 202.01,9.58 203.74,9.58 205.22,11.07 205.22,11.83 206.23,12.84 209.81,12.84 210.52,12.13 218.88,12.13 219.33,12.58 228.66,12.58 229.21,12.03 237.54,12.03 238.83,10.73 247.03,10.73 247.69,11.39 251.09,11.39 251.75,12.06 251.75,12.78 252.07,13.1 253.44,13.1 254.06,12.48 v2(254.06,12.11)
  BOTTOM w0.109: v2(282.72,37.85) v3(283.87,37.85)
+20V_VBUS_DC_SS2: length 279.3
  TOP w0.254: v2(251.16,12.15) 251.27,12.15 v2(266.16,27.03) ; v2(279.92,32.97) 279.92,38.68 281.16,39.92 PD701.3
  IN1 w0.254: v2(50.13,14.71) 50.31,14.53 51.54,14.53 52.1,13.97 52.1,13.28 53.67,11.71 59.5,11.71 61.87,14.09 66.02,14.09 66.47,14.53 69.76,14.53 71.86,12.43 73.31,12.43 73.69,12.05 75.75,12.05 77.1,10.7 77.1,9.73 77.35,9.48 77.87,9.48 78.32,9.92 80.14,9.92 81.78,11.56 92.05,11.56 95.26,8.35 95.26,7.14 96.47,5.93 96.47,4.69 96.88,4.28 100.44,4.28 101.75,2.96 113.41,2.96 116.56,6.11 119.6,6.11 120.02,6.52 120.56,6.52 120.98,6.94 120.98,7.26 120.72,7.52 120.72,8.27 120.96,8.52 122.64,8.52 123.42,9.29 125.89,9.29 127.38,7.8 134.11,7.8 135.21,8.9 138.15,8.9 138.66,9.41 139.45,9.41 141.27,11.23 142.74,11.23 143.37,11.87 149.48,11.87 150.78,13.16 151.27,13.16 151.53,12.9 152.73,12.9 152.95,13.12 153.42,13.12 153.95,12.59 156.26,12.59 156.58,12.27 158.42,12.27 158.64,12.05 158.64,11.22 160.5,9.35 166.07,9.35 166.23,9.2 170.38,9.2 174.07,5.51 178.39,5.51 180.22,3.69 182.09,3.69 183.23,4.83 187.33,4.83 190.39,7.89 193.41,7.89 193.65,7.64 193.65,5.78 194.38,5.06 196.9,5.06 202.03,10.2 203.82,10.2 204.71,11.09 204.71,11.85 206.07,13.22 209.97,13.22 210.68,12.51 218.72,12.51 219.18,12.96 231.31,12.96 231.51,13.16 242.4,13.16 242.99,12.57 249.53,12.57 249.95,12.15 v2(251.16,12.15)
  IN2 w0.254: v2(266.16,27.03) 266.16,27.36 271.1,32.3 279.25,32.3 v2(279.92,32.97)
  BOTTOM w0.254: PD6.3 v2(50.13,14.71)
  vias: v1(46.06,16.57)
+VCC_CORE: length 8.5
  TOP w0.508: v2(238.15,122.9) 237.9,122.9 PC1315.1 ; PC1317.1 231.19,122.85 v2(231.44,122.85) ; v2(234.84,122.85) 234.59,122.85 PC1316.1 ; PC1310.1 244.54,122.9 v2(244.79,122.9) ; v2(241.55,122.9) 241.3,122.9 PC1318.1
  BOTTOM w0.508: PC1310.1 244.54,122.9 v2(244.79,122.9) ; v2(238.15,122.9) 237.9,122.9 PC1315.1 ; PC1318.1 241.3,122.9 v2(241.55,122.9) ; v2(234.84,122.85) 234.59,122.85 PC1316.1 ; PC1317.1 231.19,122.85 v2(231.44,122.85)
  vias: v2(224.37,96.6) v2(225,96.6) v2(225.87,121.02) v2(225.86,96.65) v2(226.02,120.37) v2(226.01,119.77) v2(226.51,121.02) v2(226.6,119.77) v2(226.61,120.37) v2(227.04,113.88) v2(227.03,113.24) v2(227.04,112.59) v2(227.04,111.94) v2(227.06,110.64) v2(227.04,110.01) v2(227.14,121.02) v2(227.15,107.58) v2(227.15,96.35) v2(227.24,120.37) v2(227.23,119.77) v2(227.41,105.3) v2(227.41,104.08) v2(227.42,102.94) v2(227.73,121.59) v2(227.76,120.96) v2(227.79,111.28) v2(227.83,120.35) v2(227.83,119.72) v2(227.83,119.08) v2(227.83,118.45) v2(227.83,113.24) v2(227.86,112.6) v2(227.83,111.94) v2(227.83,110.64) v2(227.82,109.97) v2(227.86,109.32) v2(228.42,124.11) v2(228.42,123.53) v2(228.42,122.89) v2(228.42,122.26) v2(228.42,121.62) v2(228.42,120.99) v2(228.42,120.35) v2(228.42,119.72) v2(228.42,119.08) v2(228.42,118.45) v2(228.62,114.54) v2(228.62,113.89) v2(228.6,113.24) v2(228.62,112.59) v2(228.6,111.96) v2(228.61,110.63) v2(228.62,109.98) v2(228.89,117.5) v2(228.97,107.58) v2(229.05,124.11) v2(229.05,123.53) v2(229.05,122.89) v2(229.05,122.26) v2(229.05,121.62) v2(229.05,120.99) v2(229.05,120.35) v2(229.05,119.72) v2(229.05,119.08) v2(229.05,118.45) v2(229.4,112.61) v2(229.32,100.19) v2(229.41,113.24) v2(229.41,111.94) v2(229.41,111.28) v2(229.41,110.64) v2(229.41,109.98) v2(229.41,109.34) v2(229.56,107.58) v2(229.69,124.11) v2(229.69,123.53) v2(229.69,122.89) v2(229.69,122.26) v2(229.69,121.62) v2(229.69,120.99) v2(229.69,120.35) v2(229.69,119.72) v2(229.69,119.08) v2(229.69,118.45) v2(229.75,117.64) v2(229.77,105.3) v2(229.77,104.08) v2(229.79,102.9) v2(229.86,96.35) v2(230.19,114.54) v2(230.19,113.89) v2(230.19,112.59) v2(230.18,111.94) v2(230.19,111.29) v2(230.18,110.64) v2(230.19,109.98) v2(230.19,109.36) v2(230.28,120.36) v2(230.34,124.82) v2(230.32,124.19) v2(230.33,123.54) v2(230.32,119.72) v2(230.32,119.08) v2(230.32,118.45) v2(230.44,117.59) v2(230.58,96.56) v2(230.93,124.82) v2(230.91,124.19) v2(230.92,120.31) v2(230.98,118.94) v2(230.98,114.54) v2(230.95,113.89) v2(230.98,113.24) v2(230.99,112.62) v2(230.98,111.94) v2(231.01,123.58) v2(231.04,119.68) v2(231.03,118.27) v2(231,110.01) v2(231.19,117.51) v2(231.37,107.59) v2(231.51,124.13) v2(231.76,123.49) v2(231.77,113.25) v2(231.77,112.59) v2(231.77,111.94) v2(231.77,111.31) v2(231.77,110.64) v2(231.77,109.98) v2(231.79,109.34) v2(231.71,99.57) v2(231.83,120.38) v2(231.93,117.77) v2(231.99,107.58) v2(232.09,119.03) v2(232.08,118.37) v2(232.12,119.71) v2(232.46,117.52) v2(232.56,114.54) v2(232.55,113.89) v2(232.56,113.24) v2(232.56,112.59) v2(232.56,111.94) v2(232.56,111.3) v2(232.56,110.64) v2(232.56,109.99) v2(232.56,109.34) v2(232.86,123.44) v2(232.86,122.71) v2(232.86,121.53) v2(232.86,120.9) v2(232.86,120.26) v2(232.86,119.63) v2(232.86,118.99) v2(232.86,118.36) v2(233.07,117.8) v2(233.19,122.13) v2(233.33,114.55) v2(233.34,113.89) v2(233.32,113.24) v2(233.34,112.59) v2(233.34,111.96) v2(233.31,110.64) v2(233.34,109.98) v2(233.5,123.44) v2(233.46,122.81) v2(233.43,121.19) v2(233.43,119.98) v2(233.61,119) v2(233.61,118.37) v2(233.89,117.8) v2(233.8,107.58) v2(234.15,112.61) v2(234.13,111.94) v2(234.12,111.31) v2(234.13,110.64) v2(234.13,109.99) v2(234.13,109.34) v2(234.15,100.19) v2(234.29,123.48) v2(234.39,107.58) v2(234.38,96.54) v2(234.47,118.98) v2(234.47,118.32) v2(234.57,117.72) v2(234.91,114.56) v2(234.92,113.89) v2(234.94,113.25) v2(234.92,112.59) v2(234.92,111.94) v2(234.92,111.29) v2(234.91,110.64) v2(234.92,109.98) v2(235.08,118.98) v2(235.08,118.34) v2(235.19,123.43) v2(235.21,96.54) v2(235.35,117.73) v2(235.59,123.96) v2(235.7,113.87) v2(235.78,124.83) v2(235.71,114.54) v2(235.71,113.24) v2(235.71,111.94) v2(235.7,111.28) v2(235.99,123.26) v2(235.98,118.3) v2(235.96,117.59) v2(236.01,118.94) v2(236.19,107.58) v2(236.15,96.57) v2(236.29,121.66) v2(236.23,120.6) v2(236.33,126.09) v2(236.31,125.26) v2(236.32,124.49) v2(236.36,123.74) v2(236.49,113.89) v2(236.49,112.59) v2(236.44,109.99) v2(236.5,109.39) v2(236.65,121.11) v2(236.61,119.94) v2(236.6,117.67) v2(236.71,122.94) v2(236.76,122.13) v2(236.78,119.01) v2(236.78,118.37) v2(236.86,107.59) v2(236.93,126.07) v2(236.97,125.26) v2(237.04,124.47) v2(237.15,123.65) v2(237.23,117.75) v2(237.26,112.57) v2(237.27,111.89) v2(237.27,111.28) v2(237.3,110.65) v2(237.24,96.51) v2(237.3,110) v2(237.4,119.04) v2(237.41,118.37) v2(237.51,126.07) v2(237.56,125.26) v2(237.62,124.47) v2(237.73,123.65) v2(238.05,118.97) v2(238.01,118.34) v2(238.03,117.7) v2(238.06,113.28) v2(238.08,111.93) v2(238.05,110.61) v2(238.06,110) v2(238.06,96.54) v2(238.17,126.05) v2(238.3,125.26) v2(238.34,124.53) v2(238.48,107.58) v2(238.61,123.87) v2(238.68,119.06) v2(238.69,118.34) v2(238.87,113.26) v2(238.86,112.6) v2(238.86,111.94) v2(238.88,111.27) v2(238.86,110.64) v2(238.82,110) v2(238.86,109.34) v2(238.98,126.02) v2(239.08,125.2) v2(239.02,96.54) v2(239.13,124.39) v2(239.36,123.33) v2(239.37,119) v2(239.61,122.02) v2(239.64,112.59) v2(239.65,111.93) v2(239.64,111.29) v2(239.65,110.63) v2(239.64,109.98) v2(239.8,121.35) v2(239.78,120.59) v2(239.74,106.35) v2(239.74,105.59) v2(239.74,104.83) v2(239.74,104.07) v2(239.71,96.6) v2(239.82,122.66) v2(239.87,119.78) v2(240.19,123.39) v2(240.34,107.58) v2(240.45,113.92) v2(240.43,113.24) v2(240.44,112.59) v2(240.43,111.94) v2(240.41,111.28) v2(240.43,110.64) v2(240.41,110) v2(240.43,109.33) v2(240.45,96.72) v2(240.93,107.58) v2(241.06,123.54) v2(241.22,114.54) v2(241.21,113.21) v2(241.22,112.59) v2(241.23,111.92) v2(241.23,110.6) v2(241.22,109.98) v2(241.21,109.33) v2(241.49,96.54) v2(241.98,113.9) v2(242.01,114.54) v2(242.01,113.24) v2(242.01,112.59) v2(242.01,111.94) v2(242.01,111.29) v2(242.01,110.64) v2(242.02,110) v2(242.09,96.57) v2(242.47,123.51) v2(242.77,114.54) v2(242.79,113.89) v2(242.76,113.23) v2(242.79,112.59) v2(242.8,111.94) v2(242.78,110.61) v2(242.79,109.98) v2(242.79,109.36) v2(242.94,121.56) v2(242.94,120.94) v2(243.05,119.6) v2(243.12,124.04) v2(243.26,123.41) v2(243.3,120.16) v2(243.38,122.74) v2(243.41,122.11) v2(243.45,121.25) v2(243.52,126.01) v2(243.52,125.38) v2(243.52,124.74) v2(244.1,126.01) v2(244.1,125.38) v2(244.1,124.74) v2(244.1,124.11) v2(244.1,123.52) v2(244.11,120.13) v2(244.53,119.66) v2(244.74,126.01) v2(244.74,125.38) v2(244.74,124.74) v2(244.74,124.11) v2(244.74,123.52) v2(244.76,120.24) v2(245.2,119.6) v2(245.37,126.01) v2(245.37,125.38) v2(245.37,124.74) v2(245.37,124.11) v2(245.37,123.52) v2(245.52,120.11) v2(246.01,126.01) v2(246.01,125.38) v2(246.01,124.74) v2(246.01,124.11) v2(246.13,123.46) v2(246.14,120.16) v2(246.4,121.88) v2(246.56,121.26) v2(246.59,120.67) v2(246.64,125.99) v2(246.66,125.32) v2(246.67,124.66) v2(246.68,124) v2(246.69,122.64) v2(246.9,123.26) v2(246.98,121.88) v2(247.15,121.26) v2(247.17,120.67) v2(247.28,122.64) v2(247.47,124.03) v2(247.47,123.45) v2(247.57,121.88) v2(247.73,121.26) v2(248.1,122.84) v2(248.1,122.25) v2(248.11,124.03) v2(248.11,123.45) v2(248.2,121.67) v2(248.74,124.03) v2(248.74,123.45) v2(248.73,122.84) v2(248.73,122.25) v3(243.64,119.63)
+VCC_FUSEPRG: length 44.5
  TOP w0.109: v2(222.71,108.84) 222.44,109.12 UC1.G30 ; RC326.1 194.81,98.72 v2(195.02,98.51)
  IN4 w0.102: v2(222.71,108.84) 222.71,108.52 221.82,107.63 220.55,107.63 220.3,107.37 220.3,106.15 219.73,105.57 219.36,105.57 218.44,104.66 218.44,104.25 218.05,103.86 217.39,103.86 211.91,98.38 211.91,92.46 211.13,91.67 208.2,91.67 201.36,98.51 v2(195.02,98.51)
  BOTTOM w0.109: v2(195.02,98.51) v3(194.22,98.51)
+VCC_GT: length 12
  TOP w0.254: v2(253.15,96.83) 252.57,96.83 252.29,96.54 UC1.BF14 UC1.BF13 ; v2(249.24,96.67) 249.54,96.37 UC1.BB14 UC1.BB13 ; v2(248.63,96.67) UC1.BA14 UC1.BA13 ; v2(251.87,96.74) 251.37,96.24 UC1.BD14 UC1.BD13 ; UC1.AW14 246.28,96.57 v2(246.28,96.88)
  TOP w0.305: UC1.AT14 245.11,96.19 v2(245.11,96.89) ; v2(245.7,96.88) 245.7,96.24 UC1.AU14
  TOP w0.508: 249.97,116.58 248.53,118.02 PR1124.2
  vias: v2(244.37,113.89) v2(244.37,112.59) v2(244.37,111.29) v2(244.39,110.63) v2(244.37,109.98) v2(244.48,96.88) v2(245.17,113.9) v2(245.15,113.24) v2(245.13,112.59) v2(245.17,111.31) v2(245.19,109.99) v2(245.15,109.37) v2(245.17,107.65) v2(245.35,107.05) v2(245.33,105.84) v2(245.35,104.63) v2(245.77,107.65) v2(245.91,113.24) v2(245.94,112.59) v2(245.96,111.93) v2(245.94,111.29) v2(245.94,110.63) v2(245.94,109.98) v2(245.93,109.37) v2(246.7,109.98) v2(246.71,113.91) v2(246.73,113.24) v2(246.73,112.6) v2(246.73,111.94) v2(246.71,111.3) v2(246.73,110.64) v2(247.5,114.51) v2(247.52,113.89) v2(247.51,113.25) v2(247.52,112.59) v2(247.51,111.96) v2(247.51,110.62) v2(247.52,109.98) v2(247.5,109.33) v2(247.69,105.81) v2(247.71,107.02) v2(247.71,104.6) v2(248.29,112.59) v2(248.3,111.94) v2(248.3,111.27) v2(248.3,110.64) v2(248.3,109.99) v2(248.3,109.34) v2(249.09,113.89) v2(249.08,113.23) v2(249.09,112.59) v2(249.09,111.92) v2(249.09,111.29) v2(249.06,110.64) v2(249.09,109.98) v2(249.88,113.87) v2(249.88,113.24) v2(249.86,112.61) v2(249.87,111.29) v2(249.88,109.98) v2(249.88,109.36) v2(249.91,114.51) v2(250.06,107.02) v2(250.04,105.81) v2(250.08,104.6) v2(250.29,107.59) v2(250.66,113.21) v2(250.67,112.59) v2(250.65,111.92) v2(250.67,111.29) v2(250.66,110.64) v2(250.67,109.98) v2(250.67,109.35) v2(250.89,107.59) v2(251.48,114.5) v2(251.44,113.91) v2(251.45,113.24) v2(251.47,112.58) v2(251.45,111.94) v2(251.46,111.29) v2(251.45,110.64) v2(251.45,109.98) v2(252.2,122.42) v2(252.22,124.5) v2(252.22,123.83) v2(252.22,123.14) v2(252.21,121.73) v2(252.24,113.89) v2(252.24,113.24) v2(252.24,112.59) v2(252.21,111.92) v2(252.24,109.98) v2(252.22,109.33) v2(252.4,105.81) v2(252.41,107.02) v2(252.41,104.6) v2(252.87,124.52) v2(252.87,123.84) v2(252.87,123.16) v2(252.85,122.43) v2(252.86,121.75) v2(253,111.27) v2(253.01,112.59) v2(253.03,111.94) v2(253.03,110.64) v2(253.03,109.98) v2(253.03,109.34) v2(253.42,125.88) v2(253.42,125.21) v2(253.49,124.49) v2(253.49,123.82) v2(253.49,123.13) v2(253.46,122.4) v2(253.48,121.72) v2(253.87,114.7) v2(253.82,113.89) v2(253.82,112.59) v2(253.82,111.94) v2(253.82,110.66) v2(253.82,109.98) v2(253.85,109.34) v2(254.07,125.9) v2(254.07,125.23) v2(254.06,103.91) v2(254.13,106.25) v2(254.16,102.18) v2(254.19,101.49) v2(254.19,100.73) v2(254.68,125.87) v2(254.68,125.2) v2(254.6,114.56) v2(254.95,106.25) v2(254.95,103.87) v2(254.95,98.38) v2(255.32,125.86) v2(255.32,125.19) v2(255.41,114.81) v2(255.59,106.25) v2(255.59,98.38) v2(255.64,103.87) v2(255.97,125.88) v2(255.97,125.21) v2(256.3,122.54) v2(256.22,98.38) v2(256.32,124.62) v2(256.32,123.95) v2(256.32,123.27) v2(256.31,121.86) v2(256.58,125.85) v2(256.58,125.18) v2(256.66,114.8) v2(256.86,98.38) v2(256.97,124.61) v2(256.97,123.94) v2(257.01,123.31) v2(257.01,122.64) v2(257.19,125.82) v2(257.19,125.19) v2(257.56,98.38) v2(257.65,124.47) v2(257.67,123.78) v2(257.67,123.11) v2(257.7,112.74) v2(257.82,125.8) v2(257.82,125.13) v2(258.43,125.77) v2(258.43,125.14) v2(258.89,98.36) v3(251.23,120.17)
+VCC_SA: length 12.1
  TOP w0.381: PR1111.1 224.9,117.75 223.57,119.07 213.98,119.07 213.57,119.48
  vias: v2(212.82,124.69) v2(212.82,123.68) v2(212.82,122.66) v2(212.82,122.03) v2(212.82,121.39) v2(213.2,125.2) v2(213.2,124.18) v2(213.2,123.17) v2(213.42,122.02) v2(213.42,121.39) v2(214.04,122.04) v2(214.04,121.4) v2(214.04,120.77) v2(214.69,122.03) v2(214.69,121.39) v2(214.68,120.76) v2(215.29,122.02) v2(215.29,121.39) v2(215.88,122.05) v2(215.88,121.41) v2(224.7,113.23) v2(224.68,112.59) v2(224.65,111.94) v2(224.68,110.64) v2(224.72,110) v2(225.47,113.88) v2(225.47,113.23) v2(225.47,112.59) v2(225.47,111.93) v2(225.47,111.29) v2(225.46,110.63) v2(225.47,109.98) v3(214.67,123.89)
+VCC_SFR_OC: length 70.9
  TOP w0.254: UC1.BJ13 254.47,95.76 UC1.BH13 253.81,95.1 v2(253.66,95.1)
  TOP w0.305: v2(222.76,93.87) 222.44,94.21 UC1.G11
  TOP w0.356: CC210.2 262.8,95.04 262.8,94.3 CC334.1
  TOP w0.381: CC210.2 CC209.2 262.41,95.62 v2(262.22,95.43)
  IN1 w0.508: v2(262.22,95.43) 260.87,95.43 258.79,97.51 255.49,97.51 254.73,96.75 254.73,96.17 v2(253.66,95.1)
  IN4 w0.508: 224.68,95.46 225,95.78 243.59,95.78 244.11,96.3 248.15,96.3 248.67,95.78 252.84,95.78 252.89,95.72 252.99,95.72 253.38,95.34 253.38,95.24 253.52,95.1 v2(253.66,95.1)
  IN4 w0.61: 224.68,95.46 224.3,95.08
  BOTTOM w0.508: 263.88,93.8 262.25,95.43 v2(262.22,95.43) ; 263.88,93.8 263.98,93.8 267.71,97.53 CC568.1 ; 263.88,93.8 263.88,91.94 v3(265.75,90.07) 270.31,85.51 272.01,85.51 272.86,84.67 274.25,84.67 274.27,84.69 v2(275.81,84.69)
+VCCRTCEXT: length 5
  TOP w0.254: CH68.1 169.93,19.75 170.3,20.12 v1(170.47,20.12) 171.07,20.12 171.26,19.93 172.84,19.93 173.34,20.44 UH1.BG47 UH1.BF47
+VDD_SUPPLY: length 30.9
  TOP w0.254: RT526.2 50.93,38.61 50.93,37.81 RT535.1 50.55,37.43 50.55,36.55 v2(50.57,36.52) ; CT345.1 48.03,31.48 v1(48.82,31.48) 49.23,31.48 49.57,31.82 v2(49.92,31.82)
  TOP w0.305: RT517.1 49.93,28.66 49.54,29.04 RT521.1 49.54,29.55 49.86,29.87 v2(49.9,29.87)
  IN3 w0.254: v2(50.57,36.52) 50.45,36.52 50.05,36.12 50.05,35.48 50.69,34.84 50.69,34.53 50.05,33.89 50.05,31.99 49.92,31.86 v2(49.92,31.82)
  IN4 w0.254: v2(55.81,32.08) 56.08,32.35 56.58,32.35 56.97,31.96 56.97,28.74 56.71,28.48 52.96,28.48 51.7,29.74 50.03,29.74 v2(49.9,29.87) 49.9,30.65 50.23,30.97 50.23,31.51 v2(49.92,31.82)
  BOTTOM w0.229: v2(55.81,32.08) 55.87,32.14 UT5.D10 UT5.C10
  BOTTOM w0.254: v2(50.57,36.52) 50.55,36.54 50.55,36.99 51,37.45 JCCG1.1
  BOTTOM w0.381: v2(49.92,31.82) 49.92,32.01 49.65,32.28 RT519.1 49.65,33.2 RT522.1 49.64,33.83 RT534.1
+VDDA_AVDD1: length 11.8
  TOP w0.203: UA1.40 346.36,27.14
  IN1 w0.254: v2(352.99,27.73) 352.8,27.54 352.8,26.54 352.52,26.26 350.45,26.26 349.39,27.31 349.39,28.52 348.69,29.21 347.17,29.21 v2(346.36,30.03)
  BOTTOM w0.254: v2(352.99,27.73) 352.68,27.43 RA214.2
  vias: v1(346.48,27.53)
+VSS_PLL: length 3.8
  TOP w0.254: UE1.G1 129.55,24.45 129.28,24.72
  TOP w0.381: CE17.2 126.88,26.02 CE18.2 127.98,26.02 129.28,24.72
DV10: length 7.1
  BOTTOM w0.203: 26.99,13.11 26.71,13.38 26.27,13.38 25.83,13.82 UR1.46
  BOTTOM w0.356: CR245.2 CR246.2 28.25,10.3 v1(27.72,10.83)
  BOTTOM w0.508: 26.99,13.11 27.28,12.81 27.28,11.36 27.72,10.92 v1(27.72,10.83)
DV33_18: length 2.2
  BOTTOM w0.109: UR1.24 v1(17.9,17.42) 17.85,17.46 CR244.2
GND: length 5473.3
  TOP w0.102: v3(119.15,42.67) v2(117.83,42.67) ; UH1.C12 195.42,37.7 195.62,37.89 198.17,37.89 198.57,38.29 198.57,39.01 198.97,39.41 198.97,40.25 200.25,41.53 201.63,41.53 201.94,41.22 v2(201.94,40.82) 201.47,40.34 201.47,39.3 200.93,38.76 200.43,38.76 198.51,36.85 196.5,36.85 196.1,37.24 195.14,37.24 UH1.D12 ; v3(280.65,101.26) 281.31,100.6 v2(281.9,100.6) ; v2(170.74,33.3) 170.99,33.05 173.61,33.05 UH1.BG22 ; UH1.BG28 173.58,29.66 170.92,29.66 170.84,29.58 167.06,29.58 v2(166.88,29.4) ; UH1.D8 194.91,39.66 195.57,39.66 195.59,39.63 195.94,39.63 195.96,39.65 196.14,39.65 196.18,39.69 UH1.A8
  TOP w0.127: v2(16.97,57.13) 16.63,57.47 RT640.2 ; v3(28.5,54.79) 28.03,54.79 PC17.2 ; RT219.2 12.88,48.64 v2(12.64,48.4) ; RT219.2 v2(13.21,48.09) ; RT219.2 13.55,48.64 v2(13.79,48.4) ; v2(14.47,48.39) 14.86,48.77 DT18.2 ; v2(11.75,41.63) 11.42,41.96 RT504.2 ; v2(10.6,41.63) 10.93,41.96 RT504.2 ; v2(13.58,44.05) 13.11,43.58 DT14.2 ; v2(16.97,58.28) 16.63,57.93 RT640.2 ; RT631.2 v2(11.15,44.26) ; RT631.2 11.38,43.72 v2(11.7,44.04) ; RT631.2 10.93,43.72 v2(10.61,44.04) ; v2(14.66,56.45) 15.02,56.1 DT54.2 ; DT45.2 13.4,52.94 v2(13.82,53.36) ; DT45.2 13.03,52.94 v2(12.61,53.36) ; DT45.2 13.21,52.94 v2(13.21,53.45) ; v2(12.37,44.04) 12.83,43.58 DT14.2 ; v2(14.47,57.14) 14.87,57.55 RT639.2 ; v2(10.85,59.77) 10.56,59.48 RT638.2 ; v2(12.99,41.55) DT13.2 ; DT13.2 12.89,42.11 v2(12.41,41.64) ; DT13.2 13.1,42.11 v2(13.58,41.64) ; DT14.2 v2(12.99,44.07) ; DT18.2 v2(15.05,48.2) ; DT18.2 15.24,48.77 v2(15.62,48.39) ; v2(10.9,58.67) 10.56,59.01 RT638.2 ; v2(15.63,50.62) 15.24,50.24 DT17.2 ; RT504.2 v2(11.15,41.41) ; RT637.2 8.8,59.03 v2(8.45,58.67) ; RT637.2 8.26,59.24 v2(8.26,59.24) ; RT637.2 8.8,59.45 v2(8.45,59.8) ; v2(14.28,57.71) RT639.2 ; RT639.2 14.87,57.89 v2(14.47,58.29) ; RT632.2 13.47,50.39 v2(13.77,50.69) 13.77,51.15 13.44,51.47 DT44.2 ; RT632.2 12.96,50.39 v2(12.66,50.69) 12.66,51.12 13.01,51.47 DT44.2 ; RT632.2 v2(13.21,50.96) DT44.2 ; DT17.2 14.86,50.24 v2(14.48,50.62) ; DT17.2 v2(15.05,50.81) ; RT640.2 v2(17.19,57.71) ; v2(16.87,55.3) 16.48,55.68 DT52.2 ; DT54.2 15.02,55.63 v2(14.68,55.3) ; DT54.2 v2(14.51,55.88) ; v3(277.69,107) v2(277.69,107.97) ; RT638.2 v2(11.1,59.24) ; v2(17.06,55.88) DT52.2 ; DT52.2 16.48,56.06 v2(16.87,56.45) ; v2(286.35,70.3) 286.74,69.91 v3(286.74,69.37) ; UH1.BG37 172.81,25.33 172.52,25.62 171.9,25.62 v2(171.53,25.25)
  TOP w0.152: v2(198.19,41.24) 198.19,40.98 196.9,39.69 UH1.A8 ; UH1.BG33 173.46,27.52 173.42,27.57 171.88,27.57 171.76,27.45 170.45,27.45 v2(170.04,27.04) ; v2(185.04,44.73) 184.95,44.64 UH1.AD1 UH1.AD2 ; UH1.J48 192.07,20.44 192.23,20.59 UH1.J47 ; v2(186.89,19.2) 186.63,19.47 UH1.AA49 ; v2(183.08,46.39) 183.08,46.27 183.27,46.06 UH1.AG1 ; v2(173,35.49) 173.42,35.49 UH1.BG17 ; UH1.AD49 184.95,18.53 v2(185.05,18.43) ; UH1.AT1 178.85,43.78 178.56,44.07 178.56,44.68 178.06,45.19 178.06,46.2 CC302.2 ; UH1.A37 196.26,25.01 v2(196.35,24.92) ; UH1.AM49 181.08,19.1 180.85,18.88 v2(180.85,18.77) ; UH1.BC35 175.51,26.31 v2(175.51,25.93) ; v2(199.38,27.33) 199.27,27.23 196.81,27.23 196.52,27.52 UH1.A33 ; UH1.A28 196.83,29.72 v2(197.1,30) ; v2(191.48,19.28) 191.18,19.59 UH1.M49 ; UH1.BG25 173.29,31.4 ; UH1.AM1 181.08,44.23 180.56,44.75 180.56,46.33 179.63,47.26 179.63,47.6 179.1,48.13 179.1,48.15 v2(178.78,48.47) ; v2(183.27,18.41) UH1.AG49
  TOP w0.203: v2(216.43,110.6) 217.7,109.33 218.44,109.33 UC1.A30 ; PU200.14 203.98,9.46 v2(204.25,9.18) ; v2(189.65,111.75) 189.84,111.94 UV8.52 ; v2(258.99,114.64) UC1.BR38 ; PU700.22 289.84,29.1 290,28.94 290,28.69 v2(289.88,28.57) ; v2(245.94,113.89) 246.26,113.56 UC1.AV37 ; UZ44.11 325.99,25.16 v2(325.87,25.28) ; UC1.L33 225,110.96 v2(224.68,111.29) 224.96,111.56 225.01,111.61 UC1.L34 ; UH1.C4 195.73,41.31 v2(195.77,41.3) ; 173.29,31.4 173.19,31.5 169.93,31.5 v2(169.83,31.4) ; UC1.A20 v2(217.96,101.35) ; UC1.AY34 247.85,111.61 v2(247.52,111.29) 247.84,110.96 UC1.AY33 ; UC1.A6 216.99,91.13 v2(216.85,91.27) ; UC1.AH33 238.39,110.96 v2(238.07,111.29) 238.4,111.61 UC1.AH34 ; UZ9.11 v2(91.06,26.82) ; UC1.BC34 250.2,111.61 v2(249.88,111.94) ; UC1.AR14 UC1.AR13 243.74,95.08 v2(243.6,95.08) ; v2(249.88,110.64) 250.21,110.96 UC1.BC33 ; UC1.BF33 252.56,110.96 v2(252.24,111.29) ; CT317.1 29.41,39.6 28.86,39.05 CT316.1 ; v2(245.15,110.64) 245.48,110.96 UC1.AU33 ; UC1.A34 218.22,111.73 217,111.73 v2(216.88,111.85) ; UH1.A5 UH1.A4 UH1.A3 UH1.A2 ; v2(244.24,85.84) UC1.AR1 ; UC1.BD37 250.99,113.56 v2(250.67,113.89) 251,114.22 UC1.BD38 ; v2(195.22,120.59) 195.18,120.55 UV8.19 ; UV8.11 v2(194.75,117.35) ; v2(245.15,111.94) 245.48,111.61 UC1.AU34
  TOP w0.254: DI6.3 v2(357.61,32.91) ; UE1.A6 133.66,29.52 133.66,30.29 v2(134.2,30.83) ; v2(118.32,25.19) 118.1,25.41 UZ12.32 118.1,27.35 CZ51.2 ; CA54.2 341.03,21.35 340.46,20.78 339.63,20.78 339.37,20.53 339.37,20.04 338.55,19.22 338.14,19.22 337.85,18.93 v2(337.27,18.93) ; CT327.2 30.72,40.53 30.99,40.26 CT310.2 30.99,40.06 31.31,39.74 v2(31.31,39.59) ; UH1.A2 196.29,42.85 v2(196.73,43.07) ; UZ12.23 121.64,24.91 v2(121.37,25.19) ; v2(289.88,13.4) 289.66,13.19 289.66,12.18 JKBTP1.9 ; UC1.W34 231.03,111.27 v2(230.97,111.27) ; v2(347.52,39.88) 347.82,39.59 UI2.14 ; v2(179.22,135.81) 178.7,136.33 177.56,136.33 JDGFF4.B1 ; JDGFF4.B7 173.47,135.18 v2(173.37,135.08) ; PU1203.4 v2(227.01,137.48) ; JKBTP1.3 292.66,13.05 292.32,13.39 v2(292.32,13.43) ; QE2.1 117.53,19.11 117.45,19.03 116.44,19.03 v2(116.32,18.9) ; UC1.T33 228.84,111.1 v2(228.62,111.29) 228.95,111.61 UC1.T34 ; UZ23.5 328.88,31.28 329.07,31.48 v2(329.43,31.48) ; v2(283.78,80.96) 283.87,81.05 JXDP1.7 ; CN192.2 345.91,10.98 v2(345.15,10.22) ; v2(283.71,90.21) 283.87,90.05 JXDP1.37 ; v2(280.98,94.19) 281.22,93.95 JXDP1.50 ; CC322.2 277.28,85.04 276.96,84.72 276.96,83.72 277.08,83.6 UZ26.5 ; 109.13,44.25 109.13,45.6 108.83,45.91 v2(108.83,46.35) ; 109.13,44.25 109.5,43.88 JEDP1.31 ; 109.13,44.25 109,44.12 JEDP1.30 ; UC1.AH35 238.4,112.26 v2(238.06,112.6) 238.37,112.91 UC1.AH36 ; v2(231.28,96.62) 231.85,96.05 UC1.Y14 ; PU1800.2 217.1,132.9 v2(217.35,133.16) ; v2(203.05,127) 203.13,126.91 UZ7.5 ; JDGFF4.A9 172.27,137.5 v2(172.15,137.62) ; v2(242.58,139.92) 242.64,139.86 PU1201.4 ; JXDP1.31 283.92,88.25 v2(283.77,88.1) ; JXDP1.20 281.37,84.95 v2(281.06,84.64) 281.01,84.58 281.01,83.47 281.33,83.15 JXDP1.14 ; CT356.2 47.41,32.81 47.26,32.65 47.26,31.67 CT345.2 47.32,31.18 46.86,30.72 v2(46.86,29.93) ; UC1.Y38 v2(231.77,113.89) UC1.Y37 ; JXDP1.32 v2(280.92,88.55) ; UC1.N34 v2(227.08,111.29) 226.84,111.1 UC1.N33 ; JXDP1.38 280.73,90.35 v2(280.55,90.18) ; UZ19.5 193.63,95.05 v2(193.8,95.22) ; v2(195.77,41.3) 195.71,41.36 UH1.C5 ; JLED1.4 314.31,9.46 314.58,9.19 314.94,9.19 315.22,8.9 315.22,8.9 315.33,8.8 v2(315.33,8.7) ; v2(156.68,19.64) 156.68,19.69 157.08,20.09 157.35,20.09 157.72,20.46 157.72,21.25 157.41,21.55 CE61.2 ; JDGFF4.B4 175.27,135.15 v2(175.38,135.04) 175.5,134.92 175.7,134.92 176.09,134.53 176.09,134.14 175.87,133.92 JDGFF4.C3 ; JEDP1.40 114,43.7 114.78,44.47 114.78,45.95 114.48,46.25 v2(114.28,46.25) ; UC1.AG29 v2(237.67,107.59) ; v2(123.45,15.06) 123.41,15.02 122.36,15.02 CZ59.2 ; v2(283.17,12.2) 283.17,12.18 JKBTP1.20 ; JPB1.5 v2(320.85,45.75) ; v2(121.37,22.14) 121.59,21.91 UZ12.16 ; PU1200.4 250.34,139.96 v2(250.27,140.03) ; v2(17.09,6.26) 16.86,6.03 JAPS1.8 ; v2(282.39,81.35) JXDP1.8 ; v2(292.98,13.42) 293.16,13.23 293.16,12.18 JKBTP1.2 ; UE1.E6 133.96,26.05 v2(134.37,26.46) ; v2(171.39,135.13) 171.67,135.41 JDGFF4.B10 ; UC1.AB34 v2(233.34,111.29) 233.57,111.1 UC1.AB33 ; UZ21.5 189.49,87.99 v2(188.97,87.47) ; v2(281.05,87.03) 281.33,86.75 JXDP1.26 ; v2(128.55,24.41) 128.46,24.5 127.44,24.5 127.26,24.32 CE13.2 ; JAPS1.10 17.86,6.47 v2(17.99,6.6) ; UC1.AM38 241.28,113.89 v2(241.22,113.89) 241.54,113.56 UC1.AM37 ; v2(237.26,109.31) 237.61,108.96 UC1.AG30 ; RV876.2 59.68,29.13 60.62,29.13 60.89,29.39 RV861.1 ; CZ129.2 v2(327.86,32.8) ; JXDP1.25 283.8,86.45 v2(283.78,86.43) ; CE21.2 133.07,16.48 v2(132.89,16.66) ; JXDP1.19 283.75,84.65 v2(283.02,85.38) ; v2(19.95,4.68) 19.86,4.77 JAPS1.14 ; v2(235.71,110.64) UC1.AE33 236.16,111.02 236.16,111.56 UC1.AE34 ; UI1.14 349.48,50.01 v2(349.73,49.76) ; v2(318.68,12.92) 317.92,13.67 UZ58.5 ; UC1.AC37 v2(234.13,113.24) ; v2(18.69,6.6) 18.86,6.43 JAPS1.12 ; v2(219.16,129.83) 218.83,130.17 PU1800.14 ; v2(252.24,111.29) 252.57,111.61 UC1.BF34 ; CT322.1 29.33,37.74 CT319.1 28.13,37.74 CT300.2 27.51,37.74 v2(27.41,37.64) ; JXDP1.49 284.01,93.65 v2(283.81,93.45) ; UC1.U37 v2(229.41,113.89) UC1.U38 ; v2(118.32,22.14) 118.1,21.91 UZ12.9 ; JDGFF4.A3 175.87,137.88 v2(175.48,138.27) ; UC1.W33 v2(230.98,110.64) ; JEDP1.12 100,42.38 v2(100.06,42.32) ; QT6.3 71.53,25.05 70.73,25.05 70.43,24.76 RT567.2 70.03,25.11 70.13,25.21 70.13,25.61 69.95,25.79 v2(69.95,25.96) ; UC1.AC38 v2(234.13,114.54) ; JDGFF4.A6 v2(174.07,138.3) ; v2(234.71,139.89) 234.91,139.69 PU1202.4 ; JEDP1.14 101,42.41 v2(101.06,42.36) ; UC1.P37 227.49,113.56 v2(227.8,113.88) 227.47,114.22 UC1.P38 ; v2(132.82,8.68) 132.32,8.18 PR902.2 129.81,8.18 PC902.2 ; v2(157.98,14.3) 157.62,14.65 PR804.2 ; DT12.3 12.65,57.37 v2(12.57,57.29) ; UC1.AL33 240.9,110.96 v2(241.22,111.29) 240.89,111.61 UC1.AL34 ; CE60.2 129.15,12.23 131.11,12.23 v2(131.23,12.35) ; v2(283.81,82.71) 283.95,82.85 JXDP1.13 ; v2(282.53,79.55) JXDP1.2 ; 173.6,19.9 173.6,19.04 v2(173.65,18.99) 173.99,19.34 UH1.BF49 UH1.BF48 UH1.BG48 173.6,19.9
  TOP w0.305: v2(285.81,11.17) 285.66,11.32 JKBTP1.17 ; CT307.2 31.89,38.36 v2(31.96,38.29) 32.02,38.36 CT308.2 CT306.2 ; v2(61.23,2.99) 61.05,2.81 JIO1.18 ; UC1.R29 227.74,107.83 v2(227.74,107.58) ; UC1.R29 228.36,108.18 v2(228.36,107.58) ; UC1.R29 UC1.R30 ; v2(26.77,40.24) 26.54,40.24 26.24,40.54 CT328.2 ; UC1.L30 UC1.L29 225.08,107.46 225.05,107.43 v2(225.05,107.21) ; PU1800.4 216.1,133.02 v2(216,133.11) ; v2(286.68,11.17) 286.66,11.19 JKBTP1.15 ; v2(62.6,7.34) 62.55,7.29 JIO1.11 ; v2(39.91,44.48) 39.91,45.01 39.91,46.65 UT32.2 ; v2(185.5,3.24) 185.6,3.14 JUSH1.20 ; UC1.V29 230.16,107.89 v2(230.16,107.58) ; UC1.V29 230.77,108.13 v2(230.77,107.58) ; UC1.V29 UC1.V30 ; v2(282.72,78.44) 283.3,78.44 283.46,78.6 JXDP1.62 ; JUSH1.3 177.1,2.95 v2(176.85,3.2) ; UC1.AA29 UC1.AA30 232.95,108.96 v2(233.34,109.34) ; UC1.AA29 232.58,107.94 v2(232.58,107.58) ; UC1.AA29 233.2,108.06 v2(233.2,107.58) ; v2(27.41,37.64) 27.41,37.56 26.95,37.1 26.95,36.92 CT314.2 ; v2(62.82,3.67) 62.8,3.65 62.8,3.07 62.55,2.81 JIO1.12 ; CT303.2 36.02,40.43 36.04,40.45 v2(36.55,40.45) ; CT333.2 29.41,40.18 CT317.1 ; UC1.AD29 235.6,108.02 v2(235.6,107.58) ; UC1.AD29 234.98,107.98 v2(234.98,107.58) ; UC1.AD29 UC1.AD30 235.29,108.96 v2(234.92,109.33) ; JIO1.6 64.05,2.33 64.57,2.85 v2(64.65,2.85) ; v2(31.96,39.59) 31.96,39.69 32.2,39.93 CT315.2 ; v2(315.94,42.27) 316.19,42.02 UZ10.3 ; UC1.BG37 253.36,113.56 v2(253.03,113.24) ; UC1.BG38 v2(253.03,114.54) ; CT305.2 31.17,36.99 v2(30.66,36.99) ; JIO1.24 v2(59.55,2.87) ; UC1.AV38 246.27,114.22 v2(245.94,113.89) ; JIO1.5 64.05,7.02 v2(64.35,7.33) ; UC6.4 125.99,32.81 126.18,32.61 126.19,32.61 126.35,32.46 v2(126.44,32.46) ; CT309.2 33.84,39.01 v2(33.91,38.94) ; JUSH1.21 186.1,3.12 v2(186.22,3.24) ; CT320.1 27.47,38.36 v2(27.41,38.29) ; JDIMM4.251 210.93,58.99 210.51,58.57 209.38,58.57 208.98,58.17 208.98,57.65 208.63,57.29 v2(208.41,57.29) ; v2(136.53,12.27) 136.57,12.23 CZ218.2 ; JUSH1.17 184.1,3.11 v2(184.24,3.25) ; CT331.2 28.12,39.66 v2(28.06,39.59) ; v2(60.84,7.29) 60.84,7.16 61.05,6.96 JIO1.17 ; CT316.1 v2(28.06,38.94) 27.94,39.06 CT318.1 CT311.2 ; v2(342.94,18.38) 343.02,18.3 343.51,18.3 CA10.2
  TOP w0.33: v2(25.2,35.86) 25.78,36.43 CT302.2 ; CZ199.2 277.12,86.29 277.28,86.12 CC322.2 ; CZ199.2 277.16,86.64 277.62,86.64 v2(277.85,86.87) ; CZ199.2 277.12,87.86 v2(276.83,88.15) ; v2(332,28.28) 331.71,27.99 RZ541.2 ; v2(140.32,30.52) 140.32,30.49 139.65,29.82 139.65,29.37 UE1.A13 ; 85.8,7.71 CN205.2 ; v2(114.67,30.77) 114.67,30.48 CH270.2 ; CZ93.2 314.11,42.79 314.11,42.1 v2(314.01,42) ; v2(131.93,23.25) 132.03,23.35 UE1.H4 ; CZ64.2 194.27,6.54 v2(194.25,6.52) ; UE1.C4 v2(132.73,27.25) ; v2(35.72,33.05) 35.52,33.26 CT340.2 ; v2(153.73,34.15) 153.76,34.12 RE93.2 ; CE11.2 131.71,32.57 v2(131.75,32.61)
  TOP w0.356: v2(176.78,47.52) 177.08,47.22 177.52,47.22 177.72,47.02 CC302.2 ; v2(78.18,23.75) 77.34,23.75 CV953.2 ; v2(189.98,94.06) 189.89,93.97 CZ105.2 ; CE14.2 142.05,20.53 v2(142.08,20.55) ; CV15.2 85.68,43.28 84.95,42.55 CV14.2 ; CD31.2 208.6,48.58 v2(208.8,48.39) ; CV811.2 181.85,96.11 v2(182.34,96.59) ; CV810.2 184.59,87.52 v2(184.61,87.52) ; CH40.1 163.91,17.39 v2(163.5,17.8) ; v2(101.79,38.55) 101.79,38.87 CV20.2 ; CZ101.2 193.43,86.16 193.69,86.42 v2(193.69,87.18) 193.99,87.18 CZ544.2 ; v2(189.76,97.08) 190.21,97.08 CZ106.2 ; CV814.2 107.44,39.64 107.45,39.64 v2(107.98,39.64) ; v2(56.19,37.72) 56.19,37.72 56.19,37.21 CT349.2 CT347.2 ; CV942.2 154.29,44.91 v2(154.46,45.09) ; v2(107.98,38.37) 107.8,38.55 CV815.2 ; CL15.2 195.49,135.7 v2(194.85,136.34) ; v2(77.5,31.44) 77.5,31.75 77.73,31.98 CV850.2 77.07,32.47 RV890.2 ; CV941.2 154.51,45.8 v2(154.64,45.67) ; RV857.2 59.03,33.89 58.86,33.89 v2(58.83,33.85) 58.83,33.85 58.79,33.81 RV856.2 ; CL19.2 v2(206.84,130.11) ; v2(351.84,12.85) 351.68,12.69 CN287.2 ; CE31.2 126.56,22.06 v2(126.27,22.36) ; CV816.2 107.31,36.43 v2(107.98,37.1) ; CE63.2 154.01,30.53 v2(153.84,30.7) 153.84,31.17 154.14,31.47 CE64.2 ; v2(337.1,25.85) 337.55,25.39 CA31.1 ; CZ71.2 193.48,5.59 CZ66.2 194.43,5.59 v2(194.78,5.94) ; v2(46.41,38.22) 46.43,38.24 46.46,38.24 46.52,38.18 RT568.2 47.42,38.87 RT527.2 ; v2(326.38,27.57) 326.38,26.95 CZ540.2 ; v2(172.79,49.88) 173.18,49.88 CH10.2 ; v2(37.01,8.22) 37.01,8.37 37.39,8.75 38.85,8.75 39.19,9.1 PC2103.2 ; CC324.2 268.49,107 268.94,107.45 268.94,108.68 v2(268.57,109.05) ; v2(205.12,129.82) 205.8,130.5 CL199.2 ; v2(156.37,32.04) 156.37,30.46 156.03,30.13 CE36.2 ; CE52.2 160.95,23.54 v2(161.27,23.87) ; CV855.2 55.17,33.34 CT346.2 55.16,32.7 CT344.2 55.16,32.11 v2(55.22,32.06) ; v2(51.21,28.77) 51.34,28.91 51.95,28.91 CT343.2 ; CH35.2 168.82,19.74 v2(168.84,19.72) 168.84,19.26 169.14,18.96 CH63.2 169.89,18.82 CH68.2 ; CZ100.2 v2(193.33,87.72)
  TOP w0.381: UZ6.3 117.32,11.47 v2(116.89,11.9) ; JDGFF2.A3 175.87,106.21 v2(175.81,106.27) ; QH6.3 122.13,9.8 122.45,9.48 CH340.2 ; v2(57.44,15.52) 56.53,16.43 PQ5.4 ; v2(172.19,81.14) 171.67,80.62 JDGFF1.G10 ; JDGFF1.B4 v2(175.27,88.01) ; v2(175.12,127.72) 175.27,127.57 JDGFF4.G4 ; v2(93.21,30.95) 94.17,31.92 QV44.4 ; JDGFF3.G1 177.07,111.7 v2(177.22,111.86) ; PH1103.2 253.72,136.2 v2(253.55,136.36) ; JDGFF4.H9 v2(172.27,125.21) ; CC304.2 279.11,96.99 CC336.2 279.82,97.3 v2(280.32,96.8) ; v2(339.26,16.63) 339.26,18.63 CA33.2 ; JDGFF1.B7 v2(173.47,88.01) ; JDGFF3.A10 v2(171.67,121.98) ; v2(55.27,17.91) 55.04,18.14 PQ5.1 ; v2(175.82,109.51) 175.87,109.56 JDGFF3.H3 ; CZ519.2 338.61,47.94 v2(338.56,47.98) ; JDGFF1.A3 v2(175.87,90.39) ; DA6.1 326.62,11.5 v2(326.78,11.66) ; JDGFF1.F6 v2(174.07,81.36) ; JDGFF2.G10 171.42,95.46 170.8,96.08 v2(170.8,96.19) ; v2(175.36,103.67) 175.27,103.75 JDGFF2.B4 ; UZ61.3 195.83,90.07 195.28,90.62 v2(195.28,91.82) ; JDGFF3.H6 v2(174.07,109.44) ; v2(70.1,8.32) 70.28,8.14 71.47,8.14 ; CV64.2 185.36,112.12 v2(185.05,112.42) ; CZ540.2 328.67,26.61 329.38,27.33 UZ60.3 ; v2(132.96,14.34) 132.96,13.88 133.32,13.52 CE22.2 ; JDGFF1.B10 v2(171.67,88.01) ; UT2.4 43.16,34.94 43,35.1 v2(42.54,35.1) ; JDGFF3.G4 175.27,111.84 v2(175.31,111.88) ; RT447.1 39.2,51.38 v2(39.4,51.58) ; v2(171.29,103.78) 171.67,104.16 JDGFF2.B10 ; CV858.2 65,28.36 CV856.2 ; PC126.2 66.25,21.39 v2(66.25,22.18) ; v2(54.59,24.38) 55.62,24.38 PQ6.4 ; v2(280.58,85.1) 280.56,85.12 RH635.2 280.01,84.87 280.37,84.51 CH342.2 ; JDGFF3.B10 v2(171,120.14) ; RV876.2 59.13,29.68 58.57,29.68 58.27,29.39 v2(58.19,29.39) ; CT358.2 54.15,40.67 v2(53.81,41.01) ; JDGFF2.B7 173.47,103.77 v2(173.38,103.67) ; RH637.1 169.25,39.18 v2(169.23,39.17) ; v2(48.88,32.11) 49.23,32.11 49.45,32.33 CT342.2 ; RV62.2 v2(192.37,110.1) ; JDGFF4.H3 v2(175.87,125.15) ; PR75.2 56.68,20.08 56.3,20.46 v2(56.3,20.85) ; JDGFF1.A9 v2(172.27,90.39) ; RV60.2 190.01,108.04 v2(190.01,107.56) ; v2(209.46,33.53) CD123.2 ; CT357.2 55.55,38.64 55.97,39.05 v2(55.97,39.49) ; JDGFF4.G1 177.07,127.16 v2(176.67,127.57) ; CZ200.2 278.83,79.27 v2(279.58,79.27) ; QZ17.4 v2(338.04,3.09) ; v2(184.27,138.01) 184.31,138.05 CL17.2 ; v2(189.33,99.37) 189.33,99.67 189.58,99.92 UV62.3 ; RA223.1 v2(358.81,23.72) ; CL20.2 189.6,138.46 189.22,138.08 v2(189.17,138.08) ; CT321.1 34.44,38.37 34.44,38.82 v2(34.56,38.94) 34.77,38.94 35.15,38.57 RT26.2 ; UV60.3 184.81,98.36 185.12,98.67 v2(187.47,98.67) 187.47,98.35 187.72,98.1 UV68.3 ; v2(173.65,18.99) 172.95,18.99 172.41,19.53 170.93,19.53 170.19,18.79 CH68.2 ; v2(182.99,138.01) 183.07,138.09 CL16.2 ; v2(120.28,17.16) 120,17.44 QE2.4 ; v2(188.63,49.54) 188.64,49.53 189.19,49.53 CH14.2 ; UZ34.3 278.84,82.75 277.79,81.7 v2(277.79,81.43) ; JDGFF4.F6 v2(174.07,128.5) ; v2(39.87,51.2) CT237.2 39.89,50.63 39.94,50.59 40.43,50.59 RT440.1 ; RE95.1 134.1,15.95 v2(134.1,15.51) ; UZ35.3 194.42,94.33 v2(195.08,93.68) ; JDGFF3.B1 177.07,119.66 176.69,119.28 v2(176.69,118.94) ; RV868.2 144.83,36.75 v2(144.48,36.39) 144.13,36.39 143.97,36.56 RV875.2 ; CZ56.2 123.89,22.3 v2(123.82,22.23) ; v2(156.37,32.04) 156.31,32.04 CH341.2 155.25,33.1 RH634.2 ; RT584.1 64.11,22.28 v2(63.73,21.9) ; UE4.3 159.46,20.11 v2(159.85,19.72) 159.85,19.37 UE3.3 ; v2(343.34,16.8) 343.34,16.46 CA61.2 343.94,16.33 v2(343.94,16.79) ; UC3.3 169.03,49.22 RH70.2 ; QZ17.1 v2(339.34,3.15) ; PQ6.1 58.28,22.82 58.48,22.63 PC13.2 ; v2(267.08,1.94) 267.08,2.21 264.7,4.6 264.7,7.1 264.14,7.65 264.14,8.66 263.6,9.2 PD9.1 ; CV844.2 v2(134.05,47.23) ; RV813.2 185.94,83.53 185.69,83.79 185.32,83.79 185.14,83.61 UV63.3 ; v2(37.62,47.86) 37.62,46.25 CT1.2 ; v2(152.91,50.45) 153.62,49.74 CV878.2 ; v2(173.78,127.66) 173.47,127.36 JDGFF4.G7 ; CZ507.2 294.4,53.88 v2(294.25,54.03) ; v2(196.89,8.59) 195.96,9.52 CZ73.2 194.54,9.76 CZ68.2 ; CH267.2 198.79,15.62 CH555.2 198.8,14.62 199.43,13.99 PR209.2 ; v2(82.15,53.11) 82.41,53.11 83.48,52.04 83.48,51.52 83.74,51.26 83.74,50.07 83.12,49.45 83.12,46.62 83.41,46.33 83.41,45.69 83.83,45.27 ; UE11.3 126.23,15.87 126.02,15.66 125.17,15.66 RE550.2 ; JDGFF3.H10 171.67,109.49 v2(171.67,109.49) ; v2(352.74,14.42) 351.66,15.51 CA41.2 351.09,15.51 RA220.2 ; PR1100.1 225.84,118.36 v2(226.21,118.72) ; CV809.2 186.23,102.18 v2(185.27,101.21) ; v2(47.32,23.05) PQ4.1 47.86,23.74 47.87,23.73 PR2163.1 ; JDGFF1.G1 v2(177.07,80.52) ; CA23.2 322.85,9.3 322.38,8.83 v2(321.81,8.83) 321.47,8.83 320.81,9.49 RZ537.2 ; JDGFF2.H6 v2(174.07,93.78) ; JDGFF4.G10 v2(171.67,127.64) ; v2(48.1,28.18) 48.51,27.77 CT352.2 ; CA19.2 v2(322.84,12.67) ; v2(162.05,20.29) 161.76,20.57 UE5.3 ; JDGFF3.A6 v2(174.07,121.91) ; CZ130.2 v2(329.52,33.17) ; v2(272.63,96.27) 272.63,95.74 273.09,95.28 274.6,95.28 CC303.2 ; JDGFF2.C6 v2(174.07,102.85) ; JDGFF4.F3 175.87,128.44 175.93,128.38 v2(175.93,128.24) ; CZ50.2 116.38,23.94 v2(116.48,23.84) ; v2(176.04,102.85) 175.87,102.68 JDGFF2.C3 ; v2(347.1,13.29) CA66.2 ; JDGFF3.A3 v2(175.87,121.78) ; JDGFF3.C10 171.67,118.33 v2(171.53,118.47) ; v2(71.92,27.51) 71.92,28.39 RV895.2 ; JDGFF1.F3 v2(175.87,81.32) ; v2(139.4,38.85) 139.39,38.86 CV923.2 ; UV65.3 137.07,47.23 v2(137.66,47.82) ; JDGFF1.H6 v2(174.07,78.06) ; v2(148.89,35.46) 149.17,35.74 RV896.1 RV894.2 ; RV871.2 138.81,41.07 v2(138.34,41.55) 138.66,41.88 RV872.2 ; v2(191.35,138.08) 190.95,138.48 CL21.2 ; JDGFF2.B1 179.26,104.44 179.78,103.92 179.78,102.9 179.31,102.42 v2(178.9,102.42) ; v2(139.33,18.25) 139.33,18.02 138.88,17.57 CE8.2 ; v2(168.28,42.79) 168.32,42.74 168.53,42.74 RH636.1 ; JDGFF4.H6 v2(174.07,125.12) ; CC305.2 283.45,102.25 v2(283.21,102.49) ; v2(11.48,46.5) 11.49,46.49 DT8.3 ; JDGFF1.F1 v2(177.07,81.38) ; v2(172.3,78.03) 172.27,78.07 JDGFF1.H9 ; CZ67.2 172.08,7.17 173.48,7.17 v2(174.25,7.95) ; v2(38.8,23.54) 39.09,23.84 PR2109.2 ; JDGFF2.G4 v2(175.27,96.18) ; UV61.3 v2(180.94,90.77) ; v2(54.63,32.02) 54.63,31.54 CT350.1 ; CZ69.2 v2(194.25,6.52) ; PC700.1 v2(290.64,36.63) ; JDGFF2.A9 v2(172.27,106.07) ; v2(114.53,38.37) 115.3,39.13 CV817.2 ; CZ524.2 341.9,47.2 v2(342.32,47.62) ; v2(263.95,95.65) 263.92,95.62 CC209.1 CC210.1 ; RT587.2 74.38,21.87 v2(74.38,22.34) ; JDGFF2.H9 v2(172.27,93.79) ; RV64.2 v2(193.18,107.61) ; UV69.3 184.51,93.83 184.03,93.35 v2(184.03,93.16) ; v2(174.42,106.18) 174.07,105.83 JDGFF2.A6 ; CA68.2 343.37,13.08 CA67.2 344.69,13.05 v2(344.96,13.33) ; JDGFF1.G7 v2(173.47,80.54) ; JDGFF2.F3 175.87,99.18 176.41,99.72 v2(178.36,99.72) ; CT354.2 55.61,29.54 v2(56.15,29.54) ; JDGFF1.C6 174.07,87.07 v2(174.09,87.1) ; UL2.3 196.94,131.17 197.3,130.81 v2(197.5,130.81) ; CT303.2 35.96,40.42 35.96,40.07 36.17,39.86 RT36.2 ; JDGFF3.F6 174.07,113.14 v2(173.54,112.6) ; v2(173.16,118.91) 173.16,119.41 173.47,119.72 JDGFF3.B7 ; CC318.2 169.2,31.4 v2(169.83,31.4) ; RV58.2 188.86,111.08 189.54,111.75 v2(189.65,111.75) ; RH631.2 208.96,125.05 CH346.2 208.96,125.91 v2(209.22,126.18) ; JDGFF1.G4 v2(175.27,80.48) ; v2(152.54,39.08) 152.54,38.72 152.69,38.57 CV933.2 152.69,37.11 CH344.2 152.24,36.66 RH629.2 151.47,36.66 151.13,36.31 151.13,36.13 v2(150.91,35.91) ; v2(346.46,15.07) 346.31,14.92 CA56.2 345.31,14.92 v2(345.1,15.13) ; RC325.2 261.88,101.36 261.88,101.35 261.68,101.16 v2(260.74,101.16) ; CZ541.2 v2(318.05,44.36) ; JDGFF3.A9 v2(172.27,121.94) ; CA65.2 349.25,13.67 349.03,13.89 v2(349.03,14.2) ; JDGFF2.G1 177.47,95.46 177.74,95.72 v2(177.74,96.19) ; RT554.1 26.84,38.04 27.25,37.64 v2(27.41,37.64) ; v2(33.71,45.38) 33.71,44.7 33.89,44.52 RT27.2 ; v2(344.64,15.76) 344.64,16.06 CA53.1 345.24,16.21 v2(345.24,15.76) ; JDGFF2.H3 v2(175.87,93.78) ; v2(343.96,31.42) 343.38,30.85 CA47.2 ; JDGFF1.H3 v2(175.87,77.74) ; JDGFF3.C6 174.07,118.14 174.41,118.49 174.54,118.49 174.92,118.87 v2(174.92,118.95) 174.92,119.39 175.27,119.74 JDGFF3.B4 ; JDGFF3.H9 v2(172.27,109.45) ; v2(179.51,15.01) 179.15,15.38 RH326.1 ; v2(171.03,111.39) 171.26,111.16 JDGFF3.G10 ; v2(345.65,13.31) CA55.2 ; JDGFF1.A6 v2(174.07,90.39) ; v2(153.73,34.15) 153.61,34.27 QE12.3 ; CT301.2 26.23,39.37 26.07,39.54 v2(25.44,39.54) ; JDGFF2.G7 173.47,96 173.7,96.23 v2(173.7,96.51) 173.7,96.97 174.07,97.35 JDGFF2.F6 ; JDGFF1.B1 v2(177.07,88.01) ; v2(145.98,27.13) 146.09,27.23 CE30.2 ; RT34.2 35.96,35.86 v2(36.57,35.86) ; JDGFF1.C3 v2(175.87,87.09) ; JDGFF3.G7 v2(173.47,111.89)
  TOP w0.406: PQ2106.1 39.08,16.18 39.11,16.15 v2(39.54,16.15) ; PQ2102.1 36.86,8.07 v2(37.01,8.22)
  TOP w0.432: v2(330.66,4.65) 330.66,4.69 332.53,6.56 JSPK1.7
  TOP w0.457: v2(358.31,13.99) 358.24,13.99 357.88,14.35 CA13.2 ; RZ25.2 138.85,8.68 v2(139.01,8.52) ; v2(63.73,21.9) 63.73,21.29 PC124.2 ; JSPK1.6 330.88,15.36 330.94,15.42 331.59,15.42 v2(331.63,15.39) ; CC29.2 277.57,90.2 v2(276.97,90.2) ; v2(186.12,15.21) 185.9,15.42 RH344.1 ; JIR1.7 73.05,42.39 v2(72.14,41.48) ; JUSH1.28 174.15,6.96 174.25,7.06 v2(174.25,7.95) ; QV23.4 86.17,29.97 86.63,30.43 86.96,30.43 87.47,30.94 QV23.1 ; RA228.1 358.75,14.81 v2(358.5,14.56) ; DV30.1 80.77,32.25 v2(81.31,32.79) ; QT7.3 45.99,37.83 46.38,38.22 v2(46.41,38.22) ; v2(171.52,15.4) 171.47,15.36 CH4.1 ; JSD1.6 31.01,27.6 30.58,27.17 29.94,27.17 v2(29.87,27.23) ; v2(163.3,28.2) 163.3,28.69 CC320.2 ; CT351.1 48.1,36.09 CT353.1 48.17,36.06 48.35,36.24 v2(48.35,36.67) ; PC13.2 58.79,22.64 PR42.1 60.17,22.64 v2(60.52,22.99) ; RV902.2 59.87,37.08 v2(59.87,37.72) ; CC28.2 278.84,90.13 v2(278.51,89.8)
  TOP w0.508: v2(210.53,30) 210.33,29.8 JDIMM2.262 ; DA7.1 325.8,14.76 v2(325.52,14.48) ; QZ21.3 298.7,57.98 v2(298.48,58.21) ; v2(149.53,26.18) 149.53,25.2 PQ26.3 149.96,24.77 PR64.2 ; v2(149.53,26.18) 150.37,26.18 QE17.3 ; v2(149.53,26.18) 149.49,26.23 RE541.1 ; CR225.1 33.64,22.51 32.93,23.22 v2(32.93,23.31) ; v2(331.1,21.21) 330.54,20.65 C194.2 ; CC334.2 263.72,93.84 263.47,93.59 v2(262.98,93.59) ; QV7.3 75.18,28.43 75.18,28.19 v2(74.75,27.76) ; PR209.2 199.43,13.95 199.38,13.9 v2(197.84,13.9) ; PC505.2 306.71,42.82 v2(306.73,42.84) ; CA22.2 320.17,5.68 v2(320.15,5.66) 320.93,5.66 321.69,4.9 JRTC1.4 322.55,4.7 324.57,4.7 325.17,5.31 v2(325.17,5.73) ; v2(334.91,5.26) 334.65,5.26 333.36,6.56 JSPK1.7 ; PC1318.2 242.01,122.21 v2(241.59,122.21) ; v2(129.6,40.89) 130.47,41.76 RV870.1 132.41,41.76 RV3.2 ; CA64.2 345.28,35.53 CA63.2 346.73,35.53 v2(346.99,35.27) ; v2(231.48,122.16) 231.9,122.16 PC1317.2 ; CV843.2 100.84,35.35 v2(100.37,35.83) ; RZ10.1 126.55,22.95 126.27,22.67 v2(126.27,22.36) ; JTS1.8 75.84,41.18 v2(77.62,42.97) ; v2(15.14,7.25) 15.24,7.35 JSD1.22 ; R127.2 326.23,19.88 CZ157.2 ; v2(17.79,62.23) 17.99,62.04 CT367.2 18.63,60.84 CT368.2 ; PR307.2 PC312.2 268.34,98.14 v2(268.86,98.66) ; PC405.2 v2(289.39,52.53) ; v2(316.77,8.74) 317.26,8.25 JLED1.8 ; v2(92.67,8.44) QZ20.3 92.67,6.96 RZ547.2 ; RA222.1 356.02,25.35 v2(356.02,24.71) ; PC1100.1 261.22,152.45 v2(261,152.67) ; CD35.2 201.14,55.16 201.14,55.17 CD38.2 201.14,56.35 201.13,56.37 200.21,56.37 v2(200.08,56.5) ; JSD1.13 4.74,17.04 v2(5.59,17.89) ; v2(99.57,38.1) 99.01,38.66 DV4.1 ; CC32.2 CC306.2 279.99,94.64 v2(280.35,94.28) ; RE65.2 143.98,27.75 JTAG1.2 144.15,27.34 v2(143.65,26.83) ; v2(263.72,100.31) 263.61,100.41 RC324.2 ; v2(93.04,17.91) 93.22,17.73 PC21.2 ; RV881.2 v2(63.14,26.84) ; CC300.2 266.58,108.69 v2(266.88,109) ; RT553.2 36.56,41.46 v2(36.79,41.69) ; v2(146.9,37.82) 147.12,37.6 CV936.2 ; v2(194.18,57.83) 195.42,57.83 195.88,57.37 CH45.1 195.12,56.82 v2(194.75,57.19) ; v2(169.18,46.65) 168.95,46.88 RH612.1 168.95,49.14 RH70.2 ; v2(304.88,46.26) 304.88,45.47 305.65,44.7 ; CV841.2 89.54,42.36 v2(90.29,42.36) ; v2(286.35,70.3) 286.35,70.89 CC164.2 ; v2(169.75,35.26) 169.75,35.5 169.44,35.81 RH617.2 ; v2(303.99,50.63) 303.73,50.9 JFAN1.1 ; PC903.2 135.74,7.28 v2(135.84,7.38) ; v2(327.04,3.63) 327.43,3.63 JRTC1.3 327.42,4.9 v2(327.04,4.52) ; RH365.2 196,48.52 196.17,48.68 196.17,49.79 v2(196.39,50.02) ; v2(316.68,42.27) 317.11,41.84 PWRSW1.2 ; v2(313.23,32.82) PR507.2 PC515.2 ; RC437.2 264.25,105.08 v2(263.88,105.45) 263.65,105.22 RC114.2 ; v2(105.37,39.49) 105.11,39.49 DV41.1 ; JRTC1.2 326.15,6.9 v2(326.48,6.57) ; v2(348.35,37.24) 348.35,36.86 348.66,36.55 RI71.1 ; v2(134.2,50.07) 134.1,50.17 RV839.2 ; JDIMM2.262 209.11,28.94 v2(210.48,28.94) ; JDIMM2.262 209.11,30.66 v2(210.5,30.66) ; R128.2 208.52,126.38 v2(208.83,126.69) ; PR312.1 272.37,97.01 271.97,96.61 v2(271.97,96.27) ; CV928.2 137.7,45.27 v2(137.56,45.13) ; v2(288.98,25.42) 290.62,25.42 v3(291.03,25.83) 291.78,26.58 PC706.2 ; JSD1.19 31.57,8.5 v2(31.68,8.4) ; CA12.2 353.63,14.56 v2(353.84,14.56) ; v2(320.98,42.05) 321.23,41.8 JPB1.7 ; CE29.2 134.69,33.88 134.48,33.67 v2(134.48,33.24) ; RC322.2 262.69,101.74 262.65,101.78 RC325.2 ; PC805.2 147.98,13.19 v2(147.72,12.93) ; v2(165.43,37.33) 165.47,37.29 165.47,37.04 RH401.2 ; PD10.1 260.66,8.74 v2(260.73,8.81) ; v2(90.75,42.82) 90.29,43.28 CV839.1 ; PC1310.2 245.25,122.21 v2(244.83,122.21) ; PC15.2 v2(22.71,58.15) ; CE53.2 156.68,18.47 v2(156.68,19.64) ; v2(97.73,19.71) 97.68,19.76 UV24.2 ; v2(30.57,32.88) 31.04,33.35 JSD1.21 ; PD702.2 290.98,24.6 v2(288.85,24.6) ; CH321.2 117.27,34.9 v2(117.27,34.94) ; v2(260.25,103.16) 260.57,102.85 RC441.2 ; RH74.2 183.47,51.33 v2(183.47,50.67) ; JKBTP1.22 296.97,10.29 v2(296.97,11.28) ; CZ80.2 v2(279.97,8.39) 280.8,8.39 281.34,8.93 JKBTP1.21 282.21,7.06 v2(281.87,6.72) ; v2(235.83,10.08) PC210.2 ; RC442.2 263.64,96.37 v2(263.69,96.32) ; JTS1.1 82.14,35.88 v2(82.15,35.87) ; v2(143.06,36.27) 143.04,36.29 143.04,36.9 RV884.2 ; QV23.1 87.79,31.4 88.09,31.09 88.09,30.41 88.42,30.08 RV908.2 ; v2(36.51,36.67) 36.42,36.77 36.42,36.97 36.16,37.23 RT614.2 ; RI14.1 v2(347.83,45.41) ; RV873.2 138.26,43.13 v2(138.22,43.1) ; v2(92.79,20.68) 92.79,21.46 C203.2 ; v2(74.41,48.62) 74.41,48.68 73.88,49.21 JIR1.8 ; C207.2 319.05,14.58 v2(319.35,14.58) ; CD127.2 201.49,59.33 201.18,59.63 CD128.2 201.17,59.63 200.6,59.63 v2(200.5,59.73) ; CV16.2 CZ510.2 96.56,38.42 v2(97.04,37.94) ; PC106.2 v2(96.8,1.82) ; v2(109.41,10.04) 109.41,10.62 PC113.2 ; CL18.2 204.76,130.52 v2(204.13,129.88) ; PC404.2 v2(281.14,53.65) ; RE550.2 124.94,16.05 v2(125.37,16.48) ; v2(168.21,12.76) 167.98,12.76 167.44,13.29 RH334.1 ; 305.65,44.7 JFAN1.6 306.43,45.27 v2(306.43,46.28) ; 305.65,44.7 v2(305.65,46.26) ; PR905.2 125.3,8.18 v2(124.88,7.76) ; PR808.2 157.21,11.93 157.21,11.29 PC807.2 157.36,11.14 PR801.1 v2(157.36,9.65) ; v2(238.19,122.21) 238.61,122.21 PC1315.2 ; RA52.1 339.94,23.73 337.87,23.73 v2(337.61,23.46) ; CE59.2 131.64,12.93 131.64,12.76 v2(131.23,12.35) ; v2(77.01,56.74) 76.7,56.42 JFAN2.1 ; RV50.2 v2(197.27,123.31) ; PC1316.2 235.3,122.16 v2(234.88,122.16) ; PC1108.1 v2(259.37,152.65) ; v2(292.86,35.95) 292.04,35.95 PC702.2 ; PR402.2 v2(281.19,48.56) ; PR1125.1 242.07,118.21 242.16,118.12 v2(242.69,118.12) 242.8,118.02 PR1129.2 ; CE28.2 131.57,34.08 131.55,34.08 v2(131.06,33.59) ; C190.2 322.09,23.76 v2(322.09,23.77) ; CZ81.2 v2(279.97,9.58) ; v2(61.45,21.87) 61.45,21.82 61.45,21.82 PC125.2 ; RE342.2 113.45,12.46 v2(113.45,11.89) 113.45,11.38 PR108.2 ; RC139.2 282.95,100.16 v2(282.44,100.16) ; PC308.2 v2(275.77,111.68) ; PC213.2 198.28,11.2 v2(198.04,11.45) ; C195.2 v2(200.97,126.43) ; JUSH1.27 v2(190.55,7.03) ; 71.47,8.14 73.03,8.14 73.03,8.14 73.92,8.14 73.92,8.15 PC138.2 ; CV812.2 186.75,91 RV818.2 186.79,91.56 v2(186.92,91.68) ; CN289.2 CN288.2 351.9,12.85 v2(351.84,12.85) ; v2(197.11,113.7) 196.59,113.17 RV66.2 ; v2(197.14,48.92) 197.14,48.18 RH364.2 ; RV889.2 155.49,40.14 v2(155.72,40.37) ; QH6.3 122.04,10.74 v2(122.1,10.8) ; v2(270.44,12.74) 270.23,12.53 270.23,11.59 269.76,11.11 PC25.2 ; C193.1 C192.1 v2(325.67,27.58) ; PR2108.2 34.21,15.75 33.76,15.31 v2(33.63,15.31) ; CZ102.1 278.58,86.25 v2(278.56,86.27) ; PC506.2 v2(295.7,35.24) ; RV874.2 v2(138.16,44.14) ; RV911.2 86.07,32.3 v2(86.57,32.8) ; CA24.2 v2(323.55,14.37) ; v2(165.13,43.22) 164.85,42.94 CA73.2 ; v2(212.55,113.07) RC179.2 213.22,113.05 RC178.2 ; PR1116.1 v2(260.33,152.65) ; JTS1.7 82.71,41.62 v2(82.35,41.62) ; DI3.1 v2(353.85,36) ; PD200.2 205.51,7.1 v2(205.15,7.46) 204.71,7.89 PC206.2 ; v2(32.61,42.82) 33.14,43.35 RT184.2 ; RV880.2 61.09,27.43 RV883.2 61.09,26.92 v2(61.29,26.72) ; v2(8.71,35.36) 9.22,34.85 JSD1.24 ; DI2.1 357.57,53.37 v2(357.8,53.6) ; v2(165.53,39.33) 165.53,40.16 CA76.2 165.53,40.17 165.53,41.08 CH268.1 CA74.2 ; CV955.2 116.89,39.01 v2(116.91,38.99) ; CH13.2 v2(191.98,50.61) ; v2(147.72,29.48) 148.04,29.17 CE65.2 ; v2(168.96,45.24) RH609.1 ; PC123.2 62.67,21.8 62.64,21.83 v2(62.64,21.85) ; RV902.2 59.82,36.97 59.34,36.49 RV858.2 ; RC443.2 264.15,99.62 v2(264.43,99.62) 264.85,99.62 265.36,100.13 RC438.2 ; v2(115.58,17.46) CZ58.2 CZ57.2 ; v2(119.95,37.59) 119.87,37.67 CV813.2 ; PC527.2 v2(300.94,34.38) ; PC401.2 v2(281.24,49.44) ; R129.2 330.26,16.21 JSPK1.6 ; v2(143.54,24.12) 143.11,24.12 142.8,24.43 CE40.2 ; RH435.1 v2(200.01,52.82) ; CZ523.1 v2(339.5,47.97) ; QT9.3 66.25,22.93 v2(66.25,22.18) ; JIR1.2 70.47,44.71 v2(70.21,44.98) 70.74,45.51 JIR1.3 ; PR512.2 313.65,42 v2(314.01,42) ; YH2.2 v2(192.26,51.44) ; C201.1 93.5,26.37 v2(93.79,26.65) ; CV849.1 CV840.2 92.05,40.21 v2(92.61,40.21) ; v2(101.92,4.24) 101.92,3.38 102.46,2.85 PC109.2 ; CZ72.2 v2(164.28,8.07) ; PC313.2 274.73,98.78 274.85,98.91 v2(275.31,98.91) ; PR1118.1 v2(258.48,152.64) ; RC5.1 RC6.1 RC7.1 224.72,81.77 v2(225.44,82.48) ; v2(119.92,13.12) 119.78,13.26 UT34.3 ; RZ62.2 v2(123.18,27.5) ; RV905.2 197,100.8 v2(197.04,100.77) ; CZ522.1 v2(340.39,47.97) ; RC122.2 v2(287.24,78.4) ; SW3.3 v2(325.94,35.43) ; CV14.2 84.74,42.55 83.83,43.45 83.83,45.27 ; QV23.4 85.62,29.5 v2(85.57,29.45) ; PC209.2 199.43,6.21 v2(199.93,5.72) ; PC102.2 v2(98.02,1.84) ; PC104.2 v2(94.34,1.82) ; PC533.2 308.3,32.91 v2(307.65,33.56) ; v2(100.21,1.83) 100.68,2.3 PC105.2 ; v2(197.89,122.31) 197.09,121.51 CV75.2 ; PR726.2 v2(281.73,20.43) ; RE20.2 126.74,17.54 v2(126.74,18.23) ; v2(168.29,13.56) 168.29,14.4 169.23,15.34 CH5.1 ; RV863.2 v2(142.19,36.25) ; PC403.2 v2(281.16,54.87) ; PR1167.2 v2(261.51,136.52) ; v2(200.22,125.33) C191.2 ; RH193.2 197.21,51.04 196.87,51.39 195.95,51.39 195.6,51.04 v2(195.6,50.62) ; CV858.2 65,26.85 CV857.2 65.01,26.82 64.97,26.78 64.91,26.78 64.56,26.44 v2(64.18,26.44) 64.1,26.52 RV882.2 ; v2(266.23,111.38) RC319.1 ; CH30.2 167.95,44.4 167.95,44.91 v2(167.74,45.11) 167.26,45.59 CH559.2 ; v2(263.82,97.11) 263.77,97.11 263.62,97.26 RC323.2 ; v2(276,98.23) CC308.2 RC136.2 ; RC440.2 264.07,103.32 v2(263.89,103.5) ; PC513.2 308.58,43.56 v2(308.1,43.56) ; PR729.2 v2(281.82,27.22) ; v2(179.51,15.01) 179.86,15.36 RT616.1 ; v2(295.59,44.25) PC512.2 ; RV812.2 182.37,83.61 v2(183.01,84.24) ; v2(273.69,110.98) 273.71,110.96 PC307.2 ; PR405.2 v2(280.98,44.72) ; C200.2 93.78,27.83 v2(93.78,27.39) 93.67,27.28 C202.1 ; PC101.2 v2(95.55,1.8) ; YH2.4 v2(189.14,52.54) ; SW3.1 v2(327.44,35.43) ; v2(356.81,30.42) CI3.2 ; v2(186.86,83.53) RV813.2 ; PC707.2 v2(293.04,33.77) ; PC103.2 v2(99.33,1.82)
  GND1 w0.203: 5.56,58.86 JUSBC1.10 ; JUSBC1.10 5.56,59.58 ; JUSBC1.10 5.56,60.3 ; JUSBC1.10 6.94,59.58 ; JUSBC1.10 6.94,58.86 ; JUSBC1.10 6.25,58.86 ; JUSB1.4 361.45,57.8 ; JUSB1.4 359.9,57.8 ; JUSB1.4 360.67,58.57 ; JUSB1.4 360.67,57.02 ; JUSB1.4 361.27,57.2 ; JUSB1.4 361.27,58.4 ; JUSB1.4 360.07,57.2 ; JUSB1.4 360.07,58.4 ; 0.33,58.2 JUSBC1.7 ; JUSBC1.7 3.27,58.2 ; JUSBC1.7 3.27,59.03 ; JUSBC1.7 1.8,59.86 ; JUSBC1.7 1.8,58.2 ; JUSBC1.7 3.27,59.86 ; JUSB1.11 361.85,47.9 ; JUSB1.11 360.52,48.78 ; JUSB1.11 361.85,47.02 ; JUSB1.11 359.19,47.9 ; JUSB1.11 361.85,48.78 ; JUSB1.11 359.19,47.02 ; JUSB1.11 359.19,48.78 ; JUSB1.11 360.52,47.02 ; JUSBC1.5 3.27,42 ; JUSBC1.5 3.27,42.83 ; JUSBC1.5 1.8,42 ; JUSBC1.5 1.8,43.66 ; JUSBC1.5 0.33,42 ; JUSBC1.5 3.27,43.66 ; 368.02,37.82 JUSB2.12 ; JUSB2.12 368.02,39.58 ; JUSB2.12 369.35,39.58 ; JUSB2.12 366.69,37.82 ; JUSB2.12 369.35,37.82 ; JUSB2.12 366.69,39.58 ; JUSB2.12 366.69,38.7 ; JUSB2.12 369.35,38.7 ; JUSB2.11 361.85,25.9 ; JUSB2.11 359.19,26.78 ; JUSB2.11 361.85,25.02 ; JUSB2.11 360.52,25.02 ; JUSB2.11 361.85,26.78 ; JUSB2.11 359.19,25.02 ; JUSB2.11 359.19,25.9 ; JUSB2.11 360.52,26.78 ; JUSBC1.4 8.18,67.67 ; JUSBC1.4 5.52,68.45 ; JUSBC1.4 8.18,66.89 ; JUSBC1.4 8.18,68.45 ; JUSBC1.4 5.52,67.67 ; JUSBC1.4 6.85,68.45 ; 5.53,68.45 JUSBC1.2 ; JUSBC1.2 5.53,66.44 ; JUSBC1.2 5.53,67.37 ; JUSBC1.2 6.97,68.45 ; JUSBC1.2 6.25,68.45 ; 366.69,25.02 JUSB2.10 ; JUSB2.10 368.02,25.02 ; JUSB2.10 366.69,25.9 ; JUSB2.10 366.69,26.78 ; JUSB2.10 368.02,26.78 ; JUSB2.10 369.35,26.78 ; JUSB2.10 369.35,25.02 ; JUSB2.10 369.35,25.9 ; 358.57,54.9 JUSB1.7 ; JUSB1.7 359.77,54.9 ; JUSB1.7 359.17,55.08 ; JUSB1.7 359.95,54.3 ; JUSB1.7 358.4,54.3 ; JUSB1.7 359.77,53.7 ; JUSB1.7 358.57,53.7 ; JUSB1.7 359.17,53.52 ; 341.78,3.35 JNGFF4.77 ; JNGFF4.77 342.4,2.09 ; JNGFF4.77 341.78,2.09 ; JNGFF4.77 341.78,4.61 ; JNGFF4.77 342.4,4.61 ; JUSB1.12 368.02,61.58 ; JUSB1.12 369.35,60.7 ; JUSB1.12 369.35,61.58 ; JUSB1.12 366.69,61.58 ; JUSB1.12 369.35,59.82 ; JUSB1.12 366.69,59.82 ; JUSB1.12 366.69,60.7 ; JUSB1.12 368.02,59.82 ; 5.53,43.13 JUSBC1.1 ; JUSBC1.1 5.53,42.05 ; JUSBC1.1 5.53,44.06 ; JUSBC1.1 6.25,42.05 ; JUSBC1.1 6.97,42.05 ; 359.19,60.7 JUSB1.13 ; JUSB1.13 359.19,61.58 ; JUSB1.13 361.85,60.7 ; JUSB1.13 361.85,59.82 ; JUSB1.13 360.52,61.58 ; JUSB1.13 359.19,59.82 ; JUSB1.13 360.52,59.82 ; JUSB1.13 361.85,61.58 ; 366.69,48.78 JUSB1.10 ; JUSB1.10 366.69,47.02 ; JUSB1.10 369.35,47.9 ; JUSB1.10 369.35,47.02 ; JUSB1.10 366.69,47.9 ; JUSB1.10 369.35,48.78 ; JUSB1.10 368.02,47.02 ; JUSB1.10 368.02,48.78 ; 358.57,32.9 JUSB2.7 ; JUSB2.7 358.57,31.7 ; JUSB2.7 359.17,33.08 ; JUSB2.7 358.4,32.3 ; JUSB2.7 359.77,31.7 ; JUSB2.7 359.95,32.3 ; JUSB2.7 359.77,32.9 ; JUSB2.7 359.17,31.52 ; JUSBC1.3 8.18,42.83 ; JUSBC1.3 5.52,42.06 ; JUSBC1.3 5.52,42.83 ; JUSBC1.3 6.85,42.06 ; JUSB2.13 361.85,38.7 ; JUSB2.13 361.85,37.82 ; JUSB2.13 361.85,39.58 ; JUSB2.13 359.19,39.58 ; JUSB2.13 359.19,38.7 ; JUSB2.13 360.52,39.58 ; JUSB2.13 360.52,37.82 ; JUSB2.13 359.19,37.82 ; 87.35,45.82 H15.1 ; H15.1 85.83,49.42 ; H15.1 85.83,46.38 ; H15.1 87.35,49.98 ; H15.1 88.87,46.38 ; H15.1 85.27,47.9 ; H15.1 88.87,49.42 ; H15.1 89.43,47.9 ; 5.56,50.92 JUSBC1.9 ; JUSBC1.9 6.25,51.64 ; JUSBC1.9 6.94,50.92 ; JUSBC1.9 6.94,51.64 ; JUSBC1.9 5.56,51.64 ; JUSBC1.9 5.56,50.2 ; H14.1 122.67,46.38 ; H14.1 119.63,49.42 ; H14.1 121.15,49.98 ; H14.1 119.07,47.9 ; H14.1 119.63,46.38 ; H14.1 121.15,45.82 ; H14.1 123.23,47.9 ; H14.1 122.67,49.42 ; JUSB2.4 361.45,35.8 ; JUSB2.4 360.07,35.2 ; JUSB2.4 360.67,36.57 ; JUSB2.4 360.67,35.02 ; JUSB2.4 361.27,35.2 ; JUSB2.4 361.27,36.4 ; JUSB2.4 360.07,36.4 ; JUSB2.4 359.9,35.8 ; JUSBC1.8 3.27,66.84 ; JUSBC1.8 3.27,68.5 ; JUSBC1.8 3.27,67.67 ; JUSBC1.8 1.8,66.84 ; JUSBC1.8 0.33,68.5 ; JUSBC1.8 1.8,68.5 ; 1.8,50.64 JUSBC1.6 ; JUSBC1.6 3.27,51.47 ; JUSBC1.6 3.27,52.3 ; JUSBC1.6 1.8,52.3 ; JUSBC1.6 3.27,50.64 ; JUSBC1.6 0.33,52.3 ; 364.9,2.09 JNGFF4.76 ; JNGFF4.76 365.52,4.61 ; JNGFF4.76 365.52,2.09 ; JNGFF4.76 364.9,4.61 ; JNGFF4.76 365.52,3.35 ; JLOM1.9 219.29,147.55 ; JLOM1.9 219.29,150.9 ; JLOM1.9 219.29,149.22 ; JLOM1.9 218.46,150.9 ; JLOM1.9 218.46,147.55 ; JLOM1.10 199.82,150.9 ; JLOM1.10 199.41,150.9 ; JLOM1.10 200.23,150.9
  GND1 w0.254: H3.1 273.77,91.97 ; H3.1 272.1,88.01 ; H3.1 272.1,92.59 ; H3.1 274.39,90.3 ; H3.1 273.77,88.63 ; H3.1 269.81,90.3 ; H3.1 270.43,91.97 ; H3.1 270.43,88.63 ; H17.1 327.64,42.01 ; H17.1 324.12,43.5 ; H17.1 327.64,44.99 ; H17.1 324.66,44.99 ; H17.1 328.18,43.5 ; H17.1 324.66,42.01 ; H17.1 326.15,45.53 ; H17.1 326.15,41.47 ; 3.91,4.14 H9.1 ; H9.1 3.91,1.66 ; H9.1 6.39,1.66 ; H9.1 6.83,2.9 ; H9.1 5.15,4.58 ; H9.1 5.15,1.22 ; H9.1 6.39,4.14 ; H9.1 3.47,2.9 ; 3.95,69.77 H6.1 ; H6.1 5.19,70.21 ; H6.1 3.95,73.13 ; H6.1 2.71,72.69 ; H6.1 5.19,72.69 ; H6.1 5.63,71.45 ; H6.1 2.71,70.21 ; H6.1 2.27,71.45 ; 222.41,144.96 H18.1 ; H18.1 224.89,144.96 ; H18.1 222.41,147.44 ; H18.1 223.65,144.52 ; H18.1 223.65,147.88 ; H18.1 224.89,147.44 ; H18.1 221.97,146.2 ; H18.1 225.33,146.2 ; 37.33,2.48 H4.1 ; H4.1 40.93,4 ; H4.1 37.33,5.52 ; H4.1 38.85,1.92 ; H4.1 40.37,5.52 ; H4.1 38.85,6.08 ; H4.1 40.37,2.48 ; H4.1 36.77,4 ; 70.23,2.48 H5.1 ; H5.1 69.67,4 ; H5.1 73.27,2.48 ; H5.1 73.83,4 ; H5.1 71.75,6.08 ; H5.1 71.75,1.92 ; H5.1 70.23,5.52 ; H5.1 73.27,5.52 ; H12.1 272.89,115.1 ; H12.1 270.6,112.81 ; H12.1 272.27,113.43 ; H12.1 268.93,113.43 ; H12.1 268.31,115.1 ; H12.1 268.93,116.77 ; H12.1 270.6,117.39 ; H12.1 272.27,116.77 ; 3.6,53.57 H8.1 ; H8.1 4.84,56.49 ; H8.1 1.92,55.25 ; H8.1 3.6,56.93 ; H8.1 2.36,54.01 ; H8.1 4.84,54.01 ; H8.1 5.28,55.25 ; H8.1 2.36,56.49 ; 170.42,72.4 H7.1 ; H7.1 170.86,71.16 ; H7.1 173.78,72.4 ; H7.1 173.34,71.16 ; H7.1 173.34,73.64 ; H7.1 172.1,70.72 ; H7.1 172.1,74.08 ; H7.1 170.86,73.64 ; JDG1.9 103.1,22.95 ; JDG1.9 103.1,21.98 ; JDG1.9 102.4,22.95 ; JDG1.9 101.7,22.95 ; JDG1.9 101.7,21 ; JDG1.9 102.4,21 ; JDG1.9 103.1,21 ; JDG1.9 101.7,21.98 ; 296.72,48.05 H16.1 ; H16.1 297.26,49.54 ; H16.1 298.75,46.02 ; H16.1 297.26,46.56 ; H16.1 300.78,48.05 ; H16.1 298.75,50.08 ; H16.1 300.24,49.54 ; H16.1 300.24,46.56 ; SW1.4 338.48,33.67 ; SW1.4 338.48,32.14 ; SW1.4 337.72,31.9 ; SW1.4 338.72,32.91 ; SW1.4 336.96,32.14 ; SW1.4 336.72,32.91 ; SW1.4 337.72,33.91 ; SW1.4 336.96,33.67 ; 10.41,68.86 H27.1 ; H27.1 12.89,71.34 ; H27.1 13.33,70.1 ; H27.1 12.89,68.86 ; H27.1 10.41,71.34 ; H27.1 11.65,68.42 ; H27.1 9.97,70.1 ; H27.1 11.65,71.78 ; 283.97,61.7 H10.1 ; H10.1 287.33,61.7 ; H10.1 284.41,60.46 ; H10.1 286.89,60.46 ; H10.1 285.65,60.02 ; H10.1 284.41,62.94 ; H10.1 286.89,62.94 ; H10.1 285.65,63.38 ; 201.08,89.43 H21.1 ; H21.1 200.46,91.1 ; H21.1 204.42,89.43 ; H21.1 204.42,92.77 ; H21.1 205.04,91.1 ; H21.1 202.75,88.81 ; H21.1 201.08,92.77 ; H21.1 202.75,93.39 ; 102.4,16.9 JDG1.8 ; JDG1.8 101.7,17.87 ; JDG1.8 103.1,17.87 ; JDG1.8 103.1,18.85 ; JDG1.8 103.1,16.9 ; JDG1.8 101.7,16.9 ; JDG1.8 101.7,18.85 ; JDG1.8 102.4,18.85 ; 113.1,22.95 JDG1.7 ; JDG1.7 113.8,21 ; JDG1.7 113.1,21 ; JDG1.7 114.5,22.95 ; JDG1.7 113.1,21.98 ; JDG1.7 114.5,21.98 ; JDG1.7 113.8,22.95 ; H19.1 30.14,1.41 ; H19.1 30.14,2.9 ; H19.1 27.9,1.41 ; H19.1 27.9,4.39 ; H19.1 25.66,2.9 ; H19.1 30.14,4.39 ; H19.1 25.66,1.41 ; H19.1 25.66,4.39 ; JDG1.6 114.5,17.87 ; JDG1.6 113.8,18.85 ; JDG1.6 113.1,17.87 ; JDG1.6 113.1,18.85 ; JDG1.6 113.1,16.9 ; JDG1.6 114.5,18.85 ; JDG1.6 113.8,16.9 ; JDG1.6 114.5,16.9 ; H22.1 206.92,120.27 ; H22.1 206.92,116.93 ; H22.1 207.54,118.6 ; H22.1 203.58,120.27 ; H22.1 203.58,116.93 ; H22.1 205.25,120.89 ; H22.1 202.96,118.6 ; H22.1 205.25,116.31 ; 31.27,2.9 H20.1 ; H20.1 34.19,1.66 ; H20.1 32.95,4.58 ; H20.1 32.95,1.22 ; H20.1 34.63,2.9 ; H20.1 31.71,1.66 ; H20.1 34.19,4.14 ; H20.1 31.71,4.14 ; H28.1 46.67,45.43 ; H28.1 43.07,46.95 ; H28.1 47.23,46.95 ; H28.1 45.15,49.03 ; H28.1 45.15,44.87 ; H28.1 46.67,48.47 ; H28.1 43.63,45.43 ; H28.1 43.63,48.47 ; H25.1 70.79,52.91 ; H25.1 71.23,54.15 ; H25.1 69.55,52.47 ; H25.1 70.79,55.39 ; H25.1 68.31,55.39 ; H25.1 68.31,52.91 ; H25.1 69.55,55.83 ; H25.1 67.87,54.15 ; 361.65,68.42 H26.1 ; H26.1 362.89,68.86 ; H26.1 361.65,71.78 ; H26.1 359.97,70.1 ; H26.1 362.89,71.34 ; H26.1 360.41,68.86 ; H26.1 360.41,71.34 ; H26.1 363.33,70.1 ; H1.1 370.79,70.01 ; H1.1 371.23,71.25 ; H1.1 368.31,70.01 ; H1.1 369.55,69.57 ; H1.1 368.31,72.49 ; H1.1 369.55,72.93 ; H1.1 367.87,71.25 ; H1.1 370.79,72.49 ; H11.1 170.33,3.4 ; H11.1 169.89,2.16 ; H11.1 169.89,4.64 ; H11.1 166.97,3.4 ; H11.1 168.65,5.08 ; H11.1 167.41,4.64 ; H11.1 167.41,2.16 ; H11.1 168.65,1.72 ; SW1.5 331.42,33.91 ; SW1.5 330.42,32.91 ; SW1.5 332.18,32.14 ; SW1.5 330.66,32.14 ; SW1.5 332.18,33.67 ; SW1.5 332.42,32.91 ; SW1.5 331.42,31.9 ; 332.9,1.41 H24.1 ; H24.1 331.8,1.8 ; H24.1 331.41,2.9 ; H24.1 331.8,4 ; H24.1 334,4 ; H24.1 334,1.8 ; H24.1 332.9,4.39 ; H24.1 334.39,2.9 ; H23.1 5.63,39.05 ; H23.1 5.19,40.29 ; H23.1 2.27,39.05 ; H23.1 3.95,40.73 ; H23.1 3.95,37.37 ; H23.1 5.19,37.81 ; H23.1 2.71,40.29 ; H23.1 2.71,37.81
  IN1 w0.203: JUSBC1.10 6.94,59.58 ; JUSBC1.10 5.56,59.58 ; JUSBC1.10 6.94,60.3 ; JUSBC1.10 6.25,60.3 ; JUSBC1.10 6.25,58.86 ; JUSBC1.10 5.56,60.3 ; JUSBC1.10 6.94,58.86 ; JUSBC1.10 5.56,58.86 ; 5.56,50.2 JUSBC1.9 ; JUSBC1.9 6.94,51.64 ; JUSBC1.9 5.56,50.92 ; JUSBC1.9 6.25,50.2 ; JUSBC1.9 5.56,51.64 ; JUSBC1.9 6.94,50.92 ; JUSBC1.9 6.25,51.64 ; 5.53,42.05 JUSBC1.1 ; JUSBC1.1 6.97,44.06 ; JUSBC1.1 5.53,44.06 ; JUSBC1.1 6.25,44.06 ; JUSBC1.1 6.25,42.05 ; JUSBC1.1 5.53,43.13 ; JUSBC1.1 6.97,42.05 ; 6.85,42.06 JUSBC1.3 ; JUSBC1.3 5.52,42.06 ; JUSBC1.3 5.52,42.83 ; JUSBC1.3 8.18,42.83 ; JUSBC1.3 8.18,43.61 ; JUSBC1.4 8.18,66.89 ; JUSBC1.4 5.52,67.67 ; JUSBC1.4 8.18,67.67
  GND2 w0.203: JUSBC1.10 6.94,58.86 ; JUSBC1.10 6.94,59.58 ; JUSBC1.10 6.94,60.3 ; JUSBC1.10 6.25,58.86 ; JUSBC1.10 5.56,59.58 ; JUSBC1.10 6.25,60.3 ; JUSBC1.10 5.56,60.3 ; JUSBC1.10 5.56,58.86 ; JUSB2.10 368.02,26.78 ; JUSB2.10 366.69,26.78 ; JUSB2.10 366.69,25.9 ; JUSB2.10 369.35,25.02 ; JUSB2.10 369.35,25.9 ; JUSB2.10 369.35,26.78 ; JUSB2.10 366.69,25.02 ; JUSB2.10 368.02,25.02 ; 359.19,59.82 JUSB1.13 ; JUSB1.13 360.52,61.58 ; JUSB1.13 361.85,61.58 ; JUSB1.13 359.19,61.58 ; JUSB1.13 361.85,60.7 ; JUSB1.13 359.19,60.7 ; JUSB1.13 361.85,59.82 ; JUSB1.13 360.52,59.82 ; JUSBC1.5 3.27,43.66 ; JUSBC1.5 0.33,42 ; JUSBC1.5 3.27,42 ; JUSBC1.5 3.27,42.83 ; JUSBC1.5 1.8,43.66 ; JUSBC1.5 1.8,42 ; JUSB2.13 360.52,39.58 ; JUSB2.13 361.85,39.58 ; JUSB2.13 361.85,37.82 ; JUSB2.13 359.19,38.7 ; JUSB2.13 361.85,38.7 ; JUSB2.13 359.19,37.82 ; JUSB2.13 360.52,37.82 ; JUSB2.13 359.19,39.58 ; JUSB1.12 368.02,61.58 ; JUSB1.12 366.69,59.82 ; JUSB1.12 366.69,61.58 ; JUSB1.12 369.35,60.7 ; JUSB1.12 369.35,61.58 ; JUSB1.12 368.02,59.82 ; JUSB1.12 369.35,59.82 ; JUSB1.12 366.69,60.7 ; JUSB1.11 360.52,48.78 ; JUSB1.11 360.52,47.02 ; JUSB1.11 359.19,47.9 ; JUSB1.11 359.19,48.78 ; JUSB1.11 361.85,48.78 ; JUSB1.11 359.19,47.02 ; JUSB1.11 361.85,47.9 ; JUSB1.11 361.85,47.02 ; JUSB1.7 359.77,54.9 ; JUSB1.7 359.95,54.3 ; JUSB1.7 358.4,54.3 ; JUSB1.7 358.57,54.9 ; JUSB1.7 359.17,55.08 ; JUSB1.7 359.77,53.7 ; JUSB1.7 358.57,53.7 ; JUSB1.7 359.17,53.52 ; JLOM1.9 219.29,147.55 ; JLOM1.9 219.29,149.22 ; JLOM1.9 219.29,150.9 ; JLOM1.9 218.46,150.9 ; JLOM1.9 218.46,147.55 ; 368.02,37.82 JUSB2.12 ; JUSB2.12 369.35,38.7 ; JUSB2.12 366.69,37.82 ; JUSB2.12 369.35,37.82 ; JUSB2.12 369.35,39.58 ; JUSB2.12 368.02,39.58 ; JUSB2.12 366.69,38.7 ; JUSB2.12 366.69,39.58 ; 5.53,42.05 JUSBC1.1 ; JUSBC1.1 6.97,42.05 ; JUSBC1.1 5.53,44.06 ; JUSBC1.1 6.25,42.05 ; JUSBC1.1 6.25,44.06 ; JUSBC1.1 5.53,43.13 ; JUSBC1.1 6.97,44.06 ; 360.07,36.4 JUSB2.4 ; JUSB2.4 359.9,35.8 ; JUSB2.4 360.07,35.2 ; JUSB2.4 360.67,35.02 ; JUSB2.4 360.67,36.57 ; JUSB2.4 361.45,35.8 ; JUSB2.4 361.27,36.4 ; JUSB2.4 361.27,35.2 ; JUSBC1.6 3.27,52.3 ; JUSBC1.6 3.27,51.47 ; JUSBC1.6 1.8,52.3 ; JUSBC1.6 1.8,50.64 ; JUSBC1.6 3.27,50.64 ; JUSBC1.6 0.33,52.3 ; JUSB2.11 361.85,26.78 ; JUSB2.11 359.19,25.02 ; JUSB2.11 361.85,25.9 ; JUSB2.11 359.19,25.9 ; JUSB2.11 359.19,26.78 ; JUSB2.11 360.52,25.02 ; JUSB2.11 361.85,25.02 ; JUSB2.11 360.52,26.78 ; H15.1 89.43,47.9 ; H15.1 87.35,45.82 ; H15.1 85.83,46.38 ; H15.1 88.87,46.38 ; H15.1 85.27,47.9 ; H15.1 88.87,49.42 ; H15.1 87.35,49.98 ; H15.1 85.83,49.42 ; 358.57,32.9 JUSB2.7 ; JUSB2.7 359.17,33.08 ; JUSB2.7 358.4,32.3 ; JUSB2.7 359.77,31.7 ; JUSB2.7 359.77,32.9 ; JUSB2.7 359.17,31.52 ; JUSB2.7 358.57,31.7 ; JUSB2.7 359.95,32.3 ; 359.9,57.8 JUSB1.4 ; JUSB1.4 360.07,58.4 ; JUSB1.4 360.67,58.57 ; JUSB1.4 360.67,57.02 ; JUSB1.4 361.27,58.4 ; JUSB1.4 361.27,57.2 ; JUSB1.4 360.07,57.2 ; JUSB1.4 361.45,57.8 ; H14.1 121.15,49.98 ; H14.1 122.67,49.42 ; H14.1 123.23,47.9 ; H14.1 119.63,49.42 ; H14.1 122.67,46.38 ; H14.1 119.63,46.38 ; H14.1 119.07,47.9 ; H14.1 121.15,45.82 ; 5.52,68.45 JUSBC1.4 ; JUSBC1.4 8.18,66.89 ; JUSBC1.4 8.18,67.67 ; JUSBC1.4 8.18,68.45 ; JUSBC1.4 5.52,67.67 ; JUSBC1.4 6.85,68.45 ; 0.33,58.2 JUSBC1.7 ; JUSBC1.7 1.8,59.86 ; JUSBC1.7 3.27,59.86 ; JUSBC1.7 3.27,58.2 ; JUSBC1.7 3.27,59.03 ; JUSBC1.7 1.8,58.2 ; JUSB1.10 369.35,47.9 ; JUSB1.10 368.02,48.78 ; JUSB1.10 366.69,47.9 ; JUSB1.10 369.35,48.78 ; JUSB1.10 369.35,47.02 ; JUSB1.10 366.69,48.78 ; JUSB1.10 368.02,47.02 ; JUSB1.10 366.69,47.02 ; 0.33,68.5 JUSBC1.8 ; JUSBC1.8 3.27,67.67 ; JUSBC1.8 1.8,68.5 ; JUSBC1.8 3.27,66.84 ; JUSBC1.8 1.8,66.84 ; JUSBC1.8 3.27,68.5 ; 342.4,2.09 JNGFF4.77 ; JNGFF4.77 341.78,3.35 ; JNGFF4.77 341.78,2.09 ; JNGFF4.77 342.4,4.61 ; JNGFF4.77 341.78,4.61 ; 6.25,66.44 JUSBC1.2 ; JUSBC1.2 5.53,67.37 ; JUSBC1.2 6.97,66.44 ; JUSBC1.2 5.53,68.45 ; JUSBC1.2 6.97,68.45 ; JUSBC1.2 6.25,68.45 ; JUSBC1.2 5.53,66.44 ; JNGFF4.76 365.52,2.09 ; JNGFF4.76 365.52,3.35 ; JNGFF4.76 365.52,4.61 ; JNGFF4.76 364.9,4.61 ; JNGFF4.76 364.9,2.09 ; 199.41,150.9 JLOM1.10 ; JLOM1.10 199.82,150.9 ; JLOM1.10 200.23,150.9 ; JUSBC1.3 8.18,42.83 ; JUSBC1.3 5.52,42.06 ; JUSBC1.3 8.18,43.61 ; JUSBC1.3 5.52,42.83 ; JUSBC1.3 6.85,42.06 ; 5.56,50.2 JUSBC1.9 ; JUSBC1.9 6.25,50.2 ; JUSBC1.9 5.56,51.64 ; JUSBC1.9 6.94,50.92 ; JUSBC1.9 5.56,50.92 ; JUSBC1.9 6.94,51.64 ; JUSBC1.9 6.25,51.64
  GND2 w0.254: SW1.4 338.72,32.91 ; SW1.4 337.72,33.91 ; SW1.4 338.48,33.67 ; SW1.4 336.96,33.67 ; SW1.4 336.96,32.14 ; SW1.4 337.72,31.9 ; SW1.4 336.72,32.91 ; SW1.4 338.48,32.14 ; H18.1 224.89,147.44 ; H18.1 225.33,146.2 ; H18.1 222.41,144.96 ; H18.1 221.97,146.2 ; H18.1 224.89,144.96 ; H18.1 223.65,147.88 ; H18.1 223.65,144.52 ; H18.1 222.41,147.44 ; 284.41,62.94 H10.1 ; H10.1 286.89,60.46 ; H10.1 283.97,61.7 ; H10.1 287.33,61.7 ; H10.1 285.65,60.02 ; H10.1 284.41,60.46 ; H10.1 286.89,62.94 ; H10.1 285.65,63.38 ; H23.1 5.19,40.29 ; H23.1 2.71,37.81 ; H23.1 3.95,37.37 ; H23.1 3.95,40.73 ; H23.1 2.71,40.29 ; H23.1 2.27,39.05 ; H23.1 5.19,37.81 ; H23.1 5.63,39.05 ; H8.1 5.28,55.25 ; H8.1 4.84,56.49 ; H8.1 2.36,56.49 ; H8.1 3.6,56.93 ; H8.1 3.6,53.57 ; H8.1 4.84,54.01 ; H8.1 2.36,54.01 ; H8.1 1.92,55.25 ; 298.75,46.02 H16.1 ; H16.1 300.24,46.56 ; H16.1 297.26,46.56 ; H16.1 300.78,48.05 ; H16.1 297.26,49.54 ; H16.1 298.75,50.08 ; H16.1 296.72,48.05 ; H16.1 300.24,49.54 ; H26.1 361.65,71.78 ; H26.1 359.97,70.1 ; H26.1 363.33,70.1 ; H26.1 360.41,68.86 ; H26.1 360.41,71.34 ; H26.1 362.89,71.34 ; H26.1 362.89,68.86 ; H26.1 361.65,68.42 ; 2.71,72.69 H6.1 ; H6.1 3.95,73.13 ; H6.1 2.71,70.21 ; H6.1 3.95,69.77 ; H6.1 5.19,72.69 ; H6.1 2.27,71.45 ; H6.1 5.63,71.45 ; H6.1 5.19,70.21 ; 102.4,21 JDG1.9 ; JDG1.9 101.7,21.98 ; JDG1.9 101.7,22.95 ; JDG1.9 103.1,21.98 ; JDG1.9 103.1,21 ; JDG1.9 103.1,22.95 ; JDG1.9 102.4,22.95 ; JDG1.9 101.7,21 ; H28.1 46.67,45.43 ; H28.1 47.23,46.95 ; H28.1 46.67,48.47 ; H28.1 43.63,45.43 ; H28.1 43.63,48.47 ; H28.1 45.15,49.03 ; H28.1 45.15,44.87 ; H28.1 43.07,46.95 ; H25.1 70.79,55.39 ; H25.1 71.23,54.15 ; H25.1 70.79,52.91 ; H25.1 67.87,54.15 ; H25.1 69.55,55.83 ; H25.1 68.31,52.91 ; H25.1 69.55,52.47 ; H25.1 68.31,55.39 ; 202.96,118.6 H22.1 ; H22.1 206.92,116.93 ; H22.1 207.54,118.6 ; H22.1 205.25,120.89 ; H22.1 205.25,116.31 ; H22.1 203.58,116.93 ; H22.1 203.58,120.27 ; H22.1 206.92,120.27 ; JDG1.6 114.5,16.9 ; JDG1.6 114.5,17.87 ; JDG1.6 114.5,18.85 ; JDG1.6 113.8,16.9 ; JDG1.6 113.8,18.85 ; JDG1.6 113.1,17.87 ; JDG1.6 113.1,16.9 ; JDG1.6 113.1,18.85 ; H20.1 34.63,2.9 ; H20.1 34.19,4.14 ; H20.1 31.71,1.66 ; H20.1 31.71,4.14 ; H20.1 32.95,4.58 ; H20.1 32.95,1.22 ; H20.1 34.19,1.66 ; H20.1 31.27,2.9 ; JDG1.7 113.8,22.95 ; JDG1.7 113.1,21.98 ; JDG1.7 113.1,22.95 ; JDG1.7 114.5,21.98 ; JDG1.7 113.1,21 ; JDG1.7 113.8,21 ; JDG1.7 114.5,22.95 ; H5.1 73.27,5.52 ; H5.1 69.67,4 ; H5.1 71.75,6.08 ; H5.1 70.23,2.48 ; H5.1 73.83,4 ; H5.1 71.75,1.92 ; H5.1 73.27,2.48 ; H5.1 70.23,5.52 ; H21.1 204.42,89.43 ; H21.1 200.46,91.1 ; H21.1 201.08,92.77 ; H21.1 201.08,89.43 ; H21.1 204.42,92.77 ; H21.1 202.75,93.39 ; H21.1 205.04,91.1 ; H21.1 202.75,88.81 ; 272.1,88.01 H3.1 ; H3.1 274.39,90.3 ; H3.1 269.81,90.3 ; H3.1 273.77,88.63 ; H3.1 270.43,88.63 ; H3.1 273.77,91.97 ; H3.1 272.1,92.59 ; H3.1 270.43,91.97 ; 3.91,1.66 H9.1 ; H9.1 5.15,4.58 ; H9.1 6.83,2.9 ; H9.1 6.39,1.66 ; H9.1 6.39,4.14 ; H9.1 3.47,2.9 ; H9.1 5.15,1.22 ; H9.1 3.91,4.14 ; H12.1 270.6,117.39 ; H12.1 272.27,116.77 ; H12.1 272.89,115.1 ; H12.1 268.93,116.77 ; H12.1 268.31,115.1 ; H12.1 272.27,113.43 ; H12.1 268.93,113.43 ; H12.1 270.6,112.81 ; H17.1 326.15,45.53 ; H17.1 328.18,43.5 ; H17.1 327.64,44.99 ; H17.1 327.64,42.01 ; H17.1 324.66,44.99 ; H17.1 324.66,42.01 ; H17.1 324.12,43.5 ; H17.1 326.15,41.47 ; 101.7,17.87 JDG1.8 ; JDG1.8 102.4,18.85 ; JDG1.8 101.7,16.9 ; JDG1.8 103.1,17.87 ; JDG1.8 103.1,18.85 ; JDG1.8 103.1,16.9 ; JDG1.8 102.4,16.9 ; JDG1.8 101.7,18.85 ; H27.1 12.89,68.86 ; H27.1 12.89,71.34 ; H27.1 9.97,70.1 ; H27.1 11.65,71.78 ; H27.1 13.33,70.1 ; H27.1 10.41,68.86 ; H27.1 10.41,71.34 ; H27.1 11.65,68.42 ; 170.42,72.4 H7.1 ; H7.1 173.34,71.16 ; H7.1 170.86,73.64 ; H7.1 172.1,70.72 ; H7.1 173.34,73.64 ; H7.1 173.78,72.4 ; H7.1 170.86,71.16 ; H7.1 172.1,74.08 ; H4.1 38.85,6.08 ; H4.1 40.37,5.52 ; H4.1 37.33,5.52 ; H4.1 40.37,2.48 ; H4.1 37.33,2.48 ; H4.1 38.85,1.92 ; H4.1 36.77,4 ; H4.1 40.93,4 ; 330.42,32.91 SW1.5 ; SW1.5 332.42,32.91 ; SW1.5 331.42,33.91 ; SW1.5 332.18,33.67 ; SW1.5 331.42,31.9 ; SW1.5 332.18,32.14 ; SW1.5 330.66,32.14 ; H24.1 332.9,4.39 ; H24.1 332.9,1.41 ; H24.1 331.8,4 ; H24.1 331.8,1.8 ; H24.1 334,4 ; H24.1 334,1.8 ; H24.1 334.39,2.9 ; H24.1 331.41,2.9 ; H11.1 168.65,5.08 ; H11.1 169.89,4.64 ; H11.1 167.41,2.16 ; H11.1 169.89,2.16 ; H11.1 167.41,4.64 ; H11.1 166.97,3.4 ; H11.1 168.65,1.72 ; H11.1 170.33,3.4 ; 369.55,69.57 H1.1 ; H1.1 368.31,72.49 ; H1.1 368.31,70.01 ; H1.1 367.87,71.25 ; H1.1 371.23,71.25 ; H1.1 370.79,70.01 ; H1.1 369.55,72.93 ; H1.1 370.79,72.49 ; H19.1 27.9,4.39 ; H19.1 30.14,4.39 ; H19.1 27.9,1.41 ; H19.1 30.14,2.9 ; H19.1 25.66,2.9 ; H19.1 25.66,4.39 ; H19.1 30.14,1.41 ; H19.1 25.66,1.41
  GND3 w0.203: 359.19,26.78 JUSB2.11 ; JUSB2.11 359.19,25.9 ; JUSB2.11 360.52,26.78 ; JUSB2.11 361.85,26.78 ; JUSB2.11 361.85,25.9 ; JUSB2.11 361.85,25.02 ; JUSB2.11 359.19,25.02 ; JUSB2.11 360.52,25.02 ; 368.02,37.82 JUSB2.12 ; JUSB2.12 366.69,38.7 ; JUSB2.12 366.69,39.58 ; JUSB2.12 368.02,39.58 ; JUSB2.12 369.35,38.7 ; JUSB2.12 369.35,39.58 ; JUSB2.12 369.35,37.82 ; JUSB2.12 366.69,37.82 ; JUSBC1.1 6.97,42.05 ; JUSBC1.1 6.25,42.05 ; JUSBC1.1 6.25,44.06 ; JUSBC1.1 6.97,44.06 ; JUSBC1.1 5.53,44.06 ; JUSBC1.1 5.53,42.05 ; JUSBC1.1 5.53,43.13 ; 5.56,50.2 JUSBC1.9 ; JUSBC1.9 6.94,51.64 ; JUSBC1.9 6.25,51.64 ; JUSBC1.9 6.94,50.92 ; JUSBC1.9 5.56,51.64 ; JUSBC1.9 5.56,50.92 ; JUSBC1.9 6.25,50.2 ; JUSBC1.10 6.94,58.86 ; JUSBC1.10 6.25,58.86 ; JUSBC1.10 5.56,60.3 ; JUSBC1.10 6.25,60.3 ; JUSBC1.10 6.94,60.3 ; JUSBC1.10 6.94,59.58 ; JUSBC1.10 5.56,59.58 ; JUSBC1.10 5.56,58.86 ; JUSB1.10 369.35,47.9 ; JUSB1.10 366.69,47.02 ; JUSB1.10 369.35,47.02 ; JUSB1.10 366.69,47.9 ; JUSB1.10 368.02,48.78 ; JUSB1.10 369.35,48.78 ; JUSB1.10 366.69,48.78 ; JUSB1.10 368.02,47.02 ; JUSB1.11 360.52,48.78 ; JUSB1.11 361.85,47.02 ; JUSB1.11 361.85,47.9 ; JUSB1.11 359.19,47.02 ; JUSB1.11 359.19,48.78 ; JUSB1.11 360.52,47.02 ; JUSB1.11 361.85,48.78 ; JUSB1.11 359.19,47.9 ; JUSBC1.4 8.18,68.45 ; JUSBC1.4 8.18,66.89 ; JUSBC1.4 6.85,68.45 ; JUSBC1.4 8.18,67.67 ; JUSBC1.4 5.52,68.45 ; JUSBC1.4 5.52,67.67 ; JUSB2.10 369.35,25.9 ; JUSB2.10 368.02,26.78 ; JUSB2.10 369.35,26.78 ; JUSB2.10 366.69,26.78 ; JUSB2.10 366.69,25.9 ; JUSB2.10 368.02,25.02 ; JUSB2.10 366.69,25.02 ; JUSB2.10 369.35,25.02 ; JUSBC1.2 6.97,68.45 ; JUSBC1.2 6.25,68.45 ; JUSBC1.2 6.25,66.44 ; JUSBC1.2 5.53,66.44 ; JUSBC1.2 5.53,68.45 ; JUSBC1.2 6.97,66.44 ; JUSBC1.2 5.53,67.37 ; JUSB2.4 361.27,36.4 ; JUSB2.4 359.9,35.8 ; JUSB2.4 361.45,35.8 ; JUSB2.4 361.27,35.2 ; JUSB2.4 360.67,35.02 ; JUSB2.4 360.07,36.4 ; JUSB2.4 360.07,35.2 ; JUSB2.4 360.67,36.57 ; 341.78,3.35 JNGFF4.77 ; JNGFF4.77 341.78,4.61 ; JNGFF4.77 341.78,2.09 ; JNGFF4.77 342.4,2.09 ; JNGFF4.77 342.4,4.61 ; JUSB2.13 361.85,39.58 ; JUSB2.13 359.19,38.7 ; JUSB2.13 359.19,37.82 ; JUSB2.13 361.85,38.7 ; JUSB2.13 361.85,37.82 ; JUSB2.13 360.52,39.58 ; JUSB2.13 359.19,39.58 ; JUSB2.13 360.52,37.82 ; JUSB1.13 361.85,61.58 ; JUSB1.13 361.85,59.82 ; JUSB1.13 359.19,60.7 ; JUSB1.13 361.85,60.7 ; JUSB1.13 360.52,59.82 ; JUSB1.13 359.19,59.82 ; JUSB1.13 360.52,61.58 ; JUSB1.13 359.19,61.58 ; 364.9,2.09 JNGFF4.76 ; JNGFF4.76 365.52,4.61 ; JNGFF4.76 365.52,3.35 ; JNGFF4.76 364.9,4.61 ; JNGFF4.76 365.52,2.09 ; JUSB1.7 359.77,53.7 ; JUSB1.7 359.77,54.9 ; JUSB1.7 358.57,53.7 ; JUSB1.7 359.95,54.3 ; JUSB1.7 358.4,54.3 ; JUSB1.7 358.57,54.9 ; JUSB1.7 359.17,55.08 ; JUSB1.7 359.17,53.52 ; 1.8,58.2 JUSBC1.7 ; JUSBC1.7 1.8,59.86 ; JUSBC1.7 0.33,58.2 ; JUSBC1.7 3.27,59.03 ; JUSBC1.7 3.27,59.86 ; JUSBC1.7 3.27,58.2 ; JUSBC1.3 8.18,42.83 ; JUSBC1.3 6.85,42.06 ; JUSBC1.3 5.52,42.06 ; JUSBC1.3 8.18,43.61 ; JUSBC1.3 5.52,42.83 ; H14.1 122.67,49.42 ; H14.1 121.15,49.98 ; H14.1 122.67,46.38 ; H14.1 119.63,46.38 ; H14.1 119.63,49.42 ; H14.1 123.23,47.9 ; H14.1 121.15,45.82 ; H14.1 119.07,47.9 ; 366.69,61.58 JUSB1.12 ; JUSB1.12 366.69,59.82 ; JUSB1.12 369.35,59.82 ; JUSB1.12 369.35,61.58 ; JUSB1.12 366.69,60.7 ; JUSB1.12 368.02,59.82 ; JUSB1.12 369.35,60.7 ; JUSB1.12 368.02,61.58 ; JUSBC1.5 3.27,43.66 ; JUSBC1.5 0.33,42 ; JUSBC1.5 1.8,43.66 ; JUSBC1.5 3.27,42 ; JUSBC1.5 3.27,42.83 ; JUSBC1.5 1.8,42 ; 360.07,57.2 JUSB1.4 ; JUSB1.4 360.67,57.02 ; JUSB1.4 361.27,58.4 ; JUSB1.4 360.67,58.57 ; JUSB1.4 360.07,58.4 ; JUSB1.4 361.45,57.8 ; JUSB1.4 361.27,57.2 ; JUSB1.4 359.9,57.8 ; JUSBC1.8 3.27,68.5 ; JUSBC1.8 3.27,67.67 ; JUSBC1.8 3.27,66.84 ; JUSBC1.8 1.8,68.5 ; JUSBC1.8 1.8,66.84 ; JUSBC1.8 0.33,68.5 ; 359.17,31.52 JUSB2.7 ; JUSB2.7 358.4,32.3 ; JUSB2.7 359.17,33.08 ; JUSB2.7 358.57,32.9 ; JUSB2.7 359.77,32.9 ; JUSB2.7 358.57,31.7 ; JUSB2.7 359.95,32.3 ; JUSB2.7 359.77,31.7 ; H15.1 89.43,47.9 ; H15.1 85.83,49.42 ; H15.1 87.35,49.98 ; H15.1 85.83,46.38 ; H15.1 88.87,46.38 ; H15.1 85.27,47.9 ; H15.1 87.35,45.82 ; H15.1 88.87,49.42 ; JUSBC1.6 3.27,51.47 ; JUSBC1.6 0.33,52.3 ; JUSBC1.6 1.8,52.3 ; JUSBC1.6 3.27,50.64 ; JUSBC1.6 3.27,52.3 ; JUSBC1.6 1.8,50.64 ; JLOM1.9 218.46,150.9 ; JLOM1.9 219.29,149.22 ; JLOM1.9 218.46,147.55 ; JLOM1.9 219.29,147.55 ; JLOM1.9 219.29,150.9 ; JLOM1.10 199.82,150.9 ; JLOM1.10 199.41,150.9 ; JLOM1.10 200.23,150.9
  GND3 w0.254: H28.1 46.67,48.47 ; H28.1 45.15,49.03 ; H28.1 43.63,48.47 ; H28.1 45.15,44.87 ; H28.1 46.67,45.43 ; H28.1 43.07,46.95 ; H28.1 47.23,46.95 ; H28.1 43.63,45.43 ; SW1.5 331.42,33.91 ; SW1.5 331.42,31.9 ; SW1.5 330.42,32.91 ; SW1.5 332.18,33.67 ; SW1.5 330.66,32.14 ; SW1.5 332.42,32.91 ; SW1.5 332.18,32.14 ; 113.8,16.9 JDG1.6 ; JDG1.6 113.1,18.85 ; JDG1.6 113.1,17.87 ; JDG1.6 113.1,16.9 ; JDG1.6 114.5,18.85 ; JDG1.6 114.5,17.87 ; JDG1.6 113.8,18.85 ; JDG1.6 114.5,16.9 ; 11.65,68.42 H27.1 ; H27.1 12.89,68.86 ; H27.1 13.33,70.1 ; H27.1 10.41,68.86 ; H27.1 11.65,71.78 ; H27.1 10.41,71.34 ; H27.1 12.89,71.34 ; H27.1 9.97,70.1 ; H23.1 3.95,40.73 ; H23.1 2.71,40.29 ; H23.1 5.63,39.05 ; H23.1 5.19,40.29 ; H23.1 2.71,37.81 ; H23.1 5.19,37.81 ; H23.1 3.95,37.37 ; H23.1 2.27,39.05 ; H17.1 328.18,43.5 ; H17.1 326.15,41.47 ; H17.1 326.15,45.53 ; H17.1 324.66,44.99 ; H17.1 327.64,42.01 ; H17.1 324.66,42.01 ; H17.1 327.64,44.99 ; H17.1 324.12,43.5 ; H26.1 362.89,71.34 ; H26.1 359.97,70.1 ; H26.1 360.41,68.86 ; H26.1 361.65,68.42 ; H26.1 362.89,68.86 ; H26.1 360.41,71.34 ; H26.1 361.65,71.78 ; H26.1 363.33,70.1 ; 68.31,52.91 H25.1 ; H25.1 70.79,52.91 ; H25.1 71.23,54.15 ; H25.1 69.55,55.83 ; H25.1 69.55,52.47 ; H25.1 70.79,55.39 ; H25.1 68.31,55.39 ; H25.1 67.87,54.15 ; JDG1.8 103.1,16.9 ; JDG1.8 103.1,18.85 ; JDG1.8 102.4,16.9 ; JDG1.8 101.7,17.87 ; JDG1.8 101.7,18.85 ; JDG1.8 102.4,18.85 ; JDG1.8 101.7,16.9 ; JDG1.8 103.1,17.87 ; SW1.4 338.48,33.67 ; SW1.4 336.96,32.14 ; SW1.4 338.72,32.91 ; SW1.4 338.48,32.14 ; SW1.4 337.72,33.91 ; SW1.4 336.72,32.91 ; SW1.4 336.96,33.67 ; SW1.4 337.72,31.9 ; H3.1 272.1,92.59 ; H3.1 274.39,90.3 ; H3.1 270.43,88.63 ; H3.1 269.81,90.3 ; H3.1 270.43,91.97 ; H3.1 272.1,88.01 ; H3.1 273.77,88.63 ; H3.1 273.77,91.97 ; JDG1.9 103.1,21.98 ; JDG1.9 101.7,21.98 ; JDG1.9 101.7,21 ; JDG1.9 102.4,21 ; JDG1.9 101.7,22.95 ; JDG1.9 103.1,21 ; JDG1.9 102.4,22.95 ; JDG1.9 103.1,22.95 ; H9.1 6.83,2.9 ; H9.1 3.47,2.9 ; H9.1 6.39,4.14 ; H9.1 6.39,1.66 ; H9.1 5.15,1.22 ; H9.1 3.91,1.66 ; H9.1 5.15,4.58 ; H9.1 3.91,4.14 ; H7.1 173.34,71.16 ; H7.1 172.1,70.72 ; H7.1 172.1,74.08 ; H7.1 173.78,72.4 ; H7.1 170.42,72.4 ; H7.1 170.86,71.16 ; H7.1 170.86,73.64 ; H7.1 173.34,73.64 ; 368.31,70.01 H1.1 ; H1.1 369.55,69.57 ; H1.1 370.79,72.49 ; H1.1 367.87,71.25 ; H1.1 371.23,71.25 ; H1.1 368.31,72.49 ; H1.1 369.55,72.93 ; H1.1 370.79,70.01 ; 201.08,92.77 H21.1 ; H21.1 204.42,89.43 ; H21.1 200.46,91.1 ; H21.1 201.08,89.43 ; H21.1 202.75,93.39 ; H21.1 205.04,91.1 ; H21.1 204.42,92.77 ; H21.1 202.75,88.81 ; H24.1 334,1.8 ; H24.1 331.8,4 ; H24.1 331.41,2.9 ; H24.1 331.8,1.8 ; H24.1 332.9,4.39 ; H24.1 334.39,2.9 ; H24.1 332.9,1.41 ; H24.1 334,4 ; 296.72,48.05 H16.1 ; H16.1 300.24,46.56 ; H16.1 298.75,46.02 ; H16.1 300.24,49.54 ; H16.1 298.75,50.08 ; H16.1 297.26,46.56 ; H16.1 300.78,48.05 ; H16.1 297.26,49.54 ; 270.6,112.81 H12.1 ; H12.1 272.27,116.77 ; H12.1 272.27,113.43 ; H12.1 268.31,115.1 ; H12.1 268.93,113.43 ; H12.1 268.93,116.77 ; H12.1 272.89,115.1 ; H12.1 270.6,117.39 ; H11.1 168.65,5.08 ; H11.1 167.41,2.16 ; H11.1 170.33,3.4 ; H11.1 168.65,1.72 ; H11.1 167.41,4.64 ; H11.1 166.97,3.4 ; H11.1 169.89,2.16 ; H11.1 169.89,4.64 ; 70.23,2.48 H5.1 ; H5.1 70.23,5.52 ; H5.1 73.27,5.52 ; H5.1 71.75,1.92 ; H5.1 73.27,2.48 ; H5.1 71.75,6.08 ; H5.1 73.83,4 ; H5.1 69.67,4 ; H19.1 30.14,1.41 ; H19.1 30.14,4.39 ; H19.1 25.66,4.39 ; H19.1 25.66,2.9 ; H19.1 30.14,2.9 ; H19.1 27.9,4.39 ; H19.1 25.66,1.41 ; H19.1 27.9,1.41 ; 3.6,53.57 H8.1 ; H8.1 1.92,55.25 ; H8.1 4.84,54.01 ; H8.1 5.28,55.25 ; H8.1 2.36,56.49 ; H8.1 3.6,56.93 ; H8.1 2.36,54.01 ; H8.1 4.84,56.49 ; 283.97,61.7 H10.1 ; H10.1 285.65,60.02 ; H10.1 284.41,62.94 ; H10.1 287.33,61.7 ; H10.1 285.65,63.38 ; H10.1 284.41,60.46 ; H10.1 286.89,60.46 ; H10.1 286.89,62.94 ; H4.1 40.37,5.52 ; H4.1 38.85,1.92 ; H4.1 40.37,2.48 ; H4.1 38.85,6.08 ; H4.1 36.77,4 ; H4.1 37.33,2.48 ; H4.1 37.33,5.52 ; H4.1 40.93,4 ; 222.41,144.96 H18.1 ; H18.1 222.41,147.44 ; H18.1 223.65,147.88 ; H18.1 225.33,146.2 ; H18.1 223.65,144.52 ; H18.1 224.89,144.96 ; H18.1 224.89,147.44 ; H18.1 221.97,146.2 ; JDG1.7 113.8,22.95 ; JDG1.7 114.5,22.95 ; JDG1.7 113.1,22.95 ; JDG1.7 113.8,21 ; JDG1.7 113.1,21 ; JDG1.7 113.1,21.98 ; JDG1.7 114.5,21.98 ; 2.71,72.69 H6.1 ; H6.1 5.63,71.45 ; H6.1 2.27,71.45 ; H6.1 3.95,69.77 ; H6.1 2.71,70.21 ; H6.1 5.19,72.69 ; H6.1 3.95,73.13 ; H6.1 5.19,70.21 ; 31.27,2.9 H20.1 ; H20.1 32.95,4.58 ; H20.1 31.71,1.66 ; H20.1 32.95,1.22 ; H20.1 34.19,1.66 ; H20.1 34.19,4.14 ; H20.1 31.71,4.14 ; H20.1 34.63,2.9 ; H22.1 205.25,120.89 ; H22.1 205.25,116.31 ; H22.1 202.96,118.6 ; H22.1 206.92,120.27 ; H22.1 207.54,118.6 ; H22.1 206.92,116.93 ; H22.1 203.58,116.93 ; H22.1 203.58,120.27
  VCC w0.203: JUSBC1.7 1.8,59.86 ; JUSBC1.7 3.27,58.2 ; JUSBC1.7 0.33,58.2 ; JUSBC1.7 3.27,59.86 ; JUSBC1.7 3.27,59.03 ; JUSBC1.7 1.8,58.2 ; JUSBC1.4 8.18,66.89 ; JUSBC1.4 5.52,67.67 ; JUSBC1.4 5.52,68.45 ; JUSBC1.4 8.18,67.67 ; JUSBC1.4 6.85,68.45 ; JUSBC1.4 8.18,68.45 ; 0.33,42 JUSBC1.5 ; JUSBC1.5 1.8,42 ; JUSBC1.5 1.8,43.66 ; JUSBC1.5 3.27,42.83 ; JUSBC1.5 3.27,42 ; JUSBC1.2 6.25,68.45 ; JUSBC1.2 6.97,66.44 ; JUSBC1.2 6.97,68.45 ; JUSBC1.2 5.53,67.37 ; JUSBC1.2 6.25,66.44 ; JUSBC1.2 5.53,68.45 ; JUSBC1.2 5.53,66.44 ; JUSBC1.8 3.27,67.67 ; JUSBC1.8 3.27,68.5 ; JUSBC1.8 0.33,68.5 ; JUSBC1.8 3.27,66.84 ; JUSBC1.8 1.8,66.84 ; JUSBC1.8 1.8,68.5 ; 0.33,52.3 JUSBC1.6 ; JUSBC1.6 1.8,50.64 ; JUSBC1.6 3.27,50.64 ; JUSBC1.6 3.27,52.3 ; JUSBC1.6 3.27,51.47 ; JUSBC1.6 1.8,52.3 ; JUSBC1.9 6.94,51.64 ; JUSBC1.9 5.56,50.2 ; JUSBC1.9 5.56,50.92 ; JUSBC1.9 6.25,51.64 ; JUSBC1.9 6.25,50.2 ; JUSBC1.9 5.56,51.64 ; JUSBC1.9 6.94,50.92 ; 6.25,58.86 JUSBC1.10 ; JUSBC1.10 5.56,58.86 ; JUSBC1.10 6.94,58.86 ; JUSBC1.10 5.56,59.58 ; JUSBC1.10 5.56,60.3 ; JNGFF4.76 365.52,2.09 ; JNGFF4.76 365.52,4.61 ; JNGFF4.76 365.52,3.35 ; JNGFF4.76 364.9,2.09 ; JNGFF4.76 364.9,4.61 ; JLOM1.10 199.82,150.9 ; JLOM1.10 199.41,150.9 ; JLOM1.10 200.23,150.9
  VCC w0.254: 25.66,2.9 H19.1 ; H19.1 25.66,1.41 ; H19.1 25.66,4.39 ; H19.1 30.14,2.9 ; H19.1 27.9,1.41 ; H19.1 30.14,4.39 ; H19.1 30.14,1.41 ; H19.1 27.9,4.39 ; 1.92,55.25 H8.1 ; H8.1 3.6,56.93 ; H8.1 4.84,54.01 ; H8.1 2.36,56.49 ; H8.1 5.28,55.25 ; H8.1 3.6,53.57 ; H8.1 2.36,54.01 ; H8.1 4.84,56.49 ; 360.41,68.86 H26.1 ; H26.1 361.65,68.42 ; H26.1 359.97,70.1 ; H26.1 361.65,71.78 ; H26.1 362.89,71.34 ; H26.1 360.41,71.34 ; H26.1 362.89,68.86 ; H26.1 363.33,70.1 ; 2.71,70.21 H6.1 ; H6.1 2.27,71.45 ; H6.1 5.19,70.21 ; H6.1 3.95,73.13 ; H6.1 2.71,72.69 ; H6.1 5.19,72.69 ; H6.1 5.63,71.45 ; H6.1 3.95,69.77 ; H20.1 32.95,4.58 ; H20.1 31.27,2.9 ; H20.1 32.95,1.22 ; H20.1 34.19,1.66 ; H20.1 34.19,4.14 ; H20.1 34.63,2.9 ; H20.1 31.71,1.66 ; H20.1 31.71,4.14 ; H12.1 272.27,116.77 ; H12.1 270.6,112.81 ; H12.1 268.31,115.1 ; H12.1 272.89,115.1 ; H12.1 268.93,116.77 ; H12.1 270.6,117.39 ; H12.1 272.27,113.43 ; H12.1 268.93,113.43 ; H9.1 5.15,4.58 ; H9.1 3.47,2.9 ; H9.1 6.39,4.14 ; H9.1 3.91,1.66 ; H9.1 6.39,1.66 ; H9.1 5.15,1.22 ; H9.1 3.91,4.14 ; H9.1 6.83,2.9 ; 222.41,147.44 H18.1 ; H18.1 222.41,144.96 ; H18.1 223.65,147.88 ; H18.1 224.89,147.44 ; H18.1 221.97,146.2 ; H18.1 225.33,146.2 ; 9.97,70.1 H27.1 ; H27.1 12.89,71.34 ; H27.1 10.41,71.34 ; H27.1 12.89,68.86 ; H27.1 13.33,70.1 ; H27.1 10.41,68.86 ; H27.1 11.65,68.42 ; H27.1 11.65,71.78 ; H23.1 3.95,40.73 ; H23.1 2.71,40.29 ; H23.1 3.95,37.37 ; H23.1 5.19,40.29 ; H23.1 2.71,37.81 ; H23.1 2.27,39.05 ; H23.1 5.63,39.05 ; H23.1 5.19,37.81 ; H28.1 46.67,45.43 ; H28.1 47.23,46.95 ; H28.1 45.15,49.03 ; H28.1 43.63,48.47 ; H28.1 43.07,46.95 ; H28.1 43.63,45.43 ; H28.1 45.15,44.87 ; H28.1 46.67,48.47 ; 368.31,70.01 H1.1 ; H1.1 368.31,72.49 ; H1.1 367.87,71.25 ; H1.1 370.79,70.01 ; H1.1 369.55,69.57 ; H1.1 371.23,71.25 ; H1.1 370.79,72.49 ; H1.1 369.55,72.93
  GND4 w0.203: 0.33,58.2 JUSBC1.7 ; JUSBC1.7 1.8,59.86 ; JUSBC1.7 1.8,58.2 ; JUSBC1.7 3.27,59.86 ; JUSBC1.7 3.27,58.2 ; JUSBC1.7 3.27,59.03 ; 366.69,25.9 JUSB2.10 ; JUSB2.10 369.35,25.9 ; JUSB2.10 366.69,26.78 ; JUSB2.10 369.35,25.02 ; JUSB2.10 369.35,26.78 ; JUSB2.10 368.02,25.02 ; JUSB2.10 368.02,26.78 ; JUSB2.10 366.69,25.02 ; 359.19,48.78 JUSB1.11 ; JUSB1.11 361.85,47.9 ; JUSB1.11 360.52,48.78 ; JUSB1.11 360.52,47.02 ; JUSB1.11 361.85,48.78 ; JUSB1.11 361.85,47.02 ; JUSB1.11 359.19,47.9 ; JUSB1.11 359.19,47.02 ; 85.27,47.9 H15.1 ; H15.1 87.35,45.82 ; H15.1 88.87,49.42 ; H15.1 89.43,47.9 ; H15.1 88.87,46.38 ; H15.1 85.83,49.42 ; H15.1 85.83,46.38 ; H15.1 87.35,49.98 ; JUSB1.7 359.77,54.9 ; JUSB1.7 359.95,54.3 ; JUSB1.7 358.4,54.3 ; JUSB1.7 358.57,54.9 ; JUSB1.7 359.77,53.7 ; JUSB1.7 359.17,55.08 ; JUSB1.7 358.57,53.7 ; JUSB1.7 359.17,53.52 ; JUSBC1.1 6.97,42.05 ; JUSBC1.1 6.25,42.05 ; JUSBC1.1 6.97,44.06 ; JUSBC1.1 5.53,44.06 ; JUSBC1.1 5.53,43.13 ; JUSBC1.1 5.53,42.05 ; JUSBC1.1 6.25,44.06 ; JLOM1.9 218.46,150.9 ; JLOM1.9 219.29,150.9 ; JLOM1.9 219.29,149.22 ; JLOM1.9 219.29,147.55 ; JLOM1.9 218.46,147.55 ; JUSB1.4 361.27,57.2 ; JUSB1.4 361.27,58.4 ; JUSB1.4 360.67,57.02 ; JUSB1.4 360.07,57.2 ; JUSB1.4 360.67,58.57 ; JUSB1.4 361.45,57.8 ; JUSB1.4 360.07,58.4 ; JUSB1.4 359.9,57.8 ; H14.1 122.67,49.42 ; H14.1 121.15,49.98 ; H14.1 119.63,49.42 ; H14.1 123.23,47.9 ; H14.1 121.15,45.82 ; H14.1 119.63,46.38 ; H14.1 119.07,47.9 ; H14.1 122.67,46.38 ; JUSBC1.6 1.8,52.3 ; JUSBC1.6 1.8,50.64 ; JUSBC1.6 0.33,52.3 ; JUSBC1.6 3.27,51.47 ; JUSBC1.6 3.27,50.64 ; JUSBC1.6 3.27,52.3 ; 5.52,68.45 JUSBC1.4 ; JUSBC1.4 5.52,67.67 ; JUSBC1.4 8.18,66.89 ; JUSBC1.4 8.18,68.45 ; JUSBC1.4 8.18,67.67 ; JUSBC1.4 6.85,68.45 ; JNGFF4.76 365.52,4.61 ; JNGFF4.76 364.9,2.09 ; JNGFF4.76 365.52,3.35 ; JNGFF4.76 364.9,4.61 ; JNGFF4.76 365.52,2.09 ; JUSB2.11 361.85,25.02 ; JUSB2.11 361.85,26.78 ; JUSB2.11 360.52,25.02 ; JUSB2.11 359.19,25.9 ; JUSB2.11 359.19,25.02 ; JUSB2.11 361.85,25.9 ; JUSB2.11 360.52,26.78 ; JUSB2.11 359.19,26.78 ; JUSB2.4 360.67,36.57 ; JUSB2.4 361.27,36.4 ; JUSB2.4 361.45,35.8 ; JUSB2.4 361.27,35.2 ; JUSB2.4 360.07,36.4 ; JUSB2.4 360.07,35.2 ; JUSB2.4 360.67,35.02 ; JUSB2.4 359.9,35.8 ; JUSBC1.5 3.27,42.83 ; JUSBC1.5 1.8,43.66 ; JUSBC1.5 3.27,43.66 ; JUSBC1.5 3.27,42 ; JUSBC1.5 0.33,42 ; JUSBC1.5 1.8,42 ; JUSBC1.2 6.97,68.45 ; JUSBC1.2 6.97,66.44 ; JUSBC1.2 6.25,68.45 ; JUSBC1.2 5.53,68.45 ; JUSBC1.2 5.53,67.37 ; JUSBC1.2 6.25,66.44 ; JUSBC1.2 5.53,66.44 ; 359.19,60.7 JUSB1.13 ; JUSB1.13 361.85,61.58 ; JUSB1.13 360.52,59.82 ; JUSB1.13 359.19,61.58 ; JUSB1.13 359.19,59.82 ; JUSB1.13 361.85,59.82 ; JUSB1.13 361.85,60.7 ; JUSB1.13 360.52,61.58 ; JUSB1.10 369.35,47.9 ; JUSB1.10 369.35,47.02 ; JUSB1.10 368.02,48.78 ; JUSB1.10 368.02,47.02 ; JUSB1.10 366.69,47.9 ; JUSB1.10 366.69,48.78 ; JUSB1.10 366.69,47.02 ; JUSB1.10 369.35,48.78 ; 359.19,38.7 JUSB2.13 ; JUSB2.13 361.85,39.58 ; JUSB2.13 361.85,38.7 ; JUSB2.13 360.52,39.58 ; JUSB2.13 361.85,37.82 ; JUSB2.13 359.19,39.58 ; JUSB2.13 359.19,37.82 ; JUSB2.13 360.52,37.82 ; 358.57,31.7 JUSB2.7 ; JUSB2.7 359.17,33.08 ; JUSB2.7 359.95,32.3 ; JUSB2.7 358.57,32.9 ; JUSB2.7 359.77,32.9 ; JUSB2.7 359.77,31.7 ; JUSB2.7 358.4,32.3 ; JUSB2.7 359.17,31.52 ; 366.69,38.7 JUSB2.12 ; JUSB2.12 369.35,38.7 ; JUSB2.12 366.69,37.82 ; JUSB2.12 369.35,39.58 ; JUSB2.12 366.69,39.58 ; JUSB2.12 369.35,37.82 ; JUSB2.12 368.02,37.82 ; JUSB2.12 368.02,39.58 ; 6.85,42.06 JUSBC1.3 ; JUSBC1.3 5.52,42.83 ; JUSBC1.3 8.18,42.83 ; JUSBC1.3 5.52,42.06 ; JUSBC1.3 8.18,43.61 ; 366.69,60.7 JUSB1.12 ; JUSB1.12 369.35,59.82 ; JUSB1.12 368.02,59.82 ; JUSB1.12 366.69,59.82 ; JUSB1.12 369.35,61.58 ; JUSB1.12 368.02,61.58 ; JUSB1.12 366.69,61.58 ; JUSB1.12 369.35,60.7 ; JUSBC1.9 6.94,51.64 ; JUSBC1.9 5.56,50.92 ; JUSBC1.9 6.25,50.2 ; JUSBC1.9 5.56,50.2 ; JUSBC1.9 6.94,50.92 ; JUSBC1.9 5.56,51.64 ; JUSBC1.9 6.25,51.64 ; JUSBC1.10 6.94,60.3 ; JUSBC1.10 6.94,59.58 ; JUSBC1.10 5.56,58.86 ; JUSBC1.10 6.94,58.86 ; JUSBC1.10 5.56,59.58 ; JUSBC1.10 5.56,60.3 ; JUSBC1.10 6.25,60.3 ; JUSBC1.10 6.25,58.86 ; JUSBC1.8 1.8,68.5 ; JUSBC1.8 3.27,67.67 ; JUSBC1.8 1.8,66.84 ; JUSBC1.8 3.27,68.5 ; JUSBC1.8 0.33,68.5 ; JUSBC1.8 3.27,66.84 ; JLOM1.10 199.82,150.9 ; JLOM1.10 199.41,150.9 ; JLOM1.10 200.23,150.9 ; 341.78,3.35 JNGFF4.77 ; JNGFF4.77 341.78,2.09 ; JNGFF4.77 342.4,2.09 ; JNGFF4.77 341.78,4.61 ; JNGFF4.77 342.4,4.61
  GND4 w0.254: JDG1.7 114.5,22.95 ; JDG1.7 113.8,22.95 ; JDG1.7 113.8,21 ; JDG1.7 113.1,21.98 ; JDG1.7 113.1,22.95 ; JDG1.7 113.1,21 ; JDG1.7 114.5,21.98 ; H23.1 5.19,40.29 ; H23.1 2.27,39.05 ; H23.1 5.63,39.05 ; H23.1 2.71,37.81 ; H23.1 5.19,37.81 ; H23.1 2.71,40.29 ; H23.1 3.95,37.37 ; H23.1 3.95,40.73 ; H4.1 40.37,5.52 ; H4.1 37.33,5.52 ; H4.1 40.93,4 ; H4.1 40.37,2.48 ; H4.1 37.33,2.48 ; H4.1 38.85,6.08 ; H4.1 38.85,1.92 ; H4.1 36.77,4 ; 326.15,41.47 H17.1 ; H17.1 327.64,44.99 ; H17.1 324.66,44.99 ; H17.1 324.66,42.01 ; H17.1 327.64,42.01 ; H17.1 326.15,45.53 ; H17.1 328.18,43.5 ; H17.1 324.12,43.5 ; H8.1 3.6,56.93 ; H8.1 5.28,55.25 ; H8.1 2.36,56.49 ; H8.1 1.92,55.25 ; H8.1 4.84,54.01 ; H8.1 4.84,56.49 ; H8.1 3.6,53.57 ; H8.1 2.36,54.01 ; 167.41,4.64 H11.1 ; H11.1 168.65,1.72 ; H11.1 166.97,3.4 ; H11.1 168.65,5.08 ; H11.1 169.89,2.16 ; H11.1 169.89,4.64 ; H11.1 170.33,3.4 ; H11.1 167.41,2.16 ; H9.1 6.83,2.9 ; H9.1 6.39,4.14 ; H9.1 5.15,4.58 ; H9.1 3.91,1.66 ; H9.1 5.15,1.22 ; H9.1 3.47,2.9 ; H9.1 3.91,4.14 ; H9.1 6.39,1.66 ; 330.66,32.14 SW1.5 ; SW1.5 332.18,32.14 ; SW1.5 331.42,31.9 ; SW1.5 332.42,32.91 ; SW1.5 332.18,33.67 ; SW1.5 331.42,33.91 ; SW1.5 330.42,32.91 ; 221.97,146.2 H18.1 ; H18.1 223.65,147.88 ; H18.1 225.33,146.2 ; H18.1 222.41,144.96 ; H18.1 224.89,144.96 ; H18.1 223.65,144.52 ; H18.1 222.41,147.44 ; H18.1 224.89,147.44 ; JDG1.6 114.5,16.9 ; JDG1.6 113.8,16.9 ; JDG1.6 113.1,17.87 ; JDG1.6 114.5,18.85 ; JDG1.6 113.1,18.85 ; JDG1.6 113.1,16.9 ; JDG1.6 113.8,18.85 ; JDG1.6 114.5,17.87 ; H21.1 204.42,89.43 ; H21.1 201.08,89.43 ; H21.1 205.04,91.1 ; H21.1 201.08,92.77 ; H21.1 202.75,88.81 ; H21.1 200.46,91.1 ; H21.1 202.75,93.39 ; H21.1 204.42,92.77 ; 43.63,45.43 H28.1 ; H28.1 46.67,45.43 ; H28.1 47.23,46.95 ; H28.1 43.63,48.47 ; H28.1 45.15,49.03 ; H28.1 43.07,46.95 ; H28.1 45.15,44.87 ; H28.1 46.67,48.47 ; 70.23,2.48 H5.1 ; H5.1 71.75,6.08 ; H5.1 73.27,2.48 ; H5.1 71.75,1.92 ; H5.1 73.83,4 ; H5.1 73.27,5.52 ; H5.1 70.23,5.52 ; H5.1 69.67,4 ; H6.1 5.19,70.21 ; H6.1 5.63,71.45 ; H6.1 2.71,72.69 ; H6.1 2.71,70.21 ; H6.1 2.27,71.45 ; H6.1 3.95,73.13 ; H6.1 3.95,69.77 ; H6.1 5.19,72.69 ; JDG1.9 103.1,21 ; JDG1.9 103.1,21.98 ; JDG1.9 101.7,21 ; JDG1.9 102.4,22.95 ; JDG1.9 101.7,21.98 ; JDG1.9 101.7,22.95 ; JDG1.9 103.1,22.95 ; JDG1.9 102.4,21 ; H19.1 30.14,4.39 ; H19.1 30.14,2.9 ; H19.1 25.66,2.9 ; H19.1 25.66,4.39 ; H19.1 27.9,4.39 ; H19.1 25.66,1.41 ; H19.1 30.14,1.41 ; H19.1 27.9,1.41 ; H3.1 273.77,88.63 ; H3.1 273.77,91.97 ; H3.1 272.1,88.01 ; H3.1 274.39,90.3 ; H3.1 270.43,88.63 ; H3.1 270.43,91.97 ; H3.1 269.81,90.3 ; H3.1 272.1,92.59 ; 270.6,112.81 H12.1 ; H12.1 268.93,113.43 ; H12.1 270.6,117.39 ; H12.1 272.27,116.77 ; H12.1 272.89,115.1 ; H12.1 268.31,115.1 ; H12.1 272.27,113.43 ; H12.1 268.93,116.77 ; H1.1 370.79,72.49 ; H1.1 369.55,72.93 ; H1.1 371.23,71.25 ; H1.1 369.55,69.57 ; H1.1 368.31,70.01 ; H1.1 370.79,70.01 ; H1.1 367.87,71.25 ; H1.1 368.31,72.49 ; 205.25,116.31 H22.1 ; H22.1 203.58,116.93 ; H22.1 206.92,116.93 ; H22.1 205.25,120.89 ; H22.1 207.54,118.6 ; H22.1 202.96,118.6 ; H22.1 203.58,120.27 ; H22.1 206.92,120.27 ; H7.1 173.34,71.16 ; H7.1 173.34,73.64 ; H7.1 170.86,73.64 ; H7.1 170.86,71.16 ; H7.1 173.78,72.4 ; H7.1 170.42,72.4 ; H7.1 172.1,74.08 ; H7.1 172.1,70.72 ; 68.31,55.39 H25.1 ; H25.1 70.79,55.39 ; H25.1 68.31,52.91 ; H25.1 67.87,54.15 ; H25.1 69.55,52.47 ; H25.1 69.55,55.83 ; H25.1 70.79,52.91 ; H25.1 71.23,54.15 ; H10.1 286.89,62.94 ; H10.1 284.41,62.94 ; H10.1 284.41,60.46 ; H10.1 285.65,63.38 ; H10.1 285.65,60.02 ; H10.1 283.97,61.7 ; H10.1 287.33,61.7 ; H10.1 286.89,60.46 ; 101.7,18.85 JDG1.8 ; JDG1.8 101.7,16.9 ; JDG1.8 101.7,17.87 ; JDG1.8 103.1,16.9 ; JDG1.8 103.1,17.87 ; JDG1.8 102.4,18.85 ; JDG1.8 102.4,16.9 ; JDG1.8 103.1,18.85 ; 31.71,4.14 H20.1 ; H20.1 31.71,1.66 ; H20.1 31.27,2.9 ; H20.1 34.19,4.14 ; H20.1 32.95,4.58 ; H20.1 34.63,2.9 ; H20.1 34.19,1.66 ; H20.1 32.95,1.22 ; 10.41,71.34 H27.1 ; H27.1 11.65,68.42 ; H27.1 12.89,71.34 ; H27.1 12.89,68.86 ; H27.1 10.41,68.86 ; H27.1 13.33,70.1 ; H27.1 9.97,70.1 ; H27.1 11.65,71.78 ; 360.41,71.34 H26.1 ; H26.1 362.89,68.86 ; H26.1 361.65,68.42 ; H26.1 361.65,71.78 ; H26.1 360.41,68.86 ; H26.1 362.89,71.34 ; H26.1 359.97,70.1 ; H26.1 363.33,70.1 ; H16.1 300.78,48.05 ; H16.1 300.24,49.54 ; H16.1 296.72,48.05 ; H16.1 297.26,46.56 ; H16.1 300.24,46.56 ; H16.1 297.26,49.54 ; H16.1 298.75,50.08 ; H16.1 298.75,46.02 ; SW1.4 338.48,32.14 ; SW1.4 336.72,32.91 ; SW1.4 337.72,33.91 ; SW1.4 336.96,32.14 ; SW1.4 336.96,33.67 ; SW1.4 338.48,33.67 ; SW1.4 337.72,31.9 ; SW1.4 338.72,32.91 ; H24.1 334,4 ; H24.1 331.8,1.8 ; H24.1 332.9,4.39 ; H24.1 334.39,2.9 ; H24.1 331.41,2.9 ; H24.1 331.8,4 ; H24.1 334,1.8 ; H24.1 332.9,1.41
  IN4 w0.203: JUSBC1.3 8.18,42.83 ; JUSBC1.3 6.85,42.06 ; JUSBC1.3 5.52,42.06 ; JUSBC1.3 5.52,42.83 ; JUSBC1.3 8.18,43.61 ; JUSBC1.4 8.18,67.67 ; JUSBC1.4 8.18,66.89 ; JUSBC1.4 5.52,67.67 ; JUSBC1.4 6.85,68.45 ; JUSBC1.4 5.52,68.45 ; JUSBC1.4 8.18,68.45 ; 5.53,68.45 JUSBC1.2 ; JUSBC1.2 6.25,66.44 ; JUSBC1.2 6.97,66.44 ; JUSBC1.2 6.25,68.45 ; JUSBC1.2 5.53,66.44 ; JUSBC1.2 6.97,68.45 ; JUSBC1.2 5.53,67.37 ; JUSBC1.10 6.25,60.3 ; JUSBC1.10 6.94,60.3 ; JUSBC1.10 6.94,58.86 ; JUSBC1.10 5.56,58.86 ; JUSBC1.10 6.94,59.58 ; JUSBC1.10 6.25,58.86 ; JUSBC1.10 5.56,60.3 ; JUSBC1.10 5.56,59.58 ; 5.53,43.13 JUSBC1.1 ; JUSBC1.1 6.97,44.06 ; JUSBC1.1 5.53,44.06 ; JUSBC1.1 6.25,42.05 ; JUSBC1.1 6.25,44.06 ; JUSBC1.1 5.53,42.05 ; JUSBC1.1 6.97,42.05 ; 6.25,50.2 JUSBC1.9 ; JUSBC1.9 5.56,51.64 ; JUSBC1.9 6.94,51.64 ; JUSBC1.9 5.56,50.2 ; JUSBC1.9 5.56,50.92 ; JUSBC1.9 6.25,51.64 ; JUSBC1.9 6.94,50.92
  GND5 w0.203: 0.33,58.2 JUSBC1.7 ; JUSBC1.7 1.8,58.2 ; JUSBC1.7 1.8,59.86 ; JUSBC1.7 3.27,59.03 ; JUSBC1.7 3.27,59.86 ; JUSBC1.7 3.27,58.2 ; JNGFF4.76 365.52,4.61 ; JNGFF4.76 365.52,2.09 ; JNGFF4.76 364.9,4.61 ; JNGFF4.76 364.9,2.09 ; JNGFF4.76 365.52,3.35 ; 5.52,67.67 JUSBC1.4 ; JUSBC1.4 8.18,68.45 ; JUSBC1.4 6.85,68.45 ; JUSBC1.4 5.52,68.45 ; JUSBC1.4 8.18,67.67 ; JUSBC1.4 8.18,66.89 ; 359.19,61.58 JUSB1.13 ; JUSB1.13 359.19,59.82 ; JUSB1.13 361.85,59.82 ; JUSB1.13 361.85,60.7 ; JUSB1.13 359.19,60.7 ; JUSB1.13 360.52,61.58 ; JUSB1.13 360.52,59.82 ; JUSB1.13 361.85,61.58 ; 358.4,32.3 JUSB2.7 ; JUSB2.7 359.77,31.7 ; JUSB2.7 359.17,31.52 ; JUSB2.7 359.17,33.08 ; JUSB2.7 358.57,31.7 ; JUSB2.7 359.77,32.9 ; JUSB2.7 358.57,32.9 ; JUSB2.7 359.95,32.3 ; JUSBC1.5 3.27,43.66 ; JUSBC1.5 0.33,42 ; JUSBC1.5 1.8,42 ; JUSBC1.5 3.27,42 ; JUSBC1.5 3.27,42.83 ; JUSBC1.5 1.8,43.66 ; 360.52,47.02 JUSB1.11 ; JUSB1.11 361.85,48.78 ; JUSB1.11 359.19,47.02 ; JUSB1.11 360.52,48.78 ; JUSB1.11 359.19,48.78 ; JUSB1.11 361.85,47.02 ; JUSB1.11 359.19,47.9 ; JUSB1.11 361.85,47.9 ; 1.8,50.64 JUSBC1.6 ; JUSBC1.6 0.33,52.3 ; JUSBC1.6 3.27,50.64 ; JUSBC1.6 3.27,52.3 ; JUSBC1.6 3.27,51.47 ; JUSBC1.6 1.8,52.3 ; 359.19,25.9 JUSB2.11 ; JUSB2.11 360.52,26.78 ; JUSB2.11 359.19,26.78 ; JUSB2.11 361.85,26.78 ; JUSB2.11 360.52,25.02 ; JUSB2.11 361.85,25.02 ; JUSB2.11 359.19,25.02 ; JUSB2.11 361.85,25.9 ; 366.69,47.9 JUSB1.10 ; JUSB1.10 366.69,47.02 ; JUSB1.10 369.35,47.02 ; JUSB1.10 366.69,48.78 ; JUSB1.10 368.02,48.78 ; JUSB1.10 369.35,48.78 ; JUSB1.10 368.02,47.02 ; JUSB1.10 369.35,47.9 ; 5.56,50.92 JUSBC1.9 ; JUSBC1.9 5.56,50.2 ; JUSBC1.9 5.56,51.64 ; JUSBC1.9 6.94,51.64 ; JUSBC1.9 6.94,50.92 ; JUSBC1.9 6.25,51.64 ; JUSB2.12 369.35,37.82 ; JUSB2.12 368.02,39.58 ; JUSB2.12 366.69,38.7 ; JUSB2.12 369.35,39.58 ; JUSB2.12 369.35,38.7 ; JUSB2.12 366.69,37.82 ; JUSB2.12 368.02,37.82 ; JUSB2.12 366.69,39.58 ; 360.07,58.4 JUSB1.4 ; JUSB1.4 360.07,57.2 ; JUSB1.4 360.67,58.57 ; JUSB1.4 360.67,57.02 ; JUSB1.4 361.27,58.4 ; JUSB1.4 359.9,57.8 ; JUSB1.4 361.45,57.8 ; JUSB1.4 361.27,57.2 ; JUSBC1.8 3.27,66.84 ; JUSBC1.8 1.8,68.5 ; JUSBC1.8 0.33,68.5 ; JUSBC1.8 3.27,67.67 ; JUSBC1.8 1.8,66.84 ; JUSBC1.8 3.27,68.5 ; 5.56,59.58 JUSBC1.10 ; JUSBC1.10 6.94,59.58 ; JUSBC1.10 5.56,60.3 ; JUSBC1.10 5.56,58.86 ; JUSBC1.10 6.25,58.86 ; JUSBC1.10 6.25,60.3 ; JUSBC1.10 6.94,58.86 ; H15.1 88.87,46.38 ; H15.1 87.35,45.82 ; H15.1 87.35,49.98 ; H15.1 85.27,47.9 ; H15.1 85.83,49.42 ; H15.1 89.43,47.9 ; H15.1 88.87,49.42 ; H15.1 85.83,46.38 ; 119.63,46.38 H14.1 ; H14.1 122.67,49.42 ; H14.1 122.67,46.38 ; H14.1 121.15,49.98 ; H14.1 123.23,47.9 ; H14.1 119.63,49.42 ; H14.1 119.07,47.9 ; H14.1 121.15,45.82 ; 360.52,37.82 JUSB2.13 ; JUSB2.13 361.85,37.82 ; JUSB2.13 359.19,39.58 ; JUSB2.13 360.52,39.58 ; JUSB2.13 359.19,38.7 ; JUSB2.13 359.19,37.82 ; JUSB2.13 361.85,39.58 ; JUSB2.13 361.85,38.7 ; JUSB1.12 369.35,59.82 ; JUSB1.12 366.69,61.58 ; JUSB1.12 366.69,60.7 ; JUSB1.12 366.69,59.82 ; JUSB1.12 369.35,60.7 ; JUSB1.12 369.35,61.58 ; JUSB1.12 368.02,59.82 ; JUSB1.12 368.02,61.58 ; 358.57,54.9 JUSB1.7 ; JUSB1.7 359.77,53.7 ; JUSB1.7 359.17,55.08 ; JUSB1.7 358.57,53.7 ; JUSB1.7 359.77,54.9 ; JUSB1.7 359.95,54.3 ; JUSB1.7 359.17,53.52 ; JUSB1.7 358.4,54.3 ; 359.9,35.8 JUSB2.4 ; JUSB2.4 360.67,35.02 ; JUSB2.4 360.67,36.57 ; JUSB2.4 361.45,35.8 ; JUSB2.4 361.27,35.2 ; JUSB2.4 361.27,36.4 ; JUSB2.4 360.07,35.2 ; JUSB2.4 360.07,36.4 ; JUSB2.10 369.35,25.02 ; JUSB2.10 366.69,25.9 ; JUSB2.10 369.35,25.9 ; JUSB2.10 366.69,26.78 ; JUSB2.10 369.35,26.78 ; JUSB2.10 368.02,25.02 ; JUSB2.10 368.02,26.78 ; JUSB2.10 366.69,25.02 ; JUSBC1.1 6.97,42.05 ; JUSBC1.1 5.53,42.05 ; JUSBC1.1 5.53,43.13 ; JUSBC1.1 5.53,44.06 ; JUSBC1.1 6.25,42.05 ; JUSBC1.2 6.25,68.45 ; JUSBC1.2 5.53,66.44 ; JUSBC1.2 5.53,67.37 ; JUSBC1.2 6.97,68.45 ; JUSBC1.2 5.53,68.45 ; JLOM1.10 200.23,150.9 ; JLOM1.10 199.82,150.9 ; JLOM1.10 199.41,150.9 ; 341.78,3.35 JNGFF4.77 ; JNGFF4.77 342.4,4.61 ; JNGFF4.77 342.4,2.09 ; JNGFF4.77 341.78,2.09 ; JNGFF4.77 341.78,4.61 ; JLOM1.9 219.29,149.22 ; JLOM1.9 218.46,147.55 ; JLOM1.9 219.29,150.9 ; JLOM1.9 218.46,150.9 ; JLOM1.9 219.29,147.55
  GND5 w0.254: H16.1 300.24,46.56 ; H16.1 297.26,46.56 ; H16.1 300.24,49.54 ; H16.1 297.26,49.54 ; H16.1 296.72,48.05 ; H16.1 300.78,48.05 ; H16.1 298.75,50.08 ; H16.1 298.75,46.02 ; H20.1 34.63,2.9 ; H20.1 31.71,4.14 ; H20.1 34.19,4.14 ; H20.1 32.95,4.58 ; H20.1 34.19,1.66 ; H20.1 31.71,1.66 ; H20.1 32.95,1.22 ; H20.1 31.27,2.9 ; 205.25,116.31 H22.1 ; H22.1 202.96,118.6 ; H22.1 203.58,120.27 ; H22.1 205.25,120.89 ; H22.1 206.92,120.27 ; H22.1 203.58,116.93 ; H22.1 207.54,118.6 ; H22.1 206.92,116.93 ; 113.1,21.98 JDG1.7 ; JDG1.7 114.5,22.95 ; JDG1.7 114.5,21.98 ; JDG1.7 113.8,21 ; JDG1.7 113.8,22.95 ; JDG1.7 113.1,22.95 ; JDG1.7 113.1,21 ; 102.4,16.9 JDG1.8 ; JDG1.8 103.1,16.9 ; JDG1.8 102.4,18.85 ; JDG1.8 101.7,17.87 ; JDG1.8 103.1,17.87 ; JDG1.8 101.7,18.85 ; JDG1.8 101.7,16.9 ; JDG1.8 103.1,18.85 ; JDG1.9 103.1,21 ; JDG1.9 101.7,21 ; JDG1.9 101.7,22.95 ; JDG1.9 103.1,21.98 ; JDG1.9 102.4,21 ; JDG1.9 101.7,21.98 ; JDG1.9 103.1,22.95 ; JDG1.9 102.4,22.95 ; 25.66,2.9 H19.1 ; H19.1 30.14,2.9 ; H19.1 25.66,1.41 ; H19.1 30.14,1.41 ; H19.1 25.66,4.39 ; H19.1 27.9,1.41 ; H19.1 27.9,4.39 ; H19.1 30.14,4.39 ; 37.33,2.48 H4.1 ; H4.1 40.37,2.48 ; H4.1 37.33,5.52 ; H4.1 40.93,4 ; H4.1 36.77,4 ; H4.1 40.37,5.52 ; H4.1 38.85,1.92 ; H4.1 38.85,6.08 ; 268.93,113.43 H12.1 ; H12.1 272.27,113.43 ; H12.1 270.6,117.39 ; H12.1 272.89,115.1 ; H12.1 268.31,115.1 ; H12.1 268.93,116.77 ; H12.1 270.6,112.81 ; H12.1 272.27,116.77 ; 360.41,71.34 H26.1 ; H26.1 359.97,70.1 ; H26.1 362.89,68.86 ; H26.1 362.89,71.34 ; H26.1 360.41,68.86 ; H26.1 361.65,68.42 ; H26.1 363.33,70.1 ; H26.1 361.65,71.78 ; H24.1 334,1.8 ; H24.1 334,4 ; H24.1 331.41,2.9 ; H24.1 331.8,4 ; H24.1 332.9,4.39 ; H24.1 332.9,1.41 ; H24.1 331.8,1.8 ; H24.1 334.39,2.9 ; H21.1 204.42,89.43 ; H21.1 201.08,89.43 ; H21.1 205.04,91.1 ; H21.1 202.75,88.81 ; H21.1 201.08,92.77 ; H21.1 204.42,92.77 ; H21.1 200.46,91.1 ; H21.1 202.75,93.39 ; SW1.4 338.72,32.91 ; SW1.4 336.96,33.67 ; SW1.4 337.72,33.91 ; SW1.4 338.48,32.14 ; SW1.4 338.48,33.67 ; SW1.4 336.72,32.91 ; SW1.4 337.72,31.9 ; SW1.4 336.96,32.14 ; SW1.5 332.18,32.14 ; SW1.5 331.42,33.91 ; SW1.5 332.42,32.91 ; SW1.5 331.42,31.9 ; SW1.5 330.42,32.91 ; SW1.5 330.66,32.14 ; SW1.5 332.18,33.67 ; H18.1 224.89,147.44 ; H18.1 222.41,147.44 ; H18.1 223.65,147.88 ; H18.1 224.89,144.96 ; H18.1 222.41,144.96 ; H18.1 223.65,144.52 ; H18.1 221.97,146.2 ; H18.1 225.33,146.2 ; H10.1 286.89,62.94 ; H10.1 285.65,63.38 ; H10.1 286.89,60.46 ; H10.1 285.65,60.02 ; H10.1 283.97,61.7 ; H10.1 284.41,60.46 ; H10.1 287.33,61.7 ; H10.1 284.41,62.94 ; 43.63,45.43 H28.1 ; H28.1 43.07,46.95 ; H28.1 43.63,48.47 ; H28.1 46.67,48.47 ; H28.1 47.23,46.95 ; H28.1 45.15,44.87 ; H28.1 45.15,49.03 ; H28.1 46.67,45.43 ; 166.97,3.4 H11.1 ; H11.1 170.33,3.4 ; H11.1 169.89,2.16 ; H11.1 167.41,2.16 ; H11.1 168.65,1.72 ; H11.1 168.65,5.08 ; H11.1 167.41,4.64 ; H11.1 169.89,4.64 ; 367.87,71.25 H1.1 ; H1.1 369.55,69.57 ; H1.1 368.31,72.49 ; H1.1 370.79,72.49 ; H1.1 369.55,72.93 ; H1.1 368.31,70.01 ; H1.1 370.79,70.01 ; H1.1 371.23,71.25 ; H23.1 3.95,40.73 ; H23.1 5.63,39.05 ; H23.1 5.19,40.29 ; H23.1 2.71,37.81 ; H23.1 2.27,39.05 ; H23.1 2.71,40.29 ; H23.1 5.19,37.81 ; H23.1 3.95,37.37 ; H6.1 5.19,70.21 ; H6.1 3.95,69.77 ; H6.1 2.71,72.69 ; H6.1 2.71,70.21 ; H6.1 5.63,71.45 ; H6.1 3.95,73.13 ; H6.1 2.27,71.45 ; H6.1 5.19,72.69 ; H25.1 70.79,52.91 ; H25.1 70.79,55.39 ; H25.1 68.31,55.39 ; H25.1 71.23,54.15 ; H25.1 67.87,54.15 ; H25.1 69.55,55.83 ; H25.1 69.55,52.47 ; H25.1 68.31,52.91 ; 170.86,71.16 H7.1 ; H7.1 170.86,73.64 ; H7.1 172.1,74.08 ; H7.1 173.78,72.4 ; H7.1 173.34,71.16 ; H7.1 170.42,72.4 ; H7.1 172.1,70.72 ; H7.1 173.34,73.64 ; 70.23,2.48 H5.1 ; H5.1 73.83,4 ; H5.1 73.27,2.48 ; H5.1 71.75,6.08 ; H5.1 70.23,5.52 ; H5.1 71.75,1.92 ; H5.1 73.27,5.52 ; H5.1 69.67,4 ; H9.1 6.39,1.66 ; H9.1 3.47,2.9 ; H9.1 3.91,4.14 ; H9.1 6.39,4.14 ; H9.1 6.83,2.9 ; H9.1 3.91,1.66 ; H9.1 5.15,4.58 ; H9.1 5.15,1.22 ; H3.1 273.77,91.97 ; H3.1 270.43,91.97 ; H3.1 274.39,90.3 ; H3.1 272.1,88.01 ; H3.1 273.77,88.63 ; H3.1 270.43,88.63 ; H3.1 269.81,90.3 ; H3.1 272.1,92.59 ; 2.36,56.49 H8.1 ; H8.1 3.6,56.93 ; H8.1 1.92,55.25 ; H8.1 2.36,54.01 ; H8.1 4.84,56.49 ; H8.1 4.84,54.01 ; H8.1 3.6,53.57 ; H8.1 5.28,55.25 ; 326.15,41.47 H17.1 ; H17.1 328.18,43.5 ; H17.1 327.64,44.99 ; H17.1 324.66,42.01 ; H17.1 324.66,44.99 ; H17.1 326.15,45.53 ; H17.1 324.12,43.5 ; H17.1 327.64,42.01 ; 9.97,70.1 H27.1 ; H27.1 10.41,71.34 ; H27.1 13.33,70.1 ; H27.1 12.89,68.86 ; H27.1 11.65,71.78 ; H27.1 11.65,68.42 ; H27.1 10.41,68.86 ; H27.1 12.89,71.34 ; JDG1.6 114.5,18.85 ; JDG1.6 113.8,16.9 ; JDG1.6 113.1,18.85 ; JDG1.6 113.1,17.87 ; JDG1.6 114.5,16.9 ; JDG1.6 114.5,17.87 ; JDG1.6 113.1,16.9 ; JDG1.6 113.8,18.85
  BOTTOM w0.102: 299.01,1.46 300.51,1.46 ; 299.01,1.46 297.5,1.46 ; 299.01,1.46 299,1.47 JNGFF2.31 ; 300.51,1.46 300.5,1.47 JNGFF2.37 ; 300.51,1.46 302.01,1.46 ; JNGFF2.49 303.5,1.6 303.36,1.46 302.01,1.46 ; JNGFF2.19 296,1.59 296.14,1.46 297.5,1.46 ; 297.5,1.46 JNGFF2.25 ; 302.01,1.46 302,1.46 JNGFF2.43 ; v2(188.72,37.84) 188.7,37.82 187.63,37.82 v2(187.51,37.94) v2(187.51,38.58) 187.51,39.07 v2(187.64,39.21)
  BOTTOM w0.127: RT504.2 10.93,41.96 v2(10.6,41.63) ; RT504.2 v2(11.15,41.41) ; RT504.2 11.42,41.96 v2(11.75,41.63) ; DT45.2 13.03,52.94 v2(12.61,53.36) ; DT45.2 13.21,52.94 v2(13.21,53.45) ; DT45.2 13.4,52.94 v2(13.82,53.36) ; v2(12.99,41.55) DT13.2 ; DT13.2 13.1,42.11 v2(13.58,41.64) ; DT13.2 12.89,42.11 v2(12.41,41.64) ; v2(14.48,50.62) 14.86,50.24 DT17.2 ; v2(12.37,44.04) 12.83,43.58 DT14.2 ; DT18.2 14.86,48.77 v2(14.47,48.39) ; DT18.2 v2(15.05,48.2) ; DT18.2 15.24,48.77 v2(15.62,48.39) ; DT14.2 v2(12.99,44.07) ; DT14.2 13.11,43.58 v2(13.58,44.05) ; RT632.2 13.47,50.39 v2(13.77,50.69) 13.77,51.15 13.44,51.47 DT44.2 ; RT632.2 12.96,50.39 v2(12.66,50.69) 12.66,51.12 13.01,51.47 DT44.2 ; RT632.2 v2(13.21,50.96) DT44.2 ; v2(16.97,58.28) 16.63,57.93 RT640.2 ; v2(10.85,59.77) 10.56,59.48 RT638.2 ; RT639.2 v2(14.28,57.71) ; RT639.2 14.87,57.89 v2(14.47,58.29) ; RT639.2 14.87,57.55 v2(14.47,57.14) ; RT640.2 16.63,57.47 v2(16.97,57.13) ; RT640.2 v2(17.19,57.71) ; v2(10.61,44.04) 10.93,43.72 RT631.2 ; RT219.2 13.55,48.64 v2(13.79,48.4) ; RT219.2 v2(13.21,48.09) ; RT219.2 12.88,48.64 v2(12.64,48.4) ; v2(16.87,55.3) 16.48,55.68 DT52.2 ; DT17.2 v2(15.05,50.81) ; DT17.2 15.24,50.24 v2(15.63,50.62) ; DT52.2 v2(17.06,55.88) ; DT52.2 16.48,56.06 v2(16.87,56.45) ; v2(8.45,58.67) 8.8,59.03 RT637.2 ; DT54.2 15.02,56.1 v2(14.66,56.45) ; DT54.2 v2(14.51,55.88) ; DT54.2 15.02,55.63 v2(14.68,55.3) ; RT631.2 11.38,43.72 v2(11.7,44.04) ; RT631.2 v2(11.15,44.26) ; RT638.2 10.56,59.01 v2(10.9,58.67) ; RT638.2 v2(11.1,59.24) ; v2(190.47,41.54) 190.26,41.33 189.55,41.33 189.26,41.04 189.26,40.21 189.34,40.14 v2(189.34,40.03) 189.34,39.69 189.45,39.58 189.45,38.82 189.22,38.59 189.22,38.28 ; v2(188.27,41.54) 188.04,41.54 187.32,40.82 187.32,39.69 187.64,39.37 v2(187.64,39.21) ; v2(8.26,59.24) 8.26,59.24 RT637.2 ; v2(8.45,59.8) 8.8,59.45 RT637.2 ; v3(161.81,25) 161.27,24.46 v2(161.27,23.87)
  BOTTOM w0.152: 189.22,38.28 188.78,37.84 v2(188.72,37.84)
  BOTTOM w0.178: UT1.AC8 UT1.AB8 ; UT1.F20 28.68,34.42 UT1.G22 UT1.G23 ; UT1.B14 UT1.A14 ; UT1.B12 UT1.A12 ; v2(25.2,35.86) UT1.A18 UT1.B18 ; UT1.R22 UT1.R23 ; UT1.M1 UT1.M2 ; UT1.E23 UT1.E22 ; UT1.AC23 UT1.AC22 UT1.AB22 ; UT1.AC6 UT1.AB6 ; UT1.U22 UT1.U23 ; v2(25.2,41.66) 25.49,41.38 UT1.A6 UT1.B6 ; UT1.A4 UT1.B4 ; UT1.AB4 UT1.AC4 ; UT1.N23 UT1.N22 31.44,34.26 UT1.M20 30.52,34.26 UT1.L22 UT1.L23 ; UT1.A23 UT1.A22 UT1.B22 UT1.C22 UT1.C23 ; v2(29.36,34.41) 29.6,34.16 UT1.J22 UT1.J23 ; UT1.AC12 UT1.AB12 ; UT1.B16 UT1.A16 25.33,36.78 25.32,36.78 v2(25.13,36.78) ; UT1.AC10 UT1.AB10 ; UT1.AA22 UT1.AA23 ; UT1.AB18 UT1.AC18 v2(36.57,35.86) ; UT1.AC14 UT1.AB14 ; UT1.AB20 UT1.AC20 ; UT1.AB2 UT1.AB1 ; UT1.AB16 UT1.AC16 ; UT1.D2 UT1.D1 ; UT1.B8 UT1.A8 ; UT1.W23 UT1.W22 ; v2(25.12,34.52) 25.35,34.76 25.45,34.76 25.63,34.94 UT1.A20 UT1.B20 ; UT1.B10 UT1.A10
  BOTTOM w0.203: v2(36.55,40.45) 36.05,40.45 UT1.AC8 ; 5.56,60.3 JUSBC1.10 ; JUSBC1.10 6.25,60.3 ; JUSBC1.10 6.94,59.58 ; JUSBC1.10 6.25,58.86 ; JUSBC1.10 5.56,58.86 ; JUSBC1.10 6.94,58.86 ; JUSBC1.10 5.56,59.58 ; UR1.13 18.82,13.02 18.7,12.89 18.7,12.36 v2(18.25,11.92) ; v2(36.64,35.04) 36.15,35.04 UT1.AC20 ; UT1.B4 26.71,42.3 ; 6.97,42.05 JUSBC1.1 ; JUSBC1.1 5.53,44.06 ; JUSBC1.1 6.25,44.06 ; JUSBC1.1 6.97,44.06 ; JUSBC1.3 7.52,43.61 ; JUSBC1.3 8.18,42.83 ; JUSBC1.3 6.85,42.06 ; UT1.A10 v2(25.44,39.54) ; UT1.AC16 36.14,36.67 v2(36.51,36.67)
  BOTTOM w0.254: JNGFF3.51 74.87,36.7 74.62,36.45 72.27,36.45 71.99,36.74 v2(71.99,37.37) ; 324.14,16.3 325.47,16.3 325.65,16.48 JNGFF1.28 325.65,18.92 324.27,20.3 v2(323.81,20.3) v2(323.81,19.71) ; 324.14,16.3 322.7,16.3 ; 324.14,16.3 324.14,17.52 JNGFF1.22 324.15,19.38 v2(323.81,19.71) ; JNGFF1.49 330.9,10.78 v2(331.28,11.15) 331.32,11.1 332.12,11.1 v2(332.19,11.17) ; JNGFF3.45 75.32,38.2 v2(74.98,38.54) ; RH608.2 176.65,42.84 177.13,42.36 177.13,41.63 v2(177.23,41.54) ; JNGFF5.21 77.18,19.15 77.35,19.31 77.88,19.31 v2(77.96,19.24) ; JNGFF2.31 299,4.27 298.76,4.51 v2(298.76,5.18) ; JNGFF5.39 77.18,14.65 77.33,14.5 v2(77.93,14.5) ; JNGFF1.7 318.4,9.32 318.65,9.07 318.65,8.93 v2(318.83,8.75) ; v2(348.72,10.33) 348.72,10.2 348.9,10.02 JNGFF4.57 ; PC1534.2 246.75,97.05 v2(246.92,96.88) ; JNGFF5.27 77.27,17.65 v2(77.47,17.45) ; JNGFF4.1 362.9,9.93 v2(363.14,10.17) ; 324.9,11.03 325.53,11.66 v2(326.78,11.66) 327.59,11.66 327.9,11.35 JNGFF1.37 327.9,7.94 v2(327.98,7.85) ; 324.9,11.03 JNGFF1.25 ; 324.9,11.03 324.89,11.04 323.9,11.04 ; UR4.5 v2(5.83,23.5) ; v2(134.2,30.83) 134.27,30.9 CE23.2 ; JNGFF3.63 77.24,31.7 v2(77.5,31.44) 77.26,31.2 JNGFF3.65 ; v2(323.81,19.71) 322.93,18.83 v2(322.35,18.83) ; v2(243.6,95.08) 243.6,96.26 243.95,96.61 243.95,97.35 244.23,97.63 PC1533.2 ; v2(60.69,4.75) 60.25,4.31 JDEG1.10 ; UZ42.5 105.13,25.7 v2(105.88,24.95) ; JNGFF3.67 77.48,30.7 77.79,31.01 v2(77.94,31.01) ; v2(332.19,11.17) 332.4,10.96 JNGFF1.55 ; v2(332.19,11.17) 333.6,11.17 v2(333.68,11.25) 333.9,11.02 JNGFF1.61 333.9,9.06 334.11,8.84 334.75,8.84 334.94,8.65 v2(335.39,8.65) 335.4,8.66 JNGFF1.67 ; JNGFF4.33 354.9,10.04 v2(354.67,10.27) ; 323.9,11.04 322.76,11.04 322.4,10.68 JNGFF1.15 322.4,9.04 322.19,8.83 v2(321.81,8.83) 321.81,7.41 v2(321.51,7.11) 320.15,5.75 v2(320.15,5.66) ; 323.9,11.04 323.9,11.04 JNGFF1.21 ; JNGFF2.25 297.5,3.77 296.86,4.41 v2(296.86,5.21) ; CT383.1 177.68,18.71 177.94,18.98 177.94,19.82 RH424.2 ; v2(25.25,33.12) 25.69,33.56 UT1.A23 ; CE19.2 137.45,18.6 137.45,17.98 137.89,17.53 139.48,17.53 RH638.2 ; CZ54.2 120.44,23.07 v2(119.84,23.66) ; v2(322.35,18.83) 322.35,18.6 322.65,18.3 JNGFF1.16 322.65,16.34 322.7,16.3 ; v2(322.35,18.83) v2(321,18.83) 321.15,18.69 JNGFF1.10 321.15,16.54 321.39,16.3 322.7,16.3 ; UT12.3 61.92,23.34 61.66,23.09 61.12,23.09 v2(61.09,23.11) 61.09,23.34 60.81,23.62 UT11.4 ; v2(77.64,9.96) 77.45,10.15 JNGFF5.57 ; UT10.3 45.73,25.17 44.81,24.25 v2(44.52,24.25) ; PC1371.2 PC1349.2 228.46,98.32 v2(228.27,98.51) ; JNGFF4.3 362.4,10.11 v2(362.52,10.23) ; v2(353.56,10.22) 353.4,10.05 JNGFF4.39 ; v2(266.88,131.35) 267.01,131.22 PU1700.14 ; v2(350.61,10.29) 350.4,10.07 JNGFF4.51 ; JNGFF4.45 351.9,9.94 v2(351.65,10.19) ; v2(182.1,74.14) 182.85,73.39 UZ43.5 ; v2(77.77,45.58) 77.65,45.7 JNGFF3.15 ; CR229.1 v2(16.5,9.21) ; JNGFF4.21 357.9,10.11 v2(357.66,10.36) ; JNGFF4.27 356.4,10.14 v2(356.51,10.25) ; JNGFF2.63 307,3.42 v2(307.12,3.54) 307.32,3.54 307.5,3.36 JNGFF2.65 ; JNGFF5.45 77.17,13.15 77.3,13.28 v2(77.92,13.28) ; v2(301.79,3.52) 301.79,3.33 302,3.12 JNGFF2.43 ; v2(275.31,98.91) 275.23,98.99 PU300.11 ; CR230.2 v2(17.09,9.24) ; v2(187.17,43.59) 188.27,42.49 v2(188.27,41.54) ; v2(77.84,20.53) 77.19,20.53 77.07,20.65 JNGFF5.15 ; v2(303.37,3.56) 303.5,3.43 JNGFF2.49 ; DI1.3 v2(356.76,54.35) ; JNGFF4.71 345.4,9.96 v2(345.15,10.22) 344.9,9.97 JNGFF4.73 ; v2(191.01,45.1) 190.31,44.4 190.31,41.69 v2(190.47,41.54) ; JNGFF5.9 77.18,22.15 77.39,22.36 v2(77.57,22.36) ; JNGFF2.19 296,3.15 294.97,4.18 v2(292.97,4.18) 292.97,3.9 292,2.93 JNGFF2.11 ; JNGFF3.9 77.13,47.2 78.05,46.27 v2(78.05,46.11) ; JNGFF5.51 77.29,11.65 77.46,11.48 v2(77.9,11.48) ; v2(282.72,78.44) 282.65,78.37 CC338.2 281.73,76.8 CC337.2 ; JNGFF3.27 77.35,42.7 v2(77.62,42.97) ; JNGFF3.39 77.12,39.7 77.63,40.21 v2(77.63,40.48) 77.63,41.02 77.46,41.2 JNGFF3.33 ; JNGFF1.43 329.4,8.12 v2(329.2,7.91) ; JNGFF4.15 359.4,10.06 v2(359.59,10.25) ; JNGFF2.37 300.5,4.4 300.72,4.62 v2(300.72,5.17) ; v2(360.77,10.19) 360.9,10.05 JNGFF4.9 ; v2(128.55,24.41) 128.43,24.52 127.65,24.52 127.42,24.76 RE56.2 ; JCCG1.10 55.5,38.55 55.97,39.01 v2(55.97,39.49) 55.97,39.51 56,39.54 56,39.56 56.46,40.02 JCCG1.12 ; UE12.15 v2(6.39,11.76) ; v2(12.57,57.29) 12.57,57.66 12.65,57.74 DT12.3 ; JNGFF3.57 75.76,35.2 75.37,34.8 v2(75.37,33.08) ; CZ53.2 120.59,24.44 v2(119.84,25.19) ; v2(77.85,16.31) 77.23,16.31 77.07,16.15 JNGFF5.33 ; UZ45.5 v2(334.95,27.8) ; CH44.2 191.95,38.02 v2(191.52,37.59) ; v2(77.65,44.24) 77.61,44.2 JNGFF3.21
  BOTTOM w0.279: v2(187.51,27.37) 186.72,26.58 CH64.2
  BOTTOM w0.305: JNGFF2.3 290,3.73 ; 290,3.73 290.03,3.73 290.5,3.26 JNGFF2.5 ; 290,3.73 v2(289.54,4.19) ; v2(180.85,18.77) 181.34,19.26 RH325.1 ; JDIMM3.168 231.68,61.41 ; v2(265.33,35.21) 265.93,35.81 JDIMM1.39 ; v2(178.98,24.75) 179.48,24.75 CT384.1 ; JDIMM1.239 213.93,35.7 v2(213.71,35.48) ; JDIMM1.181 228.43,35.54 v2(228.44,35.53) ; v2(254.85,34.77) 255.43,35.35 JDIMM1.81 ; CD44.2 221.85,34.42 221.85,34.79 222.43,35.37 JDIMM1.205 ; v2(269.95,128.36) 269.9,128.41 PU1700.4 ; JESPI.9 167.91,12.46 v2(168.21,12.76) ; v2(223.9,35.61) 223.84,35.61 223.43,36.02 JDIMM1.201 ; v2(169.23,39.17) 169.13,39.27 CC327.2 168.11,39.2 167.63,38.72 CC329.2 ; JDIMM1.35 266.93,36.77 266.39,36.24 266.39,35.47 v2(265.37,34.46) ; 329.4,8.77 329.41,8.75 330.68,8.75 330.9,8.97 JNGFF1.49 ; v2(222.72,107.28) 222.72,107.37 222.12,107.97 CC191.1 ; v2(229.47,35.53) 229.93,35.99 JDIMM1.175 ; v2(269.49,35.15) 268.93,35.71 JDIMM1.27 ; RE55.2 129.93,33.01 129.93,33.77 v2(129.95,33.79) ; v2(60.84,7.29) 60.84,7.12 61.25,6.71 JDEG1.12 ; v2(227.02,35.85) 227.43,36.25 JDIMM1.185 ; v2(325.17,5.73) 325.74,5.73 326.48,6.47 v2(326.48,6.57) 326.32,6.74 326.32,8.48 326.4,8.56 JNGFF1.31 326.4,10.9 326.78,11.28 v2(326.78,11.66) ; RE58.2 128.45,32.33 128.07,32.71 126.7,32.71 v2(126.44,32.46) ; CR241.1 23.42,21.04 CR242.2 ; v2(263.61,34.77) 262.93,35.46 JDIMM1.51
  BOTTOM w0.33: CD24.2 254.91,32.99 v2(254.9,32.98)
  BOTTOM w0.356: CH62.2 183.02,26.7 v2(182.41,27.31) 182.86,27.76 CH36.2 ; RT524.2 56.2,36.95 56.2,37.71 56.19,37.72 56.19,37.72 v2(56.19,37.72) ; CE15.2 135.08,26.14 134.76,26.46 v2(134.37,26.46) ; CH33.2 172.77,15.99 173.8,17.02 CH41.1 174.72,17.92 v2(175.19,18.39) ; CC310.2 168.66,36.76 ; CZ18.2 280.3,8.72 v2(279.97,8.39) ; v2(5.65,15.26) 5.65,14.96 5.93,14.68 CE343.2 ; CR255.2 v2(5.62,18.56) ; v2(6.57,8.79) 6.9,9.12 CE340.2 ; v2(174.82,48.89) 175.53,48.18 RH603.2 ; v2(337.1,25.85) 337.23,25.98 CN2.2 ; CV922.2 141.29,38.26 v2(141.91,38.88) ; RH606.2 170.43,47.03 170.16,47.3 v2(169.76,47.3) ; CZ120.2 336.51,26.94 CZ121.2 ; CL280.2 184.16,124.27 v2(184.16,124.26) 184.92,124.26 CL7.2 ; CZ512.1 95.87,41.91 CZ511.2 v2(95.03,41.77) ; CE341.2 v2(9.87,16.5) ; 140.12,22.88 140.08,22.83 CE25.2 ; RH639.2 133.53,12.88 132.93,13.48 CH345.2 132.93,14.32 v2(132.96,14.34) ; CH66.2 189.07,20.46 v2(188.27,21.26) ; CV935.2 143.16,37.68 CV937.2 143.35,36.57 v2(143.06,36.27) ; CH37.2 171.8,43.05 v2(171.8,43.43) ; v2(161.27,23.87) 161.11,23.87 160.44,23.21 RH633.2 ; v2(101.16,47.44) 101.49,47.77 CZ509.2 ; RH65.2 44.07,38 44.36,37.71 CH350.2 ; CR244.1 17.2,18.04 17.45,18.29 ; CV880.2 CV879.2 154.27,44.89 v2(154.46,45.09) ; 104.55,28.24 106.56,28.24 CZ520.2 ; v2(196.73,43.07) 197.17,43.51 CH20.2 CC331.2 ; v2(136.54,31.31) 136.97,31.31 137.37,30.92 CE38.2 137.7,30.01 RE77.2 ; v2(198.78,45.74) 198.52,46 CH46.2 ; v2(69.52,22.94) 70.01,23.42 RT583.1 ; v2(277.73,88.73) 277.73,88.53 278.42,87.84 CC307.2 ; CD32.2 209.98,34.06 v2(209.46,33.53) ; CZ61.2 183.11,16.98 183.27,17.14 v2(183.27,18.41) ; CC332.2 200.26,43.09 v2(200.43,43.09) ; v2(11.57,27) 11.57,26.29 CR236.1 ; v2(180.21,73.8) 179.75,73.34 CZ514.2 ; v2(149.2,44.32) 148.64,44.88 CV927.2 ; v2(34.19,14.8) 34.29,14.9 CR214.1 ; CZ517.1 186.64,86.92 CZ513.2 186.64,85.42 CZ529.2 ; v2(24.87,21.33) 24.68,21.52 CT372.2 ; v2(152.54,39.08) 152.54,38.23 CV934.2 ; CH47.2 196.58,32.7 CH34.2 ; CH29.2 195.51,52.79 v2(195.18,53.13) ; v2(194.58,36.93) 195.14,36.93 195.44,36.62 CH38.2 ; CH21.2 174.78,37.52 175.31,36.99 v2(175.31,36.92) ; v2(71.84,49.33) 71.84,48.68 CN177.2 ; v2(279.97,9.58) 280.78,10.39 CZ17.2 ; v2(167.74,45.11) 168.46,44.4 CH67.2 168.84,44.14 169.01,44.31 CH323.2 ; CR246.1 CR245.1 29.79,8.35 v2(30.39,8.35) ; CT380.1 59.45,20.2 RT577.1 60.15,20.21 CT379.2 60.17,20 v2(59.67,19.49) 59.67,19.17 59.37,18.88 58.76,18.88 57.96,19.68 RT575.1 ; CE342.2 v2(11.54,7.91) ; CZ92.2 292.98,13.2 v2(292.98,13.42) ; v2(134.1,15.51) 134.1,15.51 134.1,15.39 134.55,14.94 CE66.2 ; v2(278.51,89.8) CC269.2 ; CZ91.2 290.48,12.8 v2(289.88,13.4) 289.17,12.69 CZ90.2 ; v2(171.52,15.4) 171.54,15.4 171.59,15.45 CH65.2 ; v2(343.4,21.26) 343.36,21.3 CA226.2 ; CV954.2 74.78,55.97 v2(74.41,56.34) ; CZ516.1 186.61,88.54 CZ518.2 186.61,89.89 CZ528.2 ; CT373.2 30.17,26.3 RT544.2
  BOTTOM w0.381: CZ532.2 336.79,21.85 v2(336.4,22.24) 335.9,21.74 CZ531.2 ; v2(159.85,19.72) 159.3,20.27 RH640.2 ; JESPI.11 167.8,17.46 167.66,17.6 v2(167.32,17.6) ; v2(70.93,26.78) 72.24,25.47 QT8.3 ; RT536.2 48.96,35.73 48.35,36.34 v2(48.35,36.67) ; v2(23.45,19.96) 23.42,19.99 CR242.2 ; CD20.2 CD22.2 CD21.2 v2(243.03,32.98) ; v2(249.38,85.71) 250.41,86.73 CC171.2 ; RT617.2 51.02,28.58 v2(51.21,28.77) ; RD89.1 201.27,56.5 v2(200.08,56.5) ; QT4.1 37.25,26.17 37.48,26.39 v2(37.48,26.61) ; CC172.2 245.41,87.01 v2(244.24,85.84) ; CD15.2 v2(249.67,64.88) 248.67,63.88 CD113.2 ; CE57.2 135.68,24.23 v2(135.88,24.03) ; CD93.2 CD30.2 211.24,64.09 212.6,62.73 v2(212.6,62.01) ; 140.12,22.88 140.67,22.88 v2(140.81,22.74) ; CD48.2 251.21,62.74 250.36,61.9 v2(249.69,61.9) ; CT20.2 20.94,29.14 20.63,28.82 v2(20.63,28.39) ; RH641.2 CH349.2 156.47,32.14 v2(156.37,32.04) ; v2(129.18,21.28) 129.18,21.03 129.25,20.96 CE20.2 ; CV957.2 174.03,92.9 CV805.2 ; CT378.1 43.95,27.83 RT573.1 45.05,27.83 45.15,27.73 CT370.1 45.93,28.02 v2(46.49,28.59) ; v2(227.75,65.55) 228.1,65.21 CD82.2 CD83.2 ; v2(66.25,22.18) 65.32,22.18 65.05,22.45 RT610.1 ; v2(254.4,64.3) 254.07,63.97 CD117.2 253.43,63.97 CD108.2 ; v2(11.48,46.5) 11.49,46.49 DT8.3 ; v2(42.01,27.74) 42.11,27.64 42.8,27.64 RT571.1 ; UH7.3 46.99,40.28 47.28,40.57 47.78,40.57 48.02,40.81 48.02,40.95 ; CC83.2 222.07,86.05 v2(222.47,85.65) ; CE62.2 121.87,26.89 v2(122.06,26.71) ; CT371.1 64.72,24.76 64.93,24.54 RT618.2 65.47,24.9 65.67,25.1 v2(65.67,25.3) ; v2(194.67,111.91) 194.51,111.75 CV61.2 ; v2(42.17,38.17) 42.45,37.9 43.08,37.9 43.4,38.22 RH65.2 ; CH348.2 162.04,19.6 162.04,20.28 v2(162.05,20.29) ; CD55.2 247.75,33.96 v2(247.76,33.95) ; CC323.2 200.64,116.74 v2(200.81,116.56) ; RH632.2 134.36,16.87 CH347.2 134.1,16.01 v2(134.1,15.51) ; CD56.2 237.2,31.67 236.41,30.87 RD12.2 ; v2(232.11,86.66) 232.41,86.66 232.7,86.95 CC165.2 ; CV932.2 149.67,37.44 147.28,37.44 v2(146.9,37.82) ; v2(214.55,34.78) 214.64,34.69 CD53.2 ; CT355.2 48.74,31.97 v2(48.88,32.11) ; v2(148.04,44.32) 147.96,44.32 CV925.2 ; v2(29.29,13.15) 29.18,13.27 CR247.2 28.72,14.03 RR205.2 ; v2(144.48,36.39) 144.49,36.41 CV938.2 ; CH34.2 197.12,32.64 RH733.2 ; QT4.4 35.56,28.28 35.32,28.51 v2(35.32,29.33) ; v2(342.95,28.39) 343.14,28.2 QN1.1 ; CT361.2 12.35,62.79 v2(12.35,62.57) ; CD23.2 v2(247.7,30.56) ; CR200.2 14.87,16.84 v2(14.43,16.84) ; PQ7.1 55.95,20.07 56.3,20.43 v2(56.3,20.85) ; CD26.2 230.51,33.49 230.09,33.06 v2(230.09,32.6) ; CD51.2 CD18.2 v2(247.48,32.47) ; v2(215.25,31.6) 215.25,31.6 CD81.2 ; CC319.2 168.96,30.22 169.83,31.08 v2(169.83,31.4) ; RD51.2 201.93,59.02 RD42.2 202.74,59.26 203.5,60.02 203.5,60.87 202.44,61.93 202.44,65.67 v2(202.56,65.8) ; PH1104.2 266.89,131.36 v2(266.88,131.35) ; v2(222.72,107.28) 223.04,107.59 PC1617.2 ; v2(169.53,36.68) 169.44,36.76 168.66,36.76 ; CZ37.2 345.49,50.48 v2(345.81,50.8) ; JDEG1.11 v2(54.75,7.29) ; RT506.2 37.75,47.12 RT507.2 ; RT506.2 37.63,47.85 v2(37.62,47.86) ; RT506.2 37.35,47.24 37.24,47.12 36.87,47.12 36.86,47.11 RT505.2 ; RT33.2 35.61,49.56 v2(35.61,50.07) ; CD120.2 CD121.2 247.02,62.38 v2(246.9,62.27) ; v2(32.06,49.45) 32.06,48.77 31.88,48.59 RT508.2 ; v2(118.32,22.14) 118.23,22.05 CZ75.2 ; v2(175.31,36.92) 175.03,36.63 CH22.2 ; CA69.2 347.2,15.15 RA221.1 348.6,15.15 349.03,14.72 v2(349.03,14.2) ; CV902.2 174.93,78.4 CV903.2 175.62,77.99 v2(175.87,77.74) ; JNGFF3.69 77.94,30.39 v2(77.94,31.01) ; v2(55.37,13.8) 54.77,13.8 PQ8.4 53.65,12.92 52.35,11.62 PQ8.1 ; v2(246.93,61.59) 246.31,61.59 245.5,62.41 CD119.2 ; v2(199.78,39.21) 199.83,39.17 CD58.2 CD59.2 ; RH610.1 170.3,45.25 RH611.1 170.26,45.3 169.02,45.3 v2(168.96,45.24) ; 48.02,40.95 48.67,40.3 49.32,40.3 49.59,40.02 JCCG1.11 ; 48.02,40.95 v2(48.02,41.46) ; PC1101.1 264.92,151.07 v2(264.92,151.73) ; RT585.2 72.95,21.4 73.83,20.52 v2(73.83,20.37) ; v2(167.08,10.96) JESPI.12 ; CC161.2 230.28,87.11 229.79,86.63 v2(229.6,86.63) ; QN1.4 344.44,25.61 344.84,25.2 v2(345.36,25.2) ; CC167.2 234.45,87.31 v2(234.18,87.04) ; RT523.2 59.87,38.84 v2(59.87,37.72) ; v2(252.85,34) 252.84,34.01 CD17.2 ; v2(226.64,86.81) 226.75,86.69 227.4,86.69 227.79,87.09 CC163.2 ; 70.21,8.22 v2(70.1,8.32) ; PQ9.1 55.19,25.23 54.59,24.63 v2(54.59,24.38) ; RH268.2 163.76,28.67 v2(163.3,28.2) ; CC81.2 256.37,87.79 v2(256.64,88.07) ; CH9.2 137.83,42.05 v2(138.34,41.55) ; v2(33.49,19.81) 34.01,19.29 CR215.2 ; CD80.2 219.84,65.86 v2(219.73,65.97) ; CD52.2 222.2,32.51 v2(222.19,32.5) 222.12,32.43 CD114.2 ; v2(139.33,18.25) 139.59,17.99 RH638.2 140.24,17.99 140.45,17.77 CH343.2 ; v2(249.61,67.32) 249.05,67.32 248.67,66.94 CD78.2 ; PR1168.2 v2(264.11,132.7) ; QZ18.1 v2(338.04,3.09) ; CD60.2 v2(230.1,31.71)
  BOTTOM w0.406: v2(174.07,93.78) 174.11,93.74 CV957.2
  BOTTOM w0.457: v2(347.33,23.23) 347.39,23.29 RA227.1 ; CV930.2 145.26,40.71 v2(145.72,41.17) ; v2(51.75,36.53) 51.75,36.24 52.15,35.84 RT537.2 ; v2(54.75,7.29) 54.38,7.29 53.99,6.91 RE86.2 ; v2(29.87,27.23) 29.87,26.62 RT544.2 ; RH554.2 170.4,33.67 170.74,33.33 v2(170.74,33.3) 170.74,32.57 RH556.2 ; RH110.1 191.33,46.7 192.32,45.71 v2(192.32,45.55) ; CMOS1.1 164,18.3 v2(163.5,17.8) ; v2(188.59,89.89) 187.45,89.89 187.26,90.09 CZ528.2 ; CA228.2 352,28.3 RA225.2 352,29.27 352.39,29.66 v2(352.39,29.86) ; v2(144.56,41.17) 144.44,41.17 CV931.2 ; v2(177.32,21.26) 177.32,20.44 RH424.2 ; RA226.1 v2(350.24,28)
  BOTTOM w0.508: PC122.2 63.73,21.29 v2(63.73,21.9) ; PC301.2 277.63,107.9 v2(277.69,107.97) ; CD68.2 216.37,31.2 v2(216.38,31.2) ; v2(187.77,87.14) 186.86,87.14 CZ517.1 ; PC1318.2 242.01,122.21 v2(241.59,122.21) ; RT42.1 15.53,37.43 RT41.1 15.51,37.11 15.15,36.75 15.15,35.92 v2(15.35,35.72) ; PC7.2 v2(14.28,36.58) 14.28,37.83 13.28,38.83 DT4.1 ; RV834.2 117.67,42.51 v2(117.83,42.67) ; RC219.1 277.64,88.83 v2(277.73,88.73) ; CD40.2 243.15,34.14 v2(242.84,34.44) ; CC168.2 237.01,87.35 v2(236.69,87.04) ; CL28.2 183.38,121.86 v2(184.22,121.02) ; v2(12.86,20.75) 12.79,20.68 UR3.4 ; v2(196.27,128.48) 195.82,128.03 RL12.2 ; RC321.2 279.29,79.57 v2(279.58,79.27) ; v2(318.68,12.92) 318.68,13.91 v2(319.35,14.58) ; v2(235.1,103.33) 235.08,103.31 PC1420.2 ; 17.45,18.29 v2(18.74,19.59) 18.22,20.11 RR239.1 ; v2(312.22,1.91) 312.21,1.92 309.59,1.92 309.1,2.41 JNGFF2.69 ; PC1398.2 234.93,119.98 v2(234.86,119.91) ; CD118.2 260.53,32.11 CD7.2 261.71,32.66 v2(261.77,32.6) ; PC307.2 273.71,110.96 v2(273.69,110.98) ; CE12.2 131.02,39.14 v2(131.02,39.87) ; v2(198.39,59.49) 197.96,59.92 RD79.1 ; CN174.2 88.23,29.76 CN176.2 87.34,29.76 CN175.2 86.42,29.75 CN178.2 86.1,29.45 v2(85.57,29.45) ; v2(325.52,14.48) 325.12,14.08 323.85,14.08 v2(323.55,14.37) ; v2(78.88,62.02) 78.49,61.62 QV43.3 ; PC1397.2 v2(238.2,121.24) ; CV956.2 176.41,78.12 176.02,77.74 v2(175.87,77.74) ; 176.2,63.27 176.2,62.91 v2(175.54,62.25) ; v2(197.33,63.81) 197.49,63.81 197.99,63.3 RD80.1 ; v2(339.06,45.81) 339.37,45.5 341.03,45.5 JSIM1.10 ; CR248.1 v2(29.73,12.42) ; v2(195.22,120.59) 194.46,121.36 CV60.2 ; CD73.2 241.13,30.87 241.84,31.58 v2(241.84,31.93) ; v2(244.83,122.21) 245.25,122.21 PC1310.2 ; v2(254.89,30.53) 254.9,30.52 CD12.2 ; CD72.2 218.7,66.1 219.21,66.61 v2(219.73,66.61) ; v2(200.52,44.21) 200.65,44.34 CD63.2 201.54,44 CD62.2 201.5,43.25 RD82.1 ; CA4.1 350.76,15.24 CA1.1 350.75,14.82 v2(351,14.57) ; v2(234.88,121.1) 234.97,121.19 PC1396.2 ; v2(21.87,25) 21.8,25.07 YT1.2 ; CD6.2 CD13.2 270.07,34.57 v2(269.49,35.15) ; PC1130.2 261.85,138.27 262.21,137.91 v2(262.21,137.16) ; RD90.1 200.47,53.28 v2(200.01,52.82) 198.68,52.82 198.33,53.18 198.33,53.6 198.63,53.9 RD43.2 ; v2(180.66,114.13) 180.1,113.56 RV903.2 ; v2(254.1,86.86) 253.67,87.29 CC84.2 ; v2(185.88,133.22) 185.88,133.01 RL13.2 ; v2(210.53,30) 210.33,29.8 JDIMM2.262 ; RR232.2 v2(28.84,15.4) ; v2(238.19,122.21) 238.61,122.21 PC1315.2 ; CD34.2 285.74,70.91 v2(286.35,70.3) ; v2(142.22,44.32) 142.61,44.71 CV926.2 142.61,45.77 CV929.2 ; PC24.2 340.44,6.51 v2(340.44,6.06) ; v2(253.42,31.67) 253.34,31.58 CD39.2 ; v2(210.48,28.94) 209.11,28.94 JDIMM2.262 ; v2(171.52,15.4) 170.81,15.4 RC75.2 ; RC171.1 258.54,82.45 v2(258.22,82.77) ; v2(264.43,99.62) 265.1,98.95 CC568.2 ; v2(137.56,45.13) 138.17,45.74 CH322.2 ; v2(278.56,86.27) 279.08,85.74 CC33.2 ; RH379.2 181.69,28.14 v2(182.24,28.69) ; v2(187.51,27.37) 187.98,27.37 188.42,26.93 CC328.2 ; CD70.2 226.95,65.72 227.45,66.21 v2(227.72,66.21) 229.24,66.21 230.13,65.33 CD69.2 ; v2(339.33,34.17) 340.71,34.17 JSIM1.12 340.67,34.86 v2(339.33,34.86) ; RD87.1 197.66,58.72 v2(197.73,58.78) ; v2(231.47,120.95) 231.72,121.19 PC1395.2 ; v2(195.08,93.68) 195.33,93.68 195.72,93.29 CC301.2 ; RV835.1 99.91,36.28 v2(100.37,35.83) ; PR115.2 64.12,11.53 v2(63.84,11.8) 64.42,12.37 PC129.2 ; RD12.2 235.99,30.63 v2(235.99,30.05) ; PC1419.2 v2(235.1,104.23) ; v2(346.91,50.89) 346.7,50.67 CZ40.2 ; JNGFF1.69 336.5,9.05 336.11,8.65 v2(335.39,8.65) ; CC170.2 239.54,87.03 v2(239.17,87.03) ; PC1306.2 v2(241.59,121.25) ; v2(194.59,34.72) 195.04,34.72 195.95,33.81 CH47.2 ; v2(232.74,67.88) 231.83,66.97 CD94.2 CD95.2 CD97.2 231.33,62.71 231.33,61.75 231.68,61.41 ; RD81.1 200.85,37.08 v2(200.68,37.26) ; v2(131.23,12.35) 131.23,13 131.19,13.03 CE3.2 ; QZ18.4 v2(339.34,3.15) ; v2(264.3,31.58) CD10.2 ; CV818.1 97.43,37.37 v2(97.07,37.01) 97.07,36.72 97.37,36.43 RV832.2 ; CC325.2 259.58,120.07 v2(259.24,119.73) ; v2(275.77,111.68) PC308.2 ; CD9.2 254.9,31.82 v2(254.89,31.84) ; QA10.3 353.91,14.49 v2(353.84,14.56) ; PC121.2 62.67,21.8 62.64,21.83 v2(62.64,21.85) ; v2(230.09,32.6) CD61.2 ; JSIM1.7 v2(346.25,48.01) ; CV881.2 CV882.2 155.11,47.49 v2(155.48,47.12) ; RE567.2 v2(7.28,17.58) ; PR732.2 57.44,14.82 v2(57.44,15.52) ; CD44.2 221.54,34.35 v2(221.08,34.81) ; CT189.2 8.14,35.93 v2(8.71,35.36) ; PC1402.2 235.08,101.5 v2(235.1,101.52) ; CD109.2 242.89,28.9 v2(242.52,29.27) ; PC120.2 v2(61.45,21.87) ; v2(354.65,29.19) 354.63,29.21 RA209.2 ; v2(241.72,87.04) 242.29,87.04 CC82.2 ; UT7.2 28.35,21.37 v2(28.76,21.77) 29.44,22.46 CT374.2 ; v2(253.41,32.85) CD42.2 ; v2(279.97,9.58) 280.06,9.49 CZ19.2 ; v2(242.51,30.17) CD43.2 ; PC1316.2 235.3,122.16 v2(234.88,122.16) ; v2(265.37,34.46) 265.8,34.03 CD19.2 ; CH32.2 198.16,45.11 v2(198.78,45.74) ; v2(354.64,28.36) 353.93,28.36 353.91,28.38 CA227.2 ; CD107.2 CD104.2 246.07,66.55 v2(246.9,67.39) ; RT509.2 RT23.2 33.53,49.92 v2(33.33,50.12) ; v2(269.84,132.15) PC1708.2 271.36,132.15 272.06,131.45 PC1707.1 ; CE10.2 128.69,38.19 128.69,36.77 128.67,36.75 v2(128.67,36.71) ; v2(256.09,34.93) 255.78,34.62 CD16.2 ; v2(230.1,31.71) 230.1,31.12 230.4,30.82 RD11.2 CD29.2 CD28.2 ; v2(186.04,118.09) 185.42,118.72 RL9.2 ; CV854.2 75.31,33.03 v2(75.37,33.08) ; v2(241,29.74) CD115.2 CD116.2 ; CV920.2 154.21,40.88 154.73,40.37 v2(155.72,40.37) ; RH313.2 182.97,44.78 183.32,45.13 183.32,46.14 v2(183.08,46.39) ; v2(184.65,128.59) 184.36,128.88 CL13.2 183.84,129.04 Y1.2 ; v2(280.58,85.1) 280.24,84.75 280.24,84.12 RC181.2 RC436.2 ; v2(235.1,102.42) 235.08,102.4 PC1409.2 ; RV833.2 117.03,38.99 v2(116.91,38.99) ; CV911.2 CV914.2 71.54,27.89 v2(71.92,27.51) ; JDIMM2.262 209.11,30.66 v2(210.5,30.66) ; CC166.2 247.9,88.29 247.63,88.56 247.2,88.56 v2(247.2,88.56) ; v2(119.95,37.59) 119.61,37.93 RV831.2 ; CE54.2 128.1,25.95 v2(127.26,26.78) ; RV830.2 107.54,44.43 107.32,44.65 v2(107.32,45.17) ; CE47.2 140.01,21.94 v2(140.81,22.74) ; v2(268.86,98.66) 268.86,98.14 PR314.2 ; v2(243.43,62.34) 243.45,62.36 CD111.2 CD110.2 v2(243.45,66.61) ; PC1128.1 PC1127.2 260.06,138.08 v2(259.74,137.76) ; CD11.2 v2(247.91,29.48) ; PC1317.2 231.9,122.16 v2(231.48,122.16) ; v2(234.53,34.28) 235.5,35.25 CD85.2 ; PR308.2 268.74,100.37 268.26,100.85 PR310.1 267.81,100.84 267.81,100.27 v2(267.9,100.18) ; v2(131.42,18.1) 131.33,18.01 CE4.2 131.33,16.47 RE313.2 ; RV829.2 118.51,36.94 v2(119.08,36.94) ; RE568.2 v2(9.68,7.88) ; CL8.2 179.77,123.88 v2(179.47,123.58) ; v2(289.54,4.19) 289.39,4.19 JNGFF2.68 ; CV921.2 151.11,42 v2(150.37,42.75) ; RH630.1 178.24,38.25 178.69,37.8 v2(178.89,37.8) ; v2(194.18,57.83) 194.79,58.45 RD18.2 ; CD74.2 v2(240.18,64.54) ; CD98.2 194.87,57.31 v2(194.75,57.19) 194.75,56.81 CD99.2 ; Y1.4 v2(181.01,130.18) ; PC1399.2 v2(238.22,119.97) ; CC187.2 223.2,97.35 222.9,97.65 222.27,97.65 v2(222.11,97.81) ; QT5.3 67.92,22.22 68.02,22.22 68.14,22.34 68.19,22.34 v2(68.77,22.92) 68.88,23.03 68.88,23.41 RE702.2 ; v2(219.73,67.24) 220.29,67.24 220.98,66.55 CD75.2 ; v2(281.87,6.72) 281.56,7.04 CZ198.2 281.21,7.08 CZ21.2 ; CD8.2 261.76,33.93 v2(261.82,33.87) ; RV892.2 68.61,27.66 v2(68.72,27.55) ; CZ38.2 348.17,50.66 v2(348.17,50.97) 348.76,50.39 CZ39.2 ; CC569.2 201.44,112.34 v2(200.98,111.87) ; PC1307.2 v2(244.83,121.25) ; v2(199.29,38.15) CD57.2 ; RV897.2 145.51,44.54 v2(145.72,44.32) ; RD83.1 v2(230.02,28.98) ; RH349.2 179.57,47.35 RH1.1 178.56,48.25 v2(178.78,48.47) ; JSIM1.11 v2(356.03,34.5) ; RH372.2 v2(165.43,37.33) ; PC1416.2 v2(235.1,105.14) ; v2(154.11,10.31) 154.38,10.04 PR811.1 ; CH266.2 173.24,18.18 173.65,18.58 v2(173.65,18.99) 173.69,19.04 173.69,20.39 172.39,21.68 RH308.2 172.66,22.1 RH83.2 ; v2(241.47,34.68) 241.13,34.34 CD45.2 240.74,33.05 CD41.2 ; CZ515.1 182.41,70.37 v2(182.85,69.93) ; JSIM1.9 v2(356.55,45.5) ; CL3.2 v2(184.21,122.5) ; v2(102.78,26.77) 103.83,27.82 CZ521.1 104.55,28.24 ; CD33.2 213.18,34.26 v2(212.6,34.85) ; PC1400.2 v2(241.59,120.01) ; v2(277.79,81.43) 277.31,80.95 275.82,80.95 272.37,77.5 271.03,77.5 270.52,78.01 CD77.2 ; v2(136.53,12.27) 136.57,12.31 CZ63.2 137.66,12.95 CZ62.2 ; CD46.2 v2(253.4,30.31) ; v2(336.51,28.21) CZ121.2 ; CD5.2 v2(249.61,67.32) ; v2(182.06,118.34) 182.37,118.66 183.23,118.66 183.52,118.95 RL3.2 ; v2(24.68,29.07) 24.62,29.14 CT21.2 23.92,29.02 YT1.4 ; QV2.3 v2(83.18,61.61) ; UC5.4 129.89,45 ; RV842.1 106.09,48.37 v2(106.38,48.07) ; CD54.2 v2(241.04,31.93) ; RV836.2 v2(110.3,49.21) ; CL14.2 184.38,131.58 v2(184.69,131.27)
  vias: v2(0.45,41.65) v2(1.75,55.25) v2(1.98,71.45) v2(2.1,39.05) v2(2.67,56.86) v2(2.67,53.64) v2(2.78,31.64) v2(2.78,24.02) v2(2.78,16.37) v2(2.78,8.76) v2(2.96,69.83) v2(3.02,73.06) v2(3.02,40.66) v2(3.02,37.44) v2(3.29,2.87) v2(3.28,0.44) v2(3.3,5.29) v2(3.88,33.83) v2(4,8.35) v2(4.26,4.54) v2(4.22,1.29) v2(4.32,28.62) v2(4.53,56.86) v2(4.53,53.64) v2(4.88,73.06) v2(4.88,69.84) v2(4.88,40.66) v2(4.88,37.44) v2(5.19,32.79) v2(5.16,24.34) v2(5.45,55.25) v2(5.73,25.81) v2(5.8,71.45) v2(5.8,39.05) v2(6.08,4.51) v2(6.36,1.4) v2(6.48,41.82) v2(6.61,0.43) v2(6.73,58.1) v2(7.01,60.04) v2(7.05,43.79) v2(7.09,41.78) v2(7,2.9) v2(7.18,50.49) v2(7.2,66.6) v2(7.33,58.11) v2(7.69,41.91) v2(7.79,66.48) v2(7.77,50.49) v2(8.24,14.18) v2(8.24,12.04) v2(8.65,25.3) v2(8.68,24.57) v2(8.73,20.55) v2(9.17,32.83) v2(9.17,31.96) v2(9.17,31.06) v2(9.14,20.98) v2(9.3,13.11) v2(9.8,70.1) v2(9.72,21.62) v2(10.24,19.04) v2(10.37,14.18) v2(10.37,12.04) v2(10.42,4.02) v2(10.72,71.71) v2(10.72,68.49) v2(10.81,28.1) v2(11.64,53.7) v2(11.84,73.47) v2(12.58,71.71) v2(12.58,68.49) v2(13.5,70.1) v2(13.97,54.02) v2(13.95,0.43) v2(14.4,14.85) v2(14.9,15.18) v2(15.36,35.12) v2(15.93,67.98) v2(15.96,11.49) v2(16.58,11.5) v2(17.15,33.84) v2(17.18,31.98) v2(17.46,36.55) v2(17.8,64.88) v2(17.73,56.14) v2(18.23,55.78) v2(18.4,30.78) v2(18.4,29.94) v2(18.71,56.18) v2(18.8,27.28) v2(19.12,56.63) v2(20.11,22.88) v2(20.12,13.25) v2(20.57,61.75) v2(20.59,6.79) v2(20.89,32.49) v2(21.09,10.05) v2(21.05,6.35) v2(21.16,20.54) v2(21.27,41.79) v2(21.27,40.47) v2(21.38,6.96) v2(21.52,47.39) v2(21.57,0.43) v2(22.09,17.18) v2(22.09,15.22) v2(22.09,13.25) v2(22.27,37.14) v2(22.27,35.85) v2(22.68,31.25) v2(23.32,6.9) v2(23.55,32.8) v2(23.71,22.98) v2(23.95,31.22) v2(24.08,48.85) v2(24.06,17.18) v2(24.06,15.22) v2(24.06,13.25) v2(24.03,6.91) v2(24.6,39.06) v2(24.61,38.13) v2(24.91,1.78) v2(25.22,58.11) v2(26.68,46.98) v2(26.8,49) v2(26.93,28.6) v2(26.95,26.43) v2(27.13,7.47) v2(27.14,6.82) v2(27.39,53.22) v2(27.4,42.19) v2(27.74,6.84) v2(27.88,53.58) v2(28.06,40.89) v2(28.22,25.3) v2(28.39,53.23) v2(28.48,26.17) v2(28.48,17.64) v2(28.49,17.01) v2(29.19,0.43) v2(29.26,44.21) v2(29.39,50.71) v2(29.33,27.45) v2(29.71,55.6) v2(29.78,28.85) v2(30.01,36.99) v2(30.01,35.04) v2(30.1,30.65) v2(30.16,27.75) v2(30.66,38.94) v2(30.9,51.32) v2(31.1,2.9) v2(31.8,1.41) v2(31.96,36.99) v2(31.97,35.68) v2(31.96,35.04) v2(32.02,4.51) v2(32.19,50.71) v2(32.54,47.96) v2(32.54,47.37) v2(32.68,19.85) v2(32.8,29.32) v2(33.05,47.67) v2(33.08,28.79) v2(33.15,20.28) v2(33.77,29.9) v2(33.88,4.51) v2(33.9,39.59) v2(34.09,1.41) v2(34.56,39.59) v2(34.8,2.9) v2(34.96,53.64) v2(36.49,30.34) v2(36.81,0.43) v2(39.54,30.96) v2(39.55,30.37) v2(41.33,52.43) v2(43.13,39.59) v2(43.15,36.55) v2(44.43,0.43) v2(44.74,35.45) v2(45.77,52.27) v2(47.31,50.8) v2(48.25,42.97) v2(50.63,41.43) v2(52.05,0.43) v2(52.69,26.99) v2(52.76,2.67) v2(53.04,21.94) v2(53.2,3.32) v2(53.37,2.72) v2(53.44,21.51) v2(53.82,42.97) v2(53.85,3.29) v2(54.04,32.04) v2(54,2.71) v2(54.51,3.29) v2(54.66,2.72) v2(55.19,3.27) v2(55.29,2.67) v2(55.9,2.7) v2(56.37,31.87) v2(56.36,31.28) v2(57.22,26.65) v2(57.84,2.81) v2(58.05,7.31) v2(58.57,27.42) v2(58.78,7.31) v2(58.93,41.9) v2(59.67,0.43) v2(60.76,41.92) v2(61.44,42.97) v2(62.53,41.94) v2(62.78,35.28) v2(62.78,33.71) v2(62.78,32.13) v2(63.24,15.74) v2(63.29,15.08) v2(63.75,30.3) v2(63.76,29.72) v2(63.95,35.28) v2(63.95,33.71) v2(63.95,32.13) v2(64.37,41.93) v2(65.12,35.28) v2(65.12,33.71) v2(65.12,32.13) v2(66.29,35.28) v2(66.29,33.71) v2(66.29,32.13) v2(66.48,49.62) v2(66.48,44.37) v2(67.29,0.43) v2(67.35,56.29) v2(67.43,35.28) v2(67.43,33.71) v2(67.43,32.13) v2(67.46,7.26) v2(67.7,54.15) v2(67.64,7.83) v2(67.91,8.61) v2(67.98,6.94) v2(68.04,9.43) v2(68.24,7.92) v2(68.49,9.05) v2(68.49,8.46) v2(68.6,35.28) v2(68.6,33.71) v2(68.6,32.13) v2(68.51,7.36) v2(68.62,55.76) v2(68.62,52.54) v2(68.68,13.58) v2(68.92,7.9) v2(69.07,9.12) v2(69.08,8.5) v2(69.33,26.05) v2(69.54,8.14) v2(69.64,47.06) v2(69.77,35.28) v2(69.77,33.71) v2(69.77,32.13) v2(69.88,48.91) v2(70.48,55.76) v2(70.48,52.54) v2(70.86,39.17) v2(70.93,35.28) v2(70.93,33.71) v2(70.93,32.13) v2(71.4,54.15) v2(72.65,57.84) v2(72.91,44.63) v2(73.29,61.68) v2(73.56,45.29) v2(73.53,30.51) v2(73.78,19.42) v2(73.89,17.31) v2(73.87,16.46) v2(73.89,13.52) v2(73.92,14.33) v2(74.81,34.41) v2(74.91,0.43) v2(75.19,50.89) v2(75.19,50.3) v2(75.5,51.39) v2(76.1,51.39) v2(77.64,65.47) v2(78.21,39.39) v2(78.38,7.75) v2(78.79,31.22) v2(78.86,23.75) v2(79.04,7.75) v2(79.67,7.74) v2(79.88,19.62) v2(80.1,28.52) v2(80.22,20.9) v2(80.58,48.36) v2(80.67,18.27) v2(81.19,16.15) v2(81.29,48.35) v2(81.52,53.22) v2(81.55,52.43) v2(81.7,19.43) v2(82.17,63.99) v2(82.55,60.16) v2(82.54,15.01) v2(82.53,0.43) v2(83.39,62.83) v2(83.42,53.88) v2(83.64,65.47) v2(83.89,8.17) v2(84.34,25.82) v2(84.52,58.8) v2(84.66,26.41) v2(84.67,8.18) v2(84.93,25.82) v2(85,51.58) v2(85.1,13.55) v2(85.11,10.56) v2(85.19,9.05) v2(85.26,26.41) v2(85.51,25.82) v2(85.7,10.58) v2(85.98,13.55) v2(85.94,9.06) v2(86.73,13.55) v2(87.29,33.53) v2(87.43,19.45) v2(87.51,13.56) v2(87.98,18.92) v2(87.96,17.69) v2(88.04,19.56) v2(88.01,18.29) v2(88.6,18.93) v2(88.57,17.71) v2(88.66,19.62) v2(88.62,18.34) v2(89.24,26.82) v2(89.33,33.81) v2(89.62,51.47) v2(90.15,0.43) v2(90.87,4.3) v2(91.01,4.87) v2(91.21,43.22) v2(91.47,4.3) v2(91.67,4.86) v2(91.92,10.44) v2(92.26,43.11) v2(93.19,24.13) v2(93.87,24.13) v2(94.5,24.13) v2(96.17,35.59) v2(96.75,35.59) v2(97.24,51.47) v2(97.77,0.43) v2(101.13,33.09) v2(101.25,33.87) v2(101.22,31.23) v2(102.34,40.77) v2(102.73,34.29) v2(103.14,37.85) v2(104.29,44.39) v2(104.86,51.47) v2(105.09,34.37) v2(105.37,44.4) v2(105.39,0.43) v2(105.45,30.92) v2(105.49,17.62) v2(106.14,17.62) v2(106.84,17.63) v2(107.01,48.06) v2(107.55,17.64) v2(108.05,14.11) v2(108.22,17.65) v2(108.64,14.11) v2(108.84,17.64) v2(109.09,30.52) v2(109.52,17.64) v2(109.99,46.61) v2(109.97,7.35) v2(110.17,39.64) v2(110.17,38.37) v2(110.17,37.1) v2(110.72,46.36) v2(110.74,30.61) v2(111.38,46.34) v2(112.03,24.18) v2(112.34,51.47) v2(112.35,39.64) v2(112.35,38.37) v2(112.35,37.1) v2(112.49,7.35) v2(112.64,24.18) v2(113.01,0.43) v2(113.18,30.82) v2(113.25,46.21) v2(114.53,39.64) v2(114.53,37.1) v2(115.47,6.46) v2(115.51,8) v2(116.09,8.59) v2(116.1,8) v2(116.05,6.46) v2(116.7,7.99) v2(117.41,8.58) v2(117.4,7.99) v2(118,7.99) v2(118.01,8.58) v2(118.36,50.47) v2(118.32,23.66) v2(118.59,7.99) v2(118.59,7.35) v2(118.62,8.58) v2(119.19,7.98) v2(119.18,7.36) v2(119.2,8.58) v2(119.84,22.14) v2(120.63,0.43) v2(121.37,23.66) v2(122.62,18.99) v2(123.23,18.99) v2(124.69,50.47) v2(128.25,0.43) v2(128.44,5.66) v2(128.79,2.73) v2(129.41,2.75) v2(130.9,45.89) v2(131.33,50.47) v2(131.64,45.92) v2(132.42,45.86) v2(135.74,51.47) v2(135.87,0.43) v2(136.47,7.36) v2(137.08,7.38) v2(137.75,7.37) v2(138.34,7.37) v2(140.36,50.11) v2(140.59,6.21) v2(140.69,36.15) v2(140.99,6.65) v2(141.29,36.15) v2(141.57,6.65) v2(141.77,28.8) v2(142.15,49.97) v2(142.15,6.65) v2(142.22,42.75) v2(142.22,41.17) v2(142.74,6.65) v2(143.3,9.02) v2(143.36,51.47) v2(143.39,44.32) v2(143.39,42.75) v2(143.39,41.17) v2(143.35,8.34) v2(143.32,6.65) v2(143.49,0.43) v2(143.88,9.02) v2(143.93,49.99) v2(143.93,8.34) v2(144.46,9.02) v2(144.56,44.32) v2(144.56,42.75) v2(144.52,8.34) v2(145.66,49.99) v2(145.72,42.75) v2(146.87,44.32) v2(146.87,42.75) v2(146.87,41.17) v2(147.28,38.62) v2(147.51,50.02) v2(147.8,38.23) v2(148.04,42.75) v2(148.04,41.17) v2(148.54,18.37) v2(149.18,18.57) v2(149.27,50.02) v2(149.2,42.75) v2(149.2,41.17) v2(150.37,44.32) v2(150.37,41.17) v2(150.98,51.47) v2(151.07,50.02) v2(151.11,38.7) v2(151.11,0.43) v2(152.65,13.52) v2(152.65,11.58) v2(153.24,12.55) v2(153.84,13.52) v2(153.84,11.58) v2(155.73,52.17) v2(157.93,49.18) v2(158.73,0.43) v2(159.92,4.79) v2(160.64,57.08) v2(160.72,4.79) v2(161.4,4.76) v2(162.14,4.78) v2(162.44,53.69) v2(162.86,54.12) v2(162.94,4.78) v2(163.68,0.43) v2(165.09,61.52) v2(166.8,3.4) v2(167.72,5.01) v2(167.72,1.79) v2(168.88,150.43) v2(168.88,142.81) v2(168.88,135.19) v2(168.88,127.57) v2(168.88,119.95) v2(168.88,112.33) v2(168.88,104.71) v2(168.88,97.09) v2(168.88,89.47) v2(168.88,81.85) v2(168.88,76.65) v2(168.88,66.54) v2(169.58,5.01) v2(169.58,1.79) v2(170.16,118.19) v2(170.25,72.4) v2(170.57,114.31) v2(170.5,3.4) v2(170.64,117.24) v2(170.63,113.6) v2(171.07,116.77) v2(171.11,114.65) v2(171.14,113.94) v2(171.17,74.01) v2(171.17,70.79) v2(172.3,154.07) v2(172.23,134.2) v2(172.93,141.45) v2(173.03,74.01) v2(173.03,70.79) v2(173.09,43.26) v2(173.14,142.76) v2(173.11,42.65) v2(173.93,142.76) v2(173.95,72.4) v2(173.97,0.43) v2(174.11,108.6) v2(174.76,142.76) v2(174.74,138.27) v2(175.26,91.88) v2(175.24,32.45) v2(175.24,23.7) v2(175.31,39.12) v2(175.31,30.27) v2(175.55,142.73) v2(175.58,28.09) v2(175.66,22.3) v2(175.77,44.09) v2(176.82,38.43) v2(176.82,37.19) v2(177.11,115.19) v2(177.64,117.8) v2(177.63,114.92) v2(177.67,114.34) v2(177.7,113.71) v2(177.81,102.96) v2(177.81,71.95) v2(177.97,117.23) v2(178.19,115.23) v2(178.27,117.8) v2(178.48,118.97) v2(178.62,74.03) v2(178.83,113.16) v2(178.91,117.8) v2(179.03,35.2) v2(179.05,33.96) v2(179.03,27.65) v2(179.11,32.53) v2(179.18,30.26) v2(179.21,139.93) v2(179.36,115.3) v2(179.34,28.91) v2(179.65,134.24) v2(179.92,154.07) v2(180.09,138.28) v2(180.05,37.63) v2(180.13,24.96) v2(180.58,136.23) v2(180.73,134.75) v2(181.05,31.47) v2(181.14,117.02) v2(181.17,24.79) v2(181.22,135.4) v2(181.32,139.93) v2(181.44,134.78) v2(181.59,0.43) v2(181.63,41.54) v2(181.64,21.52) v2(182.06,117.61) v2(182.07,23.35) v2(182.16,134.13) v2(182.24,34.11) v2(182.24,31.79) v2(182.27,30.97) v2(182.27,30.22) v2(182.22,29.51) v2(182.35,98.49) v2(182.39,35.43) v2(182.39,25) v2(182.75,134.13) v2(182.85,87.52) v2(182.88,10.39) v2(183.01,31.79) v2(183.01,31.01) v2(183.01,30.24) v2(183.01,29.46) v2(183.25,133.73) v2(183.27,9.76) v2(183.78,25.04) v2(183.87,133.76) v2(183.82,41.54) v2(183.87,37.77) v2(183.82,31.78) v2(183.86,30.2) v2(183.82,27.36) v2(183.82,21.26) v2(184.42,140.14) v2(184.55,133.91) v2(184.56,31.79) v2(184.56,30.24) v2(184.7,12.76) v2(184.87,9.09) v2(184.98,35.72) v2(184.94,10.36) v2(185.21,133.91) v2(185.34,31.79) v2(185.72,49.47) v2(186.08,41.54) v2(186.08,25.07) v2(186.11,34.11) v2(186.11,33.34) v2(186.11,30.96) v2(186.11,28.69) v2(186.17,21.25) v2(186.27,140.14) v2(186.27,37.84) v2(186.37,35.78) v2(186.3,27.4) v2(186.67,46.77) v2(186.89,33.34) v2(186.89,32.56) v2(186.89,31.79) v2(186.85,30.97) v2(186.84,30.27) v2(186.85,29.5) v2(186.8,9.08) v2(186.91,140.14) v2(187.54,154.07) v2(187.51,25) v2(187.66,33.34) v2(188.19,35.01) v2(188.38,44.73) v2(188.48,128.81) v2(188.48,127.54) v2(188.48,126.27) v2(188.77,140.14) v2(188.77,36.29) v2(188.76,24.98) v2(188.79,24.32) v2(189.26,13.8) v2(189.21,0.43) v2(189.46,32.54) v2(189.68,30.38) v2(189.69,29.78) v2(189.75,128.81) v2(189.75,127.54) v2(189.75,126.27) v2(189.77,37.68) v2(189.88,24.91) v2(189.97,120.43) v2(189.97,119.12) v2(189.97,117.81) v2(189.97,116.5) v2(189.97,115.19) v2(189.97,113.88) v2(190.14,125.54) v2(190.15,32.58) v2(190.4,29) v2(190.47,21.26) v2(190.53,56.54) v2(190.69,27.59) v2(191.02,128.81) v2(191.02,127.54) v2(191.02,126.27) v2(191.09,26.38) v2(191.04,24.65) v2(191.28,56.51) v2(191.95,56.55) v2(192.06,63.94) v2(192.14,139.07) v2(192.47,41.11) v2(192.47,30.23) v2(192.51,120.43) v2(192.51,119.12) v2(192.51,117.81) v2(192.51,116.5) v2(192.51,115.19) v2(192.51,113.88) v2(192.55,28.64) v2(193.81,139.07) v2(194.35,38.99) v2(194.53,45.83) v2(194.59,30.3) v2(194.59,28.15) v2(194.59,25.88) v2(194.59,23.68) v2(195.16,154.07) v2(195.67,97.31) v2(196.38,97.39) v2(196.43,86.5) v2(196.83,0.43) v2(197.16,19.94) v2(197.29,110.05) v2(197.27,108.18) v2(197.27,107.04) v2(197.62,125.16) v2(197.75,96.32) v2(197.88,123.47) v2(197.88,19.96) v2(198.56,39.59) v2(198.55,19.96) v2(198.64,99.09) v2(198.77,35.02) v2(198.88,109.3) v2(198.87,76.77) v2(198.86,70.28) v2(199,97.29) v2(199.13,100.72) v2(199.32,77.33) v2(199.36,76.42) v2(199.49,70.27) v2(199.65,124.1) v2(199.74,109.01) v2(199.86,102.04) v2(200.11,70.24) v2(200.29,107.29) v2(200.24,52.23) v2(200.24,51.64) v2(200.24,51.03) v2(200.24,50.43) v2(200.41,154.06) v2(200.56,99.12) v2(200.6,35.35) v2(200.58,27.83) v2(200.69,32.5) v2(200.89,22.21) v2(201,100.69) v2(201.39,113.57) v2(201.67,123.39) v2(201.82,103.86) v2(201.82,101.98) v2(202.15,115.19) v2(202.38,108.72) v2(202.36,107.24) v2(202.31,27.09) v2(202.5,17.22) v2(202.57,23.95) v2(202.7,32.54) v2(202.78,111.48) v2(202.71,48.05) v2(202.96,11.53) v2(203.06,38.81) v2(203.47,13.87) v2(203.52,101.99) v2(203.54,47.28) v2(203.53,43.63) v2(203.58,12.15) v2(203.58,10.91) v2(203.6,46.65) v2(203.71,111.99) v2(203.71,103.86) v2(203.77,45.8) v2(203.76,17.56) v2(203.97,33.66) v2(204.07,38.05) v2(204.06,37.35) v2(204.05,27.09) v2(204.2,11.53) v2(204.46,28.11) v2(204.45,0.43) v2(204.53,19.62) v2(204.64,31.53) v2(204.61,23.62) v2(204.87,13.63) v2(204.91,126.16) v2(204.94,110.16) v2(205.02,109.07) v2(205.04,21.89) v2(205.17,106.85) v2(205.18,31.3) v2(205.32,41.97) v2(205.47,43.91) v2(205.6,112.02) v2(206.22,27.01) v2(207.09,18.91) v2(207.61,23.2) v2(208.41,54.33) v2(208.44,24.96) v2(208.79,40.33) v2(208.84,128.44) v2(208.82,107.55) v2(209.16,127.93) v2(209.48,128.44) v2(209.45,22.47) v2(209.58,57.41) v2(209.79,127.93) v2(209.74,42.05) v2(209.86,125.68) v2(209.84,125.02) v2(209.84,124.44) v2(209.85,122.68) v2(209.94,121.56) v2(210.11,128.44) v2(210.29,121.06) v2(210.24,119.96) v2(210.43,127.93) v2(210.5,24.95) v2(210.75,128.44) v2(211.06,127.93) v2(211.01,8.3) v2(211.28,57.11) v2(211.28,54.87) v2(211.38,128.44) v2(211.36,61.34) v2(211.36,35.65) v2(211.49,42.45) v2(211.43,6.86) v2(211.5,40.43) v2(211.7,127.93) v2(211.9,49.31) v2(211.93,48.73) v2(211.94,48.15) v2(211.97,47.54) v2(212.02,128.44) v2(212.07,0.43) v2(212.3,88.65) v2(212.4,91.43) v2(212.59,61.36) v2(212.52,56.55) v2(212.52,55.18) v2(212.6,35.54) v2(212.65,128.44) v2(212.83,41.22) v2(212.87,40.04) v2(212.87,10.78) v2(213,91.43) v2(213.3,91.98) v2(213.24,26.73) v2(213.37,129.1) v2(213.46,90.86) v2(213.46,29) v2(213.48,10.78) v2(213.8,31.92) v2(213.82,56.8) v2(213.84,55.58) v2(213.92,129.96) v2(213.92,128.4) v2(213.96,48.92) v2(214.07,47.73) v2(214.27,40.35) v2(214.39,10.78) v2(214.47,92.07) v2(214.72,105.11) v2(214.82,93.17) v2(214.82,41.84) v2(215.06,56.62) v2(215.06,55.4) v2(215.08,10.77) v2(215.22,129.96) v2(215.22,128.4) v2(215.37,112.71) v2(215.36,49.07) v2(215.36,48.35) v2(215.36,47.63) v2(215.5,41.45) v2(215.54,40.12) v2(215.8,61.78) v2(215.71,36.1) v2(215.8,61.19) v2(216.22,92.2) v2(216.52,129.96) v2(216.52,128.4) v2(216.65,108.19) v2(216.66,107.21) v2(216.9,131.1) v2(216.86,41.95) v2(216.98,55.55) v2(216.92,39.95) v2(217.02,57.46) v2(217.37,128.74) v2(217.36,48.61) v2(217.35,47.79) v2(217.46,36.23) v2(217.85,106.17) v2(217.89,104.7) v2(217.84,99.59) v2(217.92,152.89) v2(217.92,145.11) v2(217.95,107.23) v2(217.96,102.93) v2(217.9,98.2) v2(217.98,96.63) v2(217.9,95.05) v2(217.96,93.44) v2(218.08,61.93) v2(218.06,61.33) v2(218.2,55.25) v2(218.15,41.21) v2(218.18,39.97) v2(218.21,56.59) v2(218.67,115.96) v2(219.12,48.17) v2(219.24,47.58) v2(219.34,61.14) v2(219.45,98.6) v2(219.49,95.47) v2(219.48,57.11) v2(219.49,55.87) v2(219.53,110.42) v2(219.52,108.07) v2(219.51,104.9) v2(219.51,103.32) v2(219.51,101.75) v2(219.51,100.17) v2(219.51,97.02) v2(219.51,93.88) v2(219.51,92.3) v2(219.51,90.72) v2(219.61,113.12) v2(219.69,0.43) v2(219.79,88.92) v2(219.86,42.1) v2(219.86,40.88) v2(219.93,133.2) v2(220.08,121.77) v2(220.17,114.68) v2(220.23,132.69) v2(220.43,132.11) v2(220.47,131.53) v2(220.44,130.9) v2(220.56,133.2) v2(220.51,130.27) v2(220.75,89.9) v2(220.77,56.41) v2(220.87,132.69) v2(220.89,121.8) v2(220.83,111.2) v2(220.82,107.22) v2(220.8,91.5) v2(220.83,54.96) v2(220.88,40.85) v2(220.93,48.69) v2(220.92,47.97) v2(220.92,42.04) v2(221.06,132.11) v2(221.08,130.9) v2(221.08,35.53) v2(221.12,154.07) v2(221.2,133.2) v2(221.1,131.53) v2(221.14,130.27) v2(221.22,129.67) v2(221.46,100.17) v2(221.46,95.46) v2(221.46,92.3) v2(221.41,90.74) v2(221.5,132.69) v2(221.51,118.24) v2(221.54,116.49) v2(221.53,114.84) v2(221.53,113.24) v2(221.7,132.11) v2(221.68,121.82) v2(221.8,146.2) v2(221.74,131.53) v2(221.71,130.9) v2(221.78,130.27) v2(221.83,133.2) v2(221.85,129.67) v2(221.87,10.32) v2(222.09,88.56) v2(222.14,132.69) v2(222.15,103.32) v2(222.11,102.54) v2(222.11,99.39) v2(222.12,94.65) v2(222.11,93.09) v2(222.13,92.31) v2(222.33,132.11) v2(222.37,131.53) v2(222.35,130.9) v2(222.37,121.8) v2(222.47,133.2) v2(222.41,130.27) v2(222.47,10.33) v2(222.53,129.69) v2(222.68,41.98) v2(222.72,147.81) v2(222.72,144.59) v2(222.77,132.69) v2(222.75,105.68) v2(222.77,53.7) v2(222.81,56.98) v2(222.81,55.74) v2(222.97,132.11) v2(222.98,130.9) v2(222.91,62.51) v2(222.91,61.89) v2(222.91,61.28) v2(222.92,48.67) v2(222.92,48.01) v2(223.01,131.53) v2(223.05,130.27) v2(223.08,110.63) v2(223.03,10.01) v2(223.1,133.2) v2(223.13,129.68) v2(223.41,132.69) v2(223.6,132.1) v2(223.57,93.78) v2(223.57,10.34) v2(223.56,9.75) v2(223.63,131.52) v2(223.62,130.9) v2(223.68,130.27) v2(223.63,91.77) v2(223.7,117.73) v2(223.92,84.27) v2(224.12,86.9) v2(224.13,57.44) v2(224.15,56.17) v2(224.16,10.36) v2(224.16,9.76) v2(224.29,133.5) v2(224.27,105.03) v2(224.38,114.73) v2(224.4,42.18) v2(224.58,147.81) v2(224.58,144.59) v2(224.57,88.73) v2(224.57,40.93) v2(224.79,10.34) v2(224.79,9.75) v2(224.75,9.17) v2(224.84,134.36) v2(224.84,132.8) v2(224.82,49.47) v2(224.85,48.08) v2(224.84,47.39) v2(225.29,85.45) v2(225.31,95.07) v2(225.43,10.34) v2(225.43,9.76) v2(225.5,146.2) v2(225.58,57.02) v2(225.58,55.81) v2(225.56,35.53) v2(225.56,34.77) v2(225.77,101.95) v2(225.76,101.3) v2(225.76,100.66) v2(225.76,100.03) v2(225.76,99.42) v2(225.9,61.27) v2(225.96,98.83) v2(225.92,61.94) v2(226.05,42.64) v2(226.07,41.29) v2(226.06,10.34) v2(226.07,9.75) v2(226.02,9.17) v2(226.13,134.36) v2(226.13,132.8) v2(226.19,38.98) v2(226.23,95.09) v2(226.23,94.46) v2(226.22,93.82) v2(226.23,93.19) v2(226.67,10.34) v2(226.66,9.74) v2(226.74,83.77) v2(226.88,56.51) v2(227.08,90.51) v2(227.08,88.56) v2(227.07,54.47) v2(227.14,95.07) v2(227.34,42.81) v2(227.32,10.35) v2(227.32,9.75) v2(227.31,9.12) v2(227.36,8.49) v2(227.31,0.43) v2(227.43,134.36) v2(227.43,132.8) v2(227.41,104.73) v2(227.41,103.51) v2(227.4,102.31) v2(227.42,40.83) v2(227.64,54.02) v2(227.81,135.5) v2(227.89,9.61) v2(227.85,8.84) v2(228.05,95.07) v2(228.28,133.14) v2(228.26,85.28) v2(228.27,50.23) v2(228.27,47.8) v2(228.21,39.93) v2(228.31,140.44) v2(228.33,9.2) v2(228.57,55.79) v2(228.57,54.57) v2(228.63,109.31) v2(228.74,154.07) v2(228.82,82.09) v2(228.94,140.44) v2(228.97,95.09) v2(228.97,94.46) v2(228.96,93.82) v2(228.97,93.19) v2(228.97,92.55) v2(229.1,96.48) v2(229.23,41.01) v2(229.32,99.62) v2(229.36,61.91) v2(229.36,61.33) v2(229.58,140.44) v2(229.59,88.58) v2(229.77,104.73) v2(229.77,103.51) v2(229.73,102.3) v2(229.88,95.07) v2(230.18,134.55) v2(230.2,40.91) v2(230.3,130.89) v2(230.21,42.22) v2(230.35,133.95) v2(230.39,133.36) v2(230.32,132.73) v2(230.31,132.11) v2(230.32,131.49) v2(230.32,130.27) v2(230.31,83.58) v2(230.43,129.67) v2(230.46,129.04) v2(230.45,128.42) v2(230.45,127.81) v2(230.48,99.09) v2(230.48,98.51) v2(230.6,148.39) v2(230.51,39.75) v2(230.64,55.17) v2(230.8,134.56) v2(230.8,95.07) v2(230.97,133.97) v2(230.94,132.75) v2(230.93,132.13) v2(230.93,131.51) v2(230.91,130.91) v2(230.93,130.29) v2(231,109.34) v2(231,133.38) v2(231.04,129.69) v2(231.07,129.06) v2(231.07,128.44) v2(231.06,127.82) v2(231.05,35.8) v2(231.21,148.39) v2(231.29,50.15) v2(231.39,134.56) v2(231.32,48.06) v2(231.59,136.36) v2(231.6,135.15) v2(231.56,133.96) v2(231.59,133.37) v2(231.53,132.74) v2(231.52,132.13) v2(231.52,131.51) v2(231.5,130.9) v2(231.52,130.29) v2(231.6,54.97) v2(231.68,136.97) v2(231.6,135.76) v2(231.63,129.68) v2(231.67,129.05) v2(231.66,128.44) v2(231.65,127.82) v2(231.67,84.9) v2(231.63,56.44) v2(231.79,148.39) v2(231.71,100.14) v2(231.71,95.07) v2(231.71,93.12) v2(231.71,92.47) v2(231.76,42.44) v2(231.75,41.09) v2(231.99,152.59) v2(231.98,134.47) v2(232.19,135.93) v2(232.15,96.72) v2(232.11,88.56) v2(232.39,148.39) v2(232.41,82.11) v2(232.63,95.07) v2(232.74,136.78) v2(232.74,135.22) v2(232.79,96.77) v2(233.26,83.63) v2(233.54,95.07) v2(233.63,43.23) v2(233.9,52.99) v2(234.04,136.78) v2(234.04,135.22) v2(234.09,40.48) v2(234.15,99.62) v2(234.16,85.13) v2(234.38,56.62) v2(234.48,95.07) v2(234.45,94.42) v2(234.45,93.77) v2(234.45,93.12) v2(234.45,92.47) v2(234.47,91.21) v2(234.4,54.42) v2(234.53,146.94) v2(234.62,88.56) v2(234.93,0.43) v2(235.27,146.97) v2(235.33,136.78) v2(235.33,135.22) v2(235.49,100.06) v2(235.49,99.46) v2(235.71,137.93) v2(235.73,43.42) v2(235.71,42.05) v2(235.74,40.7) v2(235.87,56.86) v2(235.89,55.61) v2(235.9,54.34) v2(236.08,151.12) v2(236.18,135.57) v2(236.21,142.92) v2(236.28,95.07) v2(236.29,80.24) v2(236.31,147.02) v2(236.42,66.23) v2(236.42,65.59) v2(236.42,64.96) v2(236.67,83.71) v2(236.7,81.92) v2(236.84,142.92) v2(237.07,146.94) v2(237.04,54.53) v2(237.2,94.42) v2(237.2,93.77) v2(237.14,91.11) v2(237.14,88.54) v2(237.23,42.89) v2(237.27,41.55) v2(237.48,142.92) v2(237.82,136.83) v2(237.88,133.84) v2(237.88,133.24) v2(237.9,132.65) v2(237.88,132.02) v2(237.88,131.4) v2(237.83,130.8) v2(237.83,130.19) v2(237.85,129.57) v2(237.85,57.5) v2(237.94,146.49) v2(237.92,136.22) v2(237.92,135.63) v2(237.92,135.04) v2(237.9,134.45) v2(238.08,109.35) v2(238.11,95.06) v2(238.47,136.82) v2(238.48,130.78) v2(238.48,130.18) v2(238.57,136.21) v2(238.56,135.62) v2(238.56,135.03) v2(238.55,134.43) v2(238.52,133.82) v2(238.52,133.23) v2(238.54,132.63) v2(238.53,132) v2(238.53,131.39) v2(238.5,129.56) v2(238.77,100.09) v2(238.77,99.46) v2(238.95,147.02) v2(239.08,130.77) v2(239.08,130.17) v2(239.1,129.55) v2(239.03,95.06) v2(239.08,85.71) v2(239.08,83.8) v2(239.15,136.81) v2(239.17,136.2) v2(239.16,135.61) v2(239.16,135.02) v2(239.15,134.42) v2(239.12,133.81) v2(239.12,133.22) v2(239.14,132.62) v2(239.13,131.99) v2(239.13,131.38) v2(239.1,107.58) v2(239.13,82.01) v2(239.17,55.74) v2(239.14,53.86) v2(239.64,113.24) v2(239.67,109.34) v2(239.69,39.64) v2(239.71,147.02) v2(239.74,107.58) v2(239.71,43.65) v2(239.73,41.67) v2(239.86,99.97) v2(239.84,99.27) v2(239.85,98.52) v2(239.92,135.93) v2(239.94,95.07) v2(239.94,93.77) v2(239.94,93.12) v2(240.01,100.68) v2(240.47,136.79) v2(240.47,135.22) v2(240.64,153.47) v2(240.71,147.02) v2(240.87,58.08) v2(240.87,56.26) v2(240.89,55.09) v2(240.88,53.24) v2(240.86,48.55) v2(240.96,41.85) v2(241.47,147.02) v2(241.45,3.2) v2(241.52,107.58) v2(241.51,38.9) v2(241.77,136.79) v2(241.77,135.22) v2(241.74,85.14) v2(241.73,83.24) v2(241.71,81.35) v2(241.73,79.43) v2(242.02,109.33) v2(242.15,107.58) v2(242.12,89.86) v2(242.48,146.41) v2(242.47,57.28) v2(242.55,0.43) v2(242.68,95.09) v2(242.68,94.46) v2(242.68,93.82) v2(242.68,93.19) v2(242.68,92.5) v2(242.67,54.36) v2(242.79,111.29) v2(242.99,41.86) v2(243.06,136.79) v2(243.06,135.22) v2(243.03,43.11) v2(243.1,39.3) v2(243.44,137.93) v2(243.58,114.54) v2(243.58,113.24) v2(243.58,111.94) v2(243.58,110.64) v2(243.56,3.15) v2(243.82,142.86) v2(243.91,135.57) v2(243.93,107.58) v2(244.17,84.05) v2(244.24,82.27) v2(244.38,109.38) v2(244.46,142.86) v2(244.52,107.58) v2(244.69,148.26) v2(244.68,89.86) v2(244.83,43.29) v2(244.98,57.26) v2(244.97,40.45) v2(245.09,142.86) v2(245.01,56.07) v2(245.01,54.82) v2(245.23,7.8) v2(245.23,7.22) v2(245.34,106.44) v2(245.34,105.23) v2(245.33,103.98) v2(245.44,95.13) v2(245.42,93.82) v2(245.43,93.19) v2(245.43,92.55) v2(245.45,79.61) v2(245.51,148.26) v2(245.59,136.22) v2(245.6,135.64) v2(245.5,82.71) v2(245.51,81.48) v2(245.61,135.06) v2(245.63,134.47) v2(245.64,133.89) v2(245.64,133.27) v2(245.65,132.69) v2(245.63,132.09) v2(245.65,131.51) v2(245.65,130.9) v2(245.66,130.31) v2(245.68,129.7) v2(245.66,129.1) v2(245.63,3.21) v2(245.86,7.8) v2(245.86,7.22) v2(246.15,85.16) v2(246.27,148.26) v2(246.22,136.2) v2(246.24,135.62) v2(246.25,135.04) v2(246.27,134.45) v2(246.28,133.87) v2(246.28,133.25) v2(246.29,132.67) v2(246.27,132.07) v2(246.28,131.49) v2(246.28,130.88) v2(246.3,130.29) v2(246.32,129.68) v2(246.3,129.08) v2(246.32,95.08) v2(246.5,7.8) v2(246.5,7.22) v2(246.73,109.34) v2(246.87,136.2) v2(246.88,135.62) v2(246.9,135.03) v2(246.98,148.24) v2(246.91,134.45) v2(246.93,133.86) v2(246.92,133.25) v2(246.94,132.66) v2(246.92,132.07) v2(246.93,131.49) v2(246.93,130.87) v2(246.94,130.29) v2(246.96,129.68) v2(246.95,129.07) v2(246.97,56.67) v2(246.99,55.45) v2(246.95,43.45) v2(246.94,42.81) v2(247.02,39.85) v2(247.19,86.69) v2(247.13,7.8) v2(247.13,7.22) v2(247.25,95.12) v2(247.52,96.91) v2(247.62,136.04) v2(247.69,106.39) v2(247.69,105.19) v2(247.78,154.07) v2(247.7,103.97) v2(248.17,136.9) v2(248.17,135.33) v2(248.17,95.08) v2(248.17,94.45) v2(248.17,93.81) v2(248.17,93.18) v2(248.17,92.54) v2(248.16,56.02) v2(248.16,54.78) v2(248.3,113.24) v2(248.73,2.62) v2(248.97,82.68) v2(248.98,49.92) v2(248.98,49.21) v2(248.98,48.01) v2(248.96,47.42) v2(249.06,146.69) v2(249.09,95.07) v2(249.09,44.63) v2(249.09,43.96) v2(249.04,40.22) v2(249.12,109.36) v2(249.23,36.5) v2(249.36,5.84) v2(249.47,136.9) v2(249.47,135.33) v2(249.68,107.59) v2(249.69,83.96) v2(249.66,61.29) v2(249.75,146.71) v2(249.72,90.47) v2(249.71,88.56) v2(250,95.06) v2(249.9,81.76) v2(249.96,56.07) v2(250.06,106.4) v2(250.03,105.19) v2(250.06,104) v2(250.03,41.24) v2(250.05,40.04) v2(250.17,0.43) v2(250.29,5.45) v2(250.46,6.81) v2(250.56,146.71) v2(250.76,136.9) v2(250.76,135.33) v2(250.94,95.1) v2(250.91,94.46) v2(250.91,93.82) v2(250.91,93.19) v2(250.91,92.55) v2(251.06,47.43) v2(251.07,35.53) v2(251.14,138.04) v2(251.15,56.52) v2(251.12,43.91) v2(251.14,42.71) v2(251.3,146.69) v2(251.28,82.41) v2(251.2,54.41) v2(251.39,90.46) v2(251.45,109.37) v2(251.49,107.56) v2(251.56,143.07) v2(251.61,135.68) v2(251.83,95.04) v2(252.19,143.07) v2(252.22,88.56) v2(252.22,86.63) v2(252.31,146.08) v2(252.42,106.42) v2(252.42,105.22) v2(252.42,103.96) v2(252.48,61.96) v2(252.47,61.29) v2(252.55,81.14) v2(252.56,50.48) v2(252.56,49.29) v2(252.74,96.36) v2(252.72,95.06) v2(252.83,143.07) v2(252.88,83.64) v2(252.88,55.81) v2(252.86,42.55) v2(252.83,40.47) v2(252.9,57.89) v2(253.12,85.1) v2(253.16,48.05) v2(253.17,47.45) v2(253.15,35.25) v2(253.15,34.64) v2(253.3,136.92) v2(253.66,94.46) v2(253.65,93.82) v2(253.66,93.19) v2(253.66,92.55) v2(253.74,96.48) v2(253.94,97.96) v2(253.91,50.34) v2(253.92,49.7) v2(254.04,105.06) v2(254.05,102.75) v2(254.02,99.39) v2(254.05,97.1) v2(254.4,62) v2(254.39,61.37) v2(254.47,83.73) v2(254.6,112.53) v2(254.57,94.42) v2(254.6,111.29) v2(254.72,90.46) v2(254.74,88.56) v2(254.76,57.26) v2(254.79,55.96) v2(254.76,54.72) v2(254.81,43.35) v2(254.83,41.99) v2(254.83,40.7) v2(254.85,35.49) v2(255.4,154.07) v2(255.39,111.36) v2(255.4,110.64) v2(255.45,85.48) v2(255.53,95.95) v2(255.62,102.33) v2(255.65,96.79) v2(255.64,48.24) v2(255.63,47.5) v2(256.05,114.59) v2(256.2,107.82) v2(256.16,61.83) v2(256.18,61.23) v2(256.22,112.5) v2(256.25,111.79) v2(256.24,107.03) v2(256.24,105.46) v2(256.26,101.52) v2(256.24,96.01) v2(256.24,95.22) v2(256.38,54.76) v2(256.43,89.66) v2(256.42,56.13) v2(256.73,8.78) v2(256.73,8.17) v2(256.9,109.42) v2(256.85,107.82) v2(256.89,103.88) v2(256.89,102.31) v2(256.89,99.16) v2(256.89,96.01) v2(256.89,94.43) v2(256.81,84.15) v2(256.95,41.16) v2(256.93,36.03) v2(257.02,42.45) v2(257.14,91.14) v2(257.11,49.76) v2(257.13,48.18) v2(257.32,9.54) v2(257.32,8.93) v2(257.33,8.26) v2(257.54,110.97) v2(257.56,107.8) v2(257.54,96.01) v2(257.57,86.53) v2(257.79,0.43) v2(257.98,9.57) v2(257.97,8.96) v2(257.95,8.27) v2(258.19,105.43) v2(258.19,96.79) v2(258.19,96.01) v2(258.19,93.64) v2(258.19,92.07) v2(258.48,42.61) v2(258.56,56.67) v2(258.56,54.46) v2(258.55,40.49) v2(258.6,8.95) v2(258.6,36.07) v2(258.63,35.44) v2(258.61,9.54) v2(258.61,8.29) v2(258.89,85.24) v2(258.99,123.45) v2(258.99,122.78) v2(259.01,124.17) v2(259.02,122.1) v2(259.02,63.04) v2(259.02,62.42) v2(259.02,61.76) v2(259.15,48.31) v2(259.16,47.6) v2(259.23,49.73) v2(259.27,49.08) v2(259.33,9.59) v2(259.35,9) v2(259.79,105.92) v2(259.76,94.95) v2(259.77,90.48) v2(259.77,89.54) v2(259.77,88.69) v2(259.87,101.91) v2(259.99,56.43) v2(260,55.15) v2(260.01,112.88) v2(260.05,110.99) v2(260.05,9.62) v2(260.07,9.03) v2(260.19,99.29) v2(260.28,83.84) v2(260.3,42.43) v2(260.28,41.11) v2(260.26,36.33) v2(260.69,61.79) v2(260.67,61.19) v2(260.77,49.43) v2(260.77,48.75) v2(260.77,48.07) v2(260.77,47.34) v2(260.95,92.32) v2(261.1,93.58) v2(261.12,87.34) v2(261.26,147.05) v2(261.26,144.93) v2(261.26,142.81) v2(261.27,88.32) v2(261.4,89.5) v2(261.96,43.01) v2(261.95,41.65) v2(261.91,35.53) v2(262.02,57) v2(262.03,55.77) v2(262.65,91.07) v2(262.66,88.08) v2(262.84,122.31) v2(262.83,121.68) v2(262.84,49.42) v2(262.87,47.3) v2(263.02,154.07) v2(263.09,62.38) v2(263.08,61.69) v2(263.38,147.05) v2(263.38,144.93) v2(263.38,142.81) v2(263.68,56.55) v2(263.66,43.43) v2(263.62,41.32) v2(263.61,35.53) v2(263.7,54.39) v2(263.81,122.33) v2(263.86,121.68) v2(264.58,121.23) v2(264.69,124.96) v2(264.67,124.34) v2(264.69,123.72) v2(264.67,123.07) v2(264.73,122.48) v2(264.7,121.83) v2(264.91,62.41) v2(264.91,61.68) v2(264.91,49.48) v2(264.91,48.74) v2(264.91,48.01) v2(264.91,47.3) v2(265.24,128.83) v2(265.24,127.54) v2(265.24,126.24) v2(265.2,121.25) v2(265.34,125) v2(265.36,124.39) v2(265.34,123.75) v2(265.36,123.12) v2(265.37,122.51) v2(265.4,121.88) v2(265.33,35.98) v2(265.42,42.19) v2(265.4,40.79) v2(265.41,0.43) v2(265.5,147.05) v2(265.5,144.93) v2(265.5,142.81) v2(265.59,129.68) v2(265.79,57.39) v2(265.79,56.02) v2(265.78,54.77) v2(265.85,121.29) v2(265.95,125.69) v2(266.01,124.99) v2(266,124.39) v2(266.01,123.74) v2(266,123.13) v2(266.05,122.5) v2(266.03,121.89) v2(266.51,121.26) v2(266.52,40.61) v2(266.63,124.99) v2(266.65,124.39) v2(266.64,123.74) v2(266.65,123.12) v2(266.67,122.51) v2(266.68,121.88) v2(266.8,128.83) v2(266.8,127.54) v2(266.8,126.24) v2(266.94,62.36) v2(266.91,61.7) v2(266.94,49.53) v2(266.94,47.96) v2(266.91,47.25) v2(266.98,43) v2(266.97,41.73) v2(267.34,13.27) v2(267.46,55.33) v2(267.45,35.53) v2(267.51,56.6) v2(267.95,129.21) v2(268.61,40.98) v2(268.81,43.02) v2(269.1,62.52) v2(269.13,61.7) v2(269.18,57.04) v2(269.21,54.93) v2(269.43,49.56) v2(269.43,48.92) v2(269.43,48.16) v2(269.43,47.37) v2(269.49,35.91) v2(270.64,57.31) v2(270.64,56.12) v2(270.66,54.85) v2(270.61,44) v2(270.64,42.18) v2(270.63,40.92) v2(270.9,154.07) v2(271.01,62.53) v2(271.03,61.7) v2(271.11,49.36) v2(271.11,48.52) v2(271.13,47.7) v2(271.13,35.54) v2(271.93,57.82) v2(271.93,56.65) v2(271.96,55.33) v2(272.34,42.33) v2(272.31,41) v2(272.74,35.6) v2(273.03,0.43) v2(273.22,152.44) v2(273.22,145.85) v2(273.25,49) v2(273.26,24.1) v2(273.37,86.69) v2(273.32,62.34) v2(273.31,61.75) v2(273.34,47.75) v2(273.44,124.37) v2(273.47,123.03) v2(273.44,121.69) v2(273.69,68.26) v2(273.69,67.56) v2(273.74,42.26) v2(273.7,40.28) v2(273.81,55.51) v2(273.83,54.28) v2(273.95,57.6) v2(274.18,35.53) v2(274.17,34.9) v2(274.59,48.47) v2(274.61,47.69) v2(274.73,43.59) v2(274.88,58.27) v2(274.98,53.77) v2(275.16,84.05) v2(275.37,61.68) v2(275.36,40.01) v2(275.95,35.53) v2(276.22,84.02) v2(276.45,57.92) v2(276.49,53.78) v2(277.55,144.77) v2(278.19,30.99) v2(278.2,31.59) v2(278.21,30.37) v2(278.24,28.84) v2(278.24,28.21) v2(278.25,27.53) v2(278.74,17.72) v2(279.23,3.54) v2(279.35,17.72) v2(279.95,17.72) v2(280.65,0.43) v2(281.07,143.5) v2(281.51,35.17) v2(281.5,34.51) v2(281.88,136.17) v2(282.22,70.3) v2(282.24,19.63) v2(282.35,96.17) v2(282.36,95.28) v2(282.4,94.66) v2(282.44,94.07) v2(282.43,93.46) v2(282.6,129.67) v2(282.71,92.91) v2(282.82,19.63) v2(282.92,95.09) v2(283.07,93.94) v2(283.19,93.34) v2(283.36,122.73) v2(283.4,46.66) v2(283.41,19.63) v2(283.8,61.7) v2(283.81,97.39) v2(283.81,96.75) v2(283.99,19.63) v2(284.04,116.6) v2(284.58,19.63) v2(284.6,111.48) v2(284.6,46.17) v2(284.72,63.31) v2(284.72,60.09) v2(285,68.49) v2(285.04,67.8) v2(285.16,19.63) v2(285.4,104.28) v2(285.65,69.08) v2(285.69,68.41) v2(285.69,67.8) v2(285.89,45.35) v2(286.24,96.67) v2(286.24,46.81) v2(286.58,63.31) v2(286.58,60.09) v2(286.54,47.32) v2(286.84,46.8) v2(286.97,91.11) v2(287.06,19.57) v2(287.16,47.32) v2(287.46,46.81) v2(287.5,61.7) v2(287.95,86.55) v2(288.06,46.81) v2(288.27,0.43) v2(289.72,80.97) v2(291.54,44.44) v2(291.54,43.8) v2(292.26,44.43) v2(292.25,43.8) v2(292.83,74.09) v2(292.99,44.45) v2(293,43.81) v2(293.74,44.45) v2(293.73,43.81) v2(293.81,34.32) v2(294.4,34.33) v2(294.54,44.45) v2(294.52,43.84) v2(295.19,12.29) v2(295.55,34.3) v2(295.89,0.43) v2(296.19,34.31) v2(296.23,68.52) v2(297.17,34.3) v2(297.26,25.82) v2(297.26,25.2) v2(297.6,12.83) v2(297.78,34.3) v2(298.74,34.3) v2(299.33,34.3) v2(299.49,55.37) v2(299.81,63.87) v2(299.87,56.02) v2(300.1,55.36) v2(300.46,56.03) v2(300.7,55.36) v2(301.09,56.01) v2(301.84,13.41) v2(302.48,15.18) v2(302.49,14.58) v2(302.49,13.97) v2(302.46,13.39) v2(302.92,15.8) v2(303.09,15.17) v2(303.08,13.98) v2(303.06,13.4) v2(303.11,14.58) v2(303.51,15.81) v2(303.51,0.43) v2(303.62,53.45) v2(303.69,15.18) v2(303.7,14.59) v2(303.69,13.99) v2(304.18,59.48) v2(304.1,15.8) v2(304.31,15.18) v2(304.32,14.59) v2(304.31,13.99) v2(305.75,51.83) v2(305.87,4.58) v2(307.28,38.88) v2(308.46,29.05) v2(308.83,56.32) v2(309.64,38.88) v2(310.94,28.99) v2(311.13,0.43) v2(311.28,9.91) v2(312.19,7.85) v2(312.19,7.18) v2(312.4,3.65) v2(313.3,39.48) v2(313.83,54.11) v2(313.93,39.5) v2(313.93,29.53) v2(314.08,40.08) v2(314.52,39.5) v2(314.55,29.53) v2(314.67,40.13) v2(315.1,39.5) v2(315.28,40.16) v2(315.26,29.52) v2(315.54,40.69) v2(315.72,39.77) v2(315.72,39.17) v2(315.89,29.51) v2(316.14,40.37) v2(316.38,39.78) v2(316.36,39.16) v2(316.36,21.84) v2(316.53,30.1) v2(316.51,29.5) v2(316.75,40.35) v2(317,39.17) v2(316.97,21.84) v2(317,39.77) v2(317.15,30.09) v2(317.13,29.49) v2(317.13,28.85) v2(317.44,21.48) v2(317.78,30.08) v2(317.77,29.48) v2(317.75,28.85) v2(318.36,29.51) v2(318.39,28.86) v2(318.61,21.67) v2(318.65,15.95) v2(318.75,0.43) v2(318.98,29.51) v2(318.97,28.88) v2(319.01,16.43) v2(319.2,21.66) v2(320.11,52.64) v2(320.79,47.81) v2(325.02,23.58) v2(325.99,23.58) v2(326.37,0.43) v2(326.89,23.6) v2(327.07,52.27) v2(328.13,29.95) v2(330.97,3.17) v2(331.48,1.5) v2(331.84,4.44) v2(332.94,27.05) v2(333.64,52.62) v2(334.06,4.46) v2(334.16,15.97) v2(334.39,0.43) v2(334.49,1.73) v2(334.76,15.97) v2(334.84,3.06) v2(338.95,43.39) v2(338.98,28.81) v2(339.32,33.49) v2(339.33,32.9) v2(339.4,30.5) v2(339.4,29.91) v2(339.4,29.24) v2(339.81,54.08) v2(339.94,43.43) v2(340.91,43.41) v2(341.6,0.43) v2(343.4,25.2) v2(343.4,23.23) v2(344.36,37.75) v2(345.36,23.23) v2(345.36,21.26) v2(345.58,38.39) v2(346.16,33.9) v2(346.16,32.87) v2(346.22,56.95) v2(346.96,5.99) v2(347.33,25.2) v2(347.33,21.26) v2(347.82,12.09) v2(348.36,8.86) v2(349.5,39.34) v2(349.63,45.32) v2(349.71,36.11) v2(349.86,33.96) v2(349.83,33.33) v2(349.84,32.72) v2(350.13,39.96) v2(350.13,38.72) v2(350.36,50.39) v2(350.36,49.14) v2(350.75,39.34) v2(350.98,49.76) v2(351.68,60.79) v2(351.6,45.32) v2(352.39,54.8) v2(353.65,56.07) v2(354.34,47.87) v2(354.91,51.4) v2(354.94,50.69) v2(354.98,47.87) v2(355.27,11.22) v2(355.6,47.89) v2(356.58,47.05) v2(356.58,46.28) v2(356.57,15.17) v2(356.57,14.58) v2(356.61,14) v2(356.99,67.15) v2(356.9,24.78) v2(357.98,23.73) v2(359.25,66.4) v2(359.8,70.1) v2(360.72,71.71) v2(360.72,68.49) v2(360.77,45.95) v2(360.77,43.54) v2(360.77,40.75) v2(362.58,71.71) v2(362.58,68.49) v2(363.18,48.37) v2(363.18,39.22) v2(363.31,45.95) v2(363.31,43.54) v2(363.31,40.75) v2(363.5,70.1) v2(363.66,66.06) v2(363.8,10.92) v2(363.95,62.97) v2(363.95,59.54) v2(363.95,56.87) v2(364.07,54.72) v2(364.07,52.3) v2(364.07,50.27) v2(364.33,36.94) v2(364.33,34.9) v2(364.33,32.36) v2(364.73,10.96) v2(364.92,73.72) v2(364.96,29.95) v2(365.47,58.14) v2(365.47,55.73) v2(365.6,53.45) v2(365.6,51.41) v2(365.62,10.96) v2(365.72,39.22) v2(365.85,48.37) v2(365.96,2.71) v2(366,4.01) v2(366.1,45.95) v2(366.1,43.54) v2(366.1,40.75) v2(366.55,10.99) v2(366.87,59.54) v2(366.87,56.87) v2(366.82,54.68) v2(366.82,52.26) v2(366.87,34.9) v2(366.87,32.36) v2(367.08,0.44) v2(367.16,49.92) v2(367.11,36.5) v2(367.43,11.2) v2(367.58,55.36) v2(367.58,31.54) v2(367.58,29.19) v2(367.56,5.55) v2(367.7,71.25) v2(368.44,11.18) v2(368.62,72.86) v2(368.62,69.64) v2(368.9,45.95) v2(368.9,43.54) v2(368.9,40.75) v2(369.17,49.37) v2(369.15,10.57) v2(369.2,5.92) v2(369.86,59.23) v2(370.48,72.86) v2(370.48,69.64) v2(370.52,66.4) v2(370.52,45.15) v2(370.51,37.24) v2(370.52,25.91) v2(371.4,71.25) v3(4.29,46.98) v3(7.9,53.23) v3(11.62,4.45) v3(25.44,49) v3(25.85,46.49) v3(26.62,6.51) v3(68.7,12.07) v3(84.47,9.85) v3(84.65,27.02) v3(89.68,6.13) v3(90.69,41.55) v3(109.91,14.25) v3(112.36,25.43) v3(129.12,3.56) v3(208.42,127.93) v3(209.37,123.49) v3(214.2,130.69) v3(216.84,142.71) v3(223.67,65.93) v3(229.43,127.56) v3(238.04,148.54) v3(242.41,148.67) v3(248.19,131.49) v3(250.31,148.82) v3(263.31,125.43) v3(267.22,66.72) v3(274.72,83.38) v3(281.73,93.59) v3(290.45,72.51) v3(301.69,14.89) v3(341.17,51.25) v3(343.18,51.88) v3(356.78,60.56)
