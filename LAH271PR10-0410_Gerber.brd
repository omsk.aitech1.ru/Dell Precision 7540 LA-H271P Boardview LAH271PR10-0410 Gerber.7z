# Allegro board LAH271PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BATSRC: length 37.1
  TOP w0.203: PU700.17 287.07,27.74 286.43,27.11 v2(286,27.11)
  IN4 w0.381: v2(286,27.11) 286.63,26.48 286.63,23.72 285.31,22.4 285.31,20.79 285.89,20.21 287.45,20.21 288.3,19.36 302.03,19.36 302.37,19.7 307.84,19.7 v2(308.4,19.14)
  BOTTOM w0.381: v2(308.4,19.14) v1(308.4,17.1) PR735.1
BATT_WHITE#: length 205.7
  TOP w0.109: v2(142.53,8.34) 142.44,8.34 v3(141.96,8.82) 141.09,9.69 RZ361.2 ; v2(313.75,6.12) 313.75,6.14 313.67,6.22 313.67,9.45 313.81,9.6 JLED1.3
  IN1 w0.102: v2(144.48,2.2) 144.33,2.34 144.33,5.46 143.87,5.93 143.87,6.72 142.53,8.06 v2(142.53,8.34)
  IN2 w0.081: v2(264.94,7.64) 263.95,7.64 263.63,7.31 252.94,7.31 251.08,9.17 237.42,9.17 236.09,10.5 228.22,10.5 227.42,11.3 221.2,11.3 218.99,9.09 216.02,9.09 215.66,8.73 215.66,3.82 213.34,1.5 193.76,1.5 193.73,1.53 173.73,1.53 172.07,3.19 172.07,4.1 169.81,6.36 166.33,6.36 165.58,5.61 159.61,5.61 159.27,5.28 159.27,2.58 158.19,1.5 145.18,1.5 v2(144.48,2.2)
  IN3 w0.081: v2(264.94,7.64) 264.68,7.64 263.83,8.49 263.83,9.94 264.56,10.66 272.15,10.66 273.76,9.05 280.47,9.05 281.03,8.49 286.78,8.49 288.4,6.86 289.34,6.86 290.6,8.12 305.95,8.12 308.05,6.02 312.48,6.02 313,6.54 313.33,6.54 313.75,6.12 v2(313.75,6.12)
BATT_YELLOW#: length 213.6
  TOP w0.109: QZ3.3 134.94,9.78 135.23,9.49 136.45,9.49 136.79,9.15 138.43,9.15 138.76,9.48 138.76,10.52 139.14,10.9 139.78,10.9 140.07,10.61 140.82,10.61 141.28,11.07 RZ28.2 141.36,10.71 141.65,10.42 141.65,9.68 142.36,8.97 v2(142.53,8.97) ; JLED1.2 313.31,9.59 313.43,9.48 313.43,6.4 v2(313.17,6.15) ; v2(145.06,2.32) 145.06,1.83 v3(145.26,1.62)
  IN1 w0.102: v2(145.06,2.32) 144.57,2.81 144.57,5.58 144.1,6.05 144.1,7 142.94,8.16 142.94,8.74 142.7,8.97 v2(142.53,8.97)
  IN2 w0.081: v2(264.69,8.19) 263.72,8.19 263.07,7.54 253.03,7.54 251.18,9.4 237.51,9.4 236.15,10.76 228.28,10.76 227.52,11.53 220.99,11.53 218.83,9.37 215.88,9.37 215.42,8.9 215.42,4.04 213.12,1.74 193.85,1.74 193.83,1.76 177.08,1.76 176.11,2.73 176.11,3.1 174.75,4.46 172.03,4.46 169.8,6.69 166.33,6.69 165.49,5.84 159.51,5.84 159.04,5.37 159.04,2.68 158.1,1.73 145.65,1.73 v2(145.06,2.32)
  IN3 w0.081: v2(313.17,6.15) 312.83,5.81 307.97,5.81 305.86,7.91 290.68,7.91 289.42,6.65 288.32,6.65 286.69,8.28 280.9,8.28 280.35,8.82 273.53,8.82 271.89,10.45 264.65,10.45 264.04,9.85 264.04,8.84 v2(264.69,8.19)
BBS_BIT6: length 3.6
  TOP w0.089: UH1.BA26 176.67,30.66 v2(176.67,30.27)
  BOTTOM w0.102: RH311.2 174.31,29.64 174.45,29.78 v1(174.94,29.78) 176.18,29.78 v2(176.67,30.27)
BC_CLK_ECE1117: length 243.2
  TOP w0.109: v2(280.84,5.4) 281.33,5.9 283.14,5.9 285.09,7.84 287.6,7.84 288.36,8.6 289.3,8.6 289.93,9.23 289.93,10.59 289.16,11.35 289.16,11.7 289.16,11.7 JKBTP1.10 ; v2(141.11,28.8) 140.8,28.49 140.8,27.75 141.02,27.52 141.02,26.86 140.81,26.64 140.21,26.64 140,26.85 UE1.D13
  IN2 w0.081: v2(280.84,5.4) 280.19,4.76 276.57,4.76 275.1,6.23 275.1,8.11 273.28,9.93 271.06,9.93 270.08,10.91 269.54,10.91 269.04,11.41 267.92,11.41 266.24,13.09 266.24,14.52 265.06,15.7 251.9,15.7 250.6,14.4 240.79,14.4 240.16,15.03 221.04,15.03 219.72,13.71 213.1,13.71 210.5,11.11 210.5,9.62 v2(211.47,8.65)
  IN4 w0.102: v2(211.47,8.65) 211.97,8.65 212.52,8.1 212.52,6.8 211.9,6.18 211.16,6.18 210.72,5.73 210.72,3.28 210.49,3.05 205.74,3.05 205.54,3.24 205.03,3.24 204.61,2.83 195.15,2.83 194.54,3.43 193.4,3.43 193.16,3.67 183.92,3.67 183.2,2.94 178.08,2.94 176.75,4.27 174.36,4.27 171.06,7.57 164.79,7.57 164.62,7.4 161.26,7.4 157.88,10.78 156.8,10.78 156.35,11.23 155.08,11.23 154.58,10.73 151.43,10.73 150.85,10.15 147.74,10.15 145.4,7.81 139.14,7.81 138.57,8.38 135.35,8.38 134.75,7.78 130.82,7.78 128.75,9.85 125.76,9.85 119.4,16.21 119.4,17.2 118.19,18.41 118.19,19.71 118.82,20.35 118.82,24.27 119.3,24.75 121.71,24.75 122.27,25.31 123.87,25.31 126.25,27.69 127.49,27.69 128.21,28.41 129.19,28.41 130.6,29.82 132.31,29.82 132.97,30.48 133.47,30.48 133.78,30.17 133.78,29.98 134.1,29.66 137.03,29.66 137.56,29.13 139.82,29.13 139.87,29.18 140.73,29.18 v2(141.11,28.8)
BC_DAT_ECE1117: length 244.7
  TOP w0.109: RE365.1 142.13,29.89 v1(141.54,29.3) 140.76,29.3 140.52,29.07 v2(140.52,28.81) 140.52,27.74 140.82,27.44 140.82,27.01 140.71,26.9 140.3,26.9 139.92,27.27 139.24,27.27 138.82,26.85 UE1.D12 ; JKBTP1.8 290.16,11.7 290.16,11.7 290.16,7.4 287.74,4.98 281.66,4.98 281.44,5.2 v2(281.44,5.41)
  IN2 w0.081: v2(281.44,5.41) 281.44,5.27 280.69,4.53 276.5,4.53 274.87,6.16 274.87,8.02 273.19,9.7 270.96,9.7 269.98,10.68 269.45,10.68 268.94,11.18 267.82,11.18 266.01,13 266.01,14.42 264.96,15.47 251.99,15.47 250.7,14.17 240.69,14.17 240.06,14.8 221.14,14.8 219.82,13.48 213.2,13.48 210.81,11.09 210.81,10.32 211.87,9.26 211.87,8.25 v2(211.68,8.06)
  IN4 w0.102: v2(211.68,8.06) 212.29,7.44 212.29,6.9 211.8,6.4 211.06,6.4 210.48,5.82 210.48,3.76 209.99,3.28 205.84,3.28 205.39,3.73 193.42,3.73 193.26,3.9 183.83,3.9 183.1,3.17 178.18,3.17 176.85,4.5 174.45,4.5 171.15,7.8 164.69,7.8 164.52,7.63 161.41,7.63 158.03,11.01 156.9,11.01 156.45,11.46 154.99,11.46 154.49,10.96 151.34,10.96 150.76,10.38 147.54,10.38 146.58,9.43 144.62,9.43 143.98,10.06 142.05,10.06 140.92,8.93 137.15,8.93 136.84,8.61 134.98,8.61 134.38,8.01 130.91,8.01 128.85,10.08 125.85,10.08 119.63,16.3 119.63,17.29 118.42,18.5 118.42,19.62 119.05,20.26 119.05,24.18 119.39,24.52 121.8,24.52 122.37,25.08 123.97,25.08 126.35,27.46 129.36,27.46 130.05,28.16 130.05,29.01 130.68,29.63 133.86,29.63 134.02,29.47 136.95,29.47 137.48,28.94 139.66,28.94 139.79,28.81 v2(140.52,28.81)
BC_INT#_ECE1117: length 229.4
  TOP w0.109: UE1.E2 130.34,26.44 129.41,26.44 127.16,28.69 v2(126.54,28.69) ; v2(282.02,3.35) 283.41,4.74 287.84,4.74 290.66,7.56 290.66,11.7 290.66,11.7 JKBTP1.7
  IN2 w0.081: v2(282.02,3.35) 281.6,2.93 274.57,2.93 272.17,5.33 269.82,5.33 267.45,7.7 267.45,10.43 265.26,12.61 265.26,13.5 264.4,14.37 261.41,14.37 260.58,13.54 253.15,13.54 252.96,13.35 238.57,13.35 238.15,13.77 231.27,13.77 230.71,13.21 220.43,13.21 219.76,12.53 213.31,12.53 211.98,11.21 211.98,10.4 212.67,9.72 212.67,7.43 211.13,5.89 v2(211.13,5.11)
  IN4 w0.102: v2(211.13,5.11) 211.13,3.24 210.7,2.8 205.66,2.8 205.46,3 205.11,3 204.71,2.6 193.6,2.6 192.89,3.31 188.82,3.31 187.85,2.34 178.36,2.34 176.66,4.04 174.16,4.04 170.87,7.34 164.88,7.34 164.71,7.17 161.1,7.17 157.72,10.55 156.3,10.55 155.63,9.88 147.79,9.88 145.5,7.59 139.04,7.59 138.55,8.08 135.37,8.08 134.85,7.56 130.7,7.56 128.66,9.59 125.65,9.59 119.16,16.08 119.16,17.11 117.96,18.32 117.96,18.75 117.46,19.25 117.46,20.25 117.85,20.64 117.85,24.13 119.32,25.6 123.73,25.6 126.54,28.4 v2(126.54,28.69)
BCM5882_ALERT#: length 96.7
  TOP w0.102: UE1.G10 v2(136.73,24.85)
  TOP w0.109: JUSH1.14 182.6,3.27 182.79,3.45 182.79,4.92 182.41,5.29 181.14,5.29 179.92,6.51 179.3,6.51 178.91,6.12 178.23,6.12 177.23,7.12 177.23,7.91 178.21,8.89 179.72,8.89 v2(181.11,10.27)
  IN4 w0.102: v2(181.11,10.27) 180.57,10.81 180.06,10.81 179.4,11.47 178.87,11.47 176.6,13.75 174.53,13.75 172.7,15.57 172.36,15.57 171.75,16.17 171.42,16.17 171.28,16.03 169.83,16.03 169.59,15.8 166.74,15.8 164.96,17.58 164.29,17.58 163.55,18.32 163.01,18.32 162.78,18.09 161.74,18.09 160.39,19.43 160.39,19.91 159.97,20.33 157.95,20.33 157.69,20.07 155.88,20.07 153.87,22.08 153.36,22.08 153.15,22.29 152.03,22.29 151.18,23.14 148.76,23.14 145.74,20.12 145.74,19.61 143.46,17.33 141.16,17.33 139.76,18.74 139.2,18.74 138.53,18.07 138.53,17.88 137.78,17.13 134.14,17.13 132.72,18.56 132.72,18.74 132.01,19.45 131.73,19.45 130.72,20.46 130.72,21.07 130.92,21.28 131.42,21.28 131.55,21.41 131.55,23.59 131.67,23.71 132.33,24.36 132.33,24.97 132.58,25.22 136.18,25.22 136.54,24.85 v2(136.73,24.85)
  BOTTOM w0.102: v2(136.73,24.85) 136.73,23.84 136.32,23.43 136.32,19.82 136.78,19.36 136.78,18.58 137.14,18.22 137.14,17.67 137.5,17.31 RE532.2
BEEP: length 313.2
  TOP w0.102: UE1.H11 v2(138.33,23.25)
  IN2 w0.081: v2(129.07,4.37) 128.28,3.59 128.28,2.31 129.31,1.28 136.9,1.28 138.16,2.54 141.99,2.54 144.79,5.35 145.58,5.35 146.01,5.78 146.01,6.57 148.58,9.14 155.59,9.14 156.63,10.17 157.58,10.17 161.15,6.6 165.6,6.6 166.18,7.18 169.96,7.18 172.22,4.92 176.15,4.92 178.85,2.22 188.89,2.22 189.62,2.95 191.4,2.95 192.05,3.6 197.18,3.6 197.84,4.26 204.77,4.26 206.27,2.77 211.2,2.77 212.31,3.87 212.31,5.19 213.26,6.14 214.17,6.14 214.55,6.52 214.55,9.02 215.64,10.12 218.58,10.12 220.67,12.21 227.83,12.21 228.36,11.69 236.61,11.69 238.23,10.06 251.63,10.06 252.76,11.19 266.04,11.19 266.99,10.24 266.99,7.51 269.61,4.89 271.66,4.89 274.1,2.46 282.51,2.46 283.24,3.18 291.61,3.18 292.08,3.66 299.58,3.66 300.79,2.45 309.99,2.45 310.56,3.02 312.97,3.02 314.01,1.99 323.47,1.99 326.69,5.2 328.37,5.2 330.82,7.65 335.46,7.65 336.08,8.27 336.48,8.27 v2(336.68,8.07) ; v2(336.41,25.86) 336.41,27.31 337.03,27.93 337.03,29.48 340.4,32.85 344.35,32.85 345.06,32.14 350.08,32.14 351.94,30.27 354.3,30.27 v2(354.67,29.9)
  IN3 w0.081: v2(131.74,8.68) 132.15,8.27 133.99,8.27 135.24,9.53 136.26,9.53 137.53,10.8 137.53,11.03 138.25,11.75 138.25,12.37 138.88,12.99 138.88,14.47 139.72,15.32 139.72,18.61 138.62,19.72 138.62,20.46 138.79,20.63 138.79,22.96 138.5,23.25 v2(138.33,23.25) ; v2(336.68,8.07) 336.68,8.67 337.11,9.1 337.4,9.1 341,12.69 341,24.34 339.97,25.37 336.91,25.37 v2(336.41,25.86)
  BOTTOM w0.109: v2(131.74,8.68) 131.74,8.31 129.74,6.31 129.74,5.04 v1(129.52,4.82) v2(129.07,4.37) ; v2(354.67,29.9) 354.5,30.07 RA13.2
BEEP_R: length 3.5
  BOTTOM w0.254: RA13.1 352.96,30.01 RA209.1 352.97,29.2 CA227.1 352.94,28.38 352.54,27.98 352.54,27.92 351.79,27.17 CA28.1
BGPO0: length 13.9
  TOP w0.102: UE1.D6 v2(133.53,27.25)
  TOP w0.109: RE749.1 125.27,21.59 125.58,21.9 v2(125.58,22.36)
  IN4 w0.102: v2(133.53,27.25) 133.53,27.46 133.1,27.89 133.1,28.26 132.7,28.66 131.81,28.66 131.32,28.17 131.17,28.17 129.12,26.12 128.22,26.12 127.4,25.3 127.4,23.67 126.92,23.19 126.41,23.19 v2(125.58,22.36)
BIA_PWM: length 41.8
  TOP w0.109: DV40.1 133.48,49.21 RV839.1 132.44,49.26 132.14,48.96 DV38.1 DV39.1 131.49,47.3 130.67,48.12 128.98,48.12 v1(128.88,48.02) v2(128.44,47.58)
  IN2 w0.081: v2(128.44,47.58) 127.88,48.14 126.43,48.14 122.92,44.63 119.17,44.63 114.06,49.75 107.02,49.75 106.37,49.1 104.28,49.1 v2(101.68,46.5)
  BOTTOM w0.109: LV1.2 101.76,46.42 v2(101.68,46.5)
BIA_PWM_EC: length 64.7
  TOP w0.109: DV40.2 136.42,48.74 v2(136.42,48.21) ; UE1.N1 129.93,19.39 v2(128.43,17.89)
  IN2 w0.081: v2(128.43,17.89) 128.17,17.62 126.2,17.62 125.47,18.36 122.63,18.36 121.37,19.62 121.06,19.62 120.82,19.86 120.82,20.12 120.12,20.82 119.3,20.82 118.91,21.21 117.1,21.21 v2(116.82,20.92)
  BOTTOM w0.109: v2(116.82,20.92) 116.82,20.89 117.13,20.89 117.92,21.68 121.76,21.68 121.86,21.78 121.86,22.37 123.66,24.17 123.66,24.58 122.5,25.74 122.5,29.42 123.52,30.44 123.52,30.98 121.48,33.02 121.48,34.79 122.2,35.51 124.72,35.51 125.29,36.09 125.29,36.86 125.56,37.9 126.01,39.26 126.18,39.68 126.18,45.69 126.99,46.49 126.99,48.04 127.1,48.15 130.2,48.15 v1(130.82,48.77) 135.87,48.77 v2(136.42,48.21)
BIA_PWM_PCH: length 82.2
  TOP w0.089: UH1.AU48 178.96,20.36 178.96,20.78 v2(179.43,21.25)
  TOP w0.109: v2(138.83,38.68) 138.83,39.44 137.89,40.38 134.76,40.38 134.6,40.53 130.47,40.53 129.9,39.96 128.91,39.96 127.13,41.73 v1(127.13,42.89) 127.13,47.81 128.25,48.93 DV38.2
  IN1 w0.102: v2(179.43,21.25) 178.22,21.25 177.78,21.7 177.14,21.7 175.94,22.89 172.93,22.89 171.27,24.55 168.29,24.55 167.58,25.25 165.38,25.25 164.78,25.86 163.71,25.86 163.71,25.86 161.31,25.86 161.28,25.9 160.64,25.9 160.38,25.64 160.38,25.38 160.04,25.04 159.33,25.04 158.34,26.03 156.49,26.03 156.04,25.59 147.79,25.59 v2(147.49,25.28)
  BOTTOM w0.109: v2(147.49,25.28) 147.58,25.38 147.58,28.92 147.29,29.2 147.29,30.46 145.19,32.57 143.48,32.57 143.25,32.79 141.84,32.79 141.17,33.46 140.76,33.46 139.8,32.51 138.75,32.51 138.39,32.87 138.39,33.91 139.09,34.61 139.09,38.41 v2(138.83,38.68)
BIOS_REC: length 9.1
  TOP w0.089: v2(178.88,23.09) 179.08,22.89 UH1.AR42
  BOTTOM w0.109: RH76.2 178.02,17.5 178.02,17.61 178.7,18.3 178.7,18.69 178.28,19.11 178.28,20.41 177.69,21 177.69,22.02 178.76,23.09 v2(178.88,23.09) 178.88,23.78 v1(179.15,24.05)
BL_PWR_SRC_ON: length 20.2
  TOP w0.109: v2(78.68,52.34) v3(79.81,52.34)
  IN4 w0.254: v2(78.68,52.34) 79.37,52.34 81.23,54.21 81.23,56.87 v2(80.65,57.46)
  BOTTOM w0.254: v2(80.65,57.46) 80.79,57.32 RV5.1 ; v2(82.49,43) 82.49,44.39 81.34,45.55 81.34,46.11 79.7,47.75 79.7,49.18 80.01,49.49 80.01,51.02 v2(78.68,52.34)
BOARD_ID: length 8
  TOP w0.109: UE1.J13 139.93,22.85 141.55,24.47 141.85,24.47 CE40.1 142.36,24.99 143.15,24.99 143.45,24.69 144.42,24.69 144.62,24.89 RE79.2 145.85,25.25 v1(146.01,25.42)
BQ24780_REGN: length 26
  TOP w0.203: PC706.1 291.72,28.76 290.64,29.84 289.91,29.84 289.85,29.9 PU700.24
  TOP w0.508: v2(296.2,25.73) 294.38,25.73 v1(294.17,25.94) 294.01,26.1 294.01,28.18 293.28,28.91 PD702.1 292.92,28.76 PC706.1 ; PR712.1 289.37,36.79 289.93,36.79 v2(290.5,37.36)
  IN1 w0.508: v2(296.2,25.73) 295.06,25.73 292.19,28.61 292.19,36.02 290.85,37.36 v2(290.5,37.36)
BREATH_LED#: length 245.1
  TOP w0.109: v2(139.74,30.59) 139.74,30.56 139.35,30.17 139.35,29.54 139.06,29.25 139.06,29.11 138.87,28.92 138.75,28.92 138.41,28.58 138.41,28.12 UE1.C11 ; v2(316.57,46.57) 316.78,46.36 QZ7.3 ; v2(185.05,60.11) v1(185.05,60.78) 185.05,61.2 192.23,68.38 192.23,72.03 191.87,72.4 191.87,75.08 199.86,83.07 203.13,83.07 213.17,73.03 259.83,73.03 270.62,83.82 274.34,83.82 275.69,85.17 v2(275.69,85.51)
  IN2 w0.081: v2(139.74,30.59) 140.1,30.95 140.63,30.95 140.91,30.67 144.42,30.67 144.55,30.54 145.3,30.54 146.37,31.61 151.91,31.61 152.34,32.04 155.12,32.04 156.06,32.98 157.25,32.98 157.66,33.39 157.66,34.13 158.33,34.81 158.33,34.81 160.62,37.09 162.51,37.09 163.41,37.99 166.67,37.99 167.45,38.77 167.45,39.25 169,40.81 169.78,40.81 170.76,41.79 170.76,42.53 170.21,43.09 170.21,43.68 172.58,46.05 172.58,48.16 173.87,49.45 173.87,50.1 175.83,52.06 176.47,52.06 181.39,56.98 181.39,58.15 183.35,60.11 v2(185.05,60.11) ; v2(275.69,85.51) 274.67,84.49 274.67,83.67 275.68,82.66 275.68,80.62 279.5,76.8 286.4,76.8 292.98,70.22 292.98,66.65 297.78,61.84 299.64,61.84 314.91,46.57 v2(316.57,46.57)
BREATH_LED#_Q: length 3.6
  TOP w0.109: v1(317.96,47.03) 317.96,47.47 RZ32.1 316.13,48.06 QZ7.1
BREATH_LED#_R: length 5.2
  TOP w0.109: JPB1.4 318.33,45.25 318.15,45.43 v1(318.15,45.59) 318.15,46.23 318.4,46.48 318.4,47.95 RZ32.2
BST_1.2V: length 4.7
  TOP w0.109: 207.27,11.52 208.74,11.52 v1(209.98,10.28)
  TOP w0.508: PR200.2 207.29,10.34 207.48,10.53 207.48,10.98 207.18,11.28
BST_1.2V_R: length 2.7
  TOP w0.109: v1(208.02,7.57) 208.69,8.25 208.69,8.8
  TOP w0.508: PC201.2 208.69,8.8 PR200.1
BST_3V: length 1.8
  TOP w0.109: v1(113.2,3.26) 113.2,3.51 112.3,4.41 111.99,4.41
BST_3VR: length 0.9
  BOTTOM w0.109: v2(311.49,26.01) v3(312.38,26.01)
BST_5VR: length 1.4
  TOP w0.109: v1(310.29,35.51) 309.98,35.82 PR501.1
BST_+1VSP: length 2.9
  TOP w0.109: 149.82,10.08 149.7,9.95 148.06,9.95 147.51,10.49 v1(147.51,10.82)
BST_IO:
  vias: v1(275.48,100.77)
BST_IO_R: length 2.4
  BOTTOM w0.109: v1(279.08,102.24) 278.7,101.85 PC305.1
  BOTTOM w0.508: PC305.1 278.05,100.63 PR302.2
BT_RADIO_DIS#: length 335.4
  TOP w0.109: v1(110.86,24.1) 110.62,23.86 v2(110.13,23.86) ; v2(128.73,30.05) 128.73,29.98 128.71,29.96 128.71,29.44 129.61,28.54 129.61,28.32 129.89,28.04 130.34,28.04 UE1.C2
  IN1 w0.102: v2(330.94,22.49) 330.62,22.49 329.76,23.35 329.76,24.73 328.11,26.38 324.88,26.38 320.77,30.49 320.77,35.81 319.44,37.14 314.23,37.14 311.72,39.66 311.57,39.66 308.97,42.26 308.97,43.61 308.08,44.5 304.99,44.5 304.41,43.91 297.1,43.91 295.56,42.38 291.56,42.38 289.48,40.29 281.56,40.29 278.11,36.84 278.11,35.44 275.15,32.47 275.15,26.27 274.52,25.64 273.18,25.64 270.44,22.9 263.05,22.9 260.23,25.71 257.31,25.71 v2(257.06,25.97)
  IN3 w0.081: v2(128.73,30.05) 128.12,30.05 127.1,29.03 127.1,28.6 126.72,28.21 126.35,28.21 123.68,25.54 121.57,25.54 121.25,25.87 117.53,25.87 117.25,25.59 113.16,25.59 112.23,24.66 110.93,24.66 v2(110.13,23.86) ; v2(257.06,25.97) 257.06,20.58 250.75,14.26 231.61,14.26 229.06,11.71 213.09,11.71 210.15,8.78 210.15,4.97 208.99,3.81 196.8,3.81 194.26,1.27 179.66,1.27 177.2,3.73 175.7,3.73 175.2,3.22 175.2,2.8 175.52,2.48 175.52,1.66 175.45,1.59 172.27,1.59 171.48,2.38 171.48,4.62 169.87,6.22 167.47,6.22 165.78,4.53 165.78,2.17 165.07,1.46 116.57,1.46 v2(116.19,1.84)
  IN4 w0.102: v2(116.19,1.84) 115.09,1.84 111.82,5.1 111.82,11.02 109.74,13.1 107.89,13.1 103.55,17.45 103.55,23 103.94,23.4 106.81,23.4 107.26,22.96 109.74,22.96 110.13,23.34 v2(110.13,23.86)
  BOTTOM w0.109: DZ2.1 330.35,22.49 v2(330.94,22.49) ; RE11.1 128.98,33.25 128.98,30.31 v2(128.73,30.05)
BT_RADIO_DIS#_R: length 3.2
  BOTTOM w0.109: JNGFF1.46 330.15,18.28 330.41,18.54 v1(330.41,19.54) 330.41,20.21 DZ2.2
C10_PWR_GATE#: length 7.8
  TOP w0.109: UZ35.1 195.72,94.17 196.14,93.76 196.14,92.42 195.83,92.11 UZ61.4 196.46,91.27 RZ542.1 197.27,91.32 v1(197.27,90.59) 197.27,89.96 RC562.2
CAM_MIC_CBL_DET#: length 133
  TOP w0.089: UH1.AW13 v2(177.46,37.96)
  TOP w0.109: JEDP1.17 102.5,44.04 v2(102.13,44.41)
  IN2 w0.081: v2(112.36,21.46) 112.36,21.38 113.95,19.78 115.15,19.78 115.4,19.54 116.58,19.54 116.99,19.13 118.04,19.13 119.67,17.5 119.67,17.08 120.24,16.51 124.04,16.51 124.46,16.08 125.83,16.08 126.37,16.62 129.62,16.62 130.31,17.31 131.9,17.31 132.31,17.72 133.27,17.72 133.71,17.28 135.75,17.28 135.96,17.07 137.44,17.07 138.63,18.26 139.44,19.07 139.78,19.07 141.16,20.44 141.16,20.53 141.83,21.2 144.35,21.2 146.09,22.95 146.47,22.95 149.07,25.55 152.32,25.55 153.33,26.55 154.28,26.55 154.95,27.22 157.26,27.22 157.87,27.83 158.52,27.83 158.78,28.09 159.62,28.09 159.75,28.22 160.03,28.22 160.36,28.55 161.07,28.55 161.99,29.47 162.59,29.47 163.83,30.71 163.83,32.83 164.67,33.67 167.55,33.67 168.73,34.84 168.73,35.44 168.94,35.65 170.49,35.65 170.91,36.08 170.91,36.91 171.07,37.07 173.56,37.07 174.72,38.23 176.08,38.23 176.36,37.96 v2(177.46,37.96)
  BOTTOM w0.109: v2(102.13,44.41) 101.2,44.41 100.65,43.86 100.65,41.58 100.29,41.22 99.75,41.22 98.98,40.45 98.98,39.8 98.36,39.18 97.3,39.18 95.75,37.64 95.75,36.11 95.5,35.86 95.5,34.2 96.12,33.59 96.12,31.35 97.66,29.82 97.66,28.37 98.74,27.28 98.74,24.71 98.05,24.01 98.05,20.61 99.8,18.86 106.46,18.86 106.9,18.42 v1(108.02,18.42) 109.93,18.42 112.36,20.84 v2(112.36,21.46) ; RH319.2 176.64,41.39 176.93,41.1 177.58,41.1 177.89,40.79 177.89,40.26 177.96,40.19 177.96,39.87 177.46,39.37 v2(177.46,37.96)
CCG5_AR_RST#: length 75.6
  TOP w0.109: RT37.2 25.83,41.93 25.52,42.24 25.13,42.24 23.52,43.85 v1(23.52,45.22) 23.52,46.43 22.88,47.06 v2(22.88,48.7)
  IN3 w0.081: v2(22.88,48.7) 22.88,47.85 23.27,47.46 23.7,47.46 23.89,47.65 24.8,47.65 26.63,49.48 28.22,49.48 28.66,49.05 33.63,49.05 33.76,48.93 35.83,48.93 36.45,48.3 37.05,48.3 37.19,48.16 37.19,45.34 37.82,44.71 37.82,42.54 39.74,40.61 39.74,38.77 40.53,37.99 40.53,37.69 44.01,34.2 46.44,34.2 46.74,34.5 47.64,34.5 48.4,35.26 48.79,35.26 49.51,35.98 49.51,36.32 50.32,37.13 51.18,37.13 51.38,36.93 52.96,36.93 v2(53.36,36.53) 53.74,36.91 54.67,36.91 55.85,35.73 58.4,35.73 59.51,34.61 60.66,34.61 61.46,33.82 61.46,31.94 60.19,30.68 v2(60.19,28.63)
  BOTTOM w0.076: 57.16,27.79 57.11,27.84 57.11,28.29 UT5.B2
  BOTTOM w0.109: v2(53.36,36.53) 53.36,36.86 53.27,36.95 52.66,36.95 52.5,37.1 JCCG1.4 ; v2(60.19,28.63) 59.62,28.63 59.02,28.04 59.02,27.06 58.81,26.85 58.32,26.85 57.63,27.54 57.41,27.54 57.16,27.79
CCG5_I2C_INT1#: length 141.9
  TOP w0.102: UE1.F10 v2(137.53,25.65)
  IN1 w0.102: v2(59.27,35.43) 59.27,35.06 56.7,32.49 53.24,32.49 52.82,32.07 52.82,31.16 51.91,30.26 v2(51.91,30.22) ; v2(98.63,34.03) 98.32,34.34 98.32,36 100.27,37.95 100.27,38.61 101.25,39.58 101.25,41.34 100.55,42.04 100.55,44.3 98.3,46.55 97.72,46.55 v2(97.31,46.13)
  IN2 w0.081: v2(98.63,34.03) 99.33,33.33 100.39,33.33 100.7,33.02 100.7,32.66 101.23,32.12 102.04,32.12 102.84,31.32 102.84,30.56 103.97,29.44 108.41,29.44 109.64,28.22 115.08,28.22 117.18,26.11 117.18,25.31 117.96,24.53 119.58,24.53 120.37,23.74 120.37,23.59 120.94,23.03 121.72,23.03 121.73,23.02 124.06,23.02 125.49,21.59 125.49,21.26 126.16,20.59 126.7,20.59 126.81,20.7 129.28,20.7 129.72,21.15 129.72,23.45 130.73,24.46 137.02,24.46 137.12,24.57 137.12,24.98 137.53,25.39 v2(137.53,25.65)
  IN3 w0.081: v2(92.87,49.8) 93.1,49.56 93.1,48.24 88.9,44.04 85.83,44.04 82.63,47.24 80,47.24 77.34,49.9 73.15,49.9 72.15,50.9 69.11,50.9 v2(67.5,49.29)
  BOTTOM w0.102: RE91.1 141.53,30.11 140.67,29.25 140.06,29.25 139.79,28.98 139.79,28.17 139.28,27.66 138.48,26.85 138.15,26.85 137.91,26.61 137.91,26.12 137.53,25.74 v2(137.53,25.65)
  BOTTOM w0.109: v2(97.31,46.13) 93.63,49.8 v2(92.87,49.8) ; v2(67.5,49.29) 67.5,49.29 67.19,48.97 67.19,43.02 v1(64.74,40.57) 64.28,40.11 61.75,40.11 61.35,39.71 61.35,37.14 60.61,36.4 60.24,36.4 v2(59.27,35.43) ; v2(51.91,30.22) 52.1,30.04 UT5.L5
CCG5_ILIM1#: length 4.2
  TOP w0.109: QT9.2 66.18,24.46 65.8,24.83 v1(65.38,24.83) 65.28,24.73 65.28,24.39 65.39,24.27 RT589.2 65.22,23.98 64.96,23.73 64.96,22.43 RT584.2
CCG5_ILIM2#: length 21.5
  BOTTOM w0.109: RT590.2 60.38,33.79 60.58,33.58 60.58,31.81 60.78,31.61 60.78,30.27 61.25,29.8 61.25,28.07 62.89,26.43 63.48,26.43 63.9,26.85 64.35,26.85 65.48,25.71 66.33,25.71 67.79,27.17 68.41,27.17 68.48,27.09 v1(69.46,27.09) 70.29,27.09 70.52,26.86 70.52,26.61 70.96,26.17 70.96,25.7 70.01,24.75 RT583.2 70.88,24.51 QT8.2
CCG5_SMBCLK: length 122.7
  TOP w0.102: UE1.C3 131.16,28.02 v2(131.16,28.8)
  TOP w0.109: v2(52.22,39.55) 52.04,39.37 v1(52.04,39) 52.04,37.6 52.41,37.23 52.41,36.37 52.67,36.11 53.19,36.11 53.36,35.94 RT582.1
  IN1 w0.102: v2(52.22,39.55) 52.39,39.38 52.39,36.37 52.91,35.86 53.86,35.86 55.37,34.34 55.37,33.55 54.51,32.68 53.16,32.68 52.58,32.1 52.58,31.48 v2(51.32,30.23)
  IN2 w0.081: v2(91.43,20.92) 90.92,21.43 90.92,21.72 90.14,22.51 90.14,25.38 89.62,25.89 88.97,25.89 86.03,28.82 83.28,28.82 83.07,28.62 80.62,28.62 78.36,30.88 78.36,31.36 v2(78.17,31.55)
  IN3 w0.081: 56.98,32.78 57.17,32.78 ; 56.98,32.78 57.17,32.78 ; 56.98,32.78 56.68,32.78 56.61,32.71 51.07,32.71 50.83,32.47 50.83,32.47 50.76,32.4 50.76,31.33 51.32,30.76 v2(51.32,30.23) ; 57.17,32.78 58.82,32.78 59.43,32.17 v2(60.14,32.17) ; v2(131.16,28.8) 130.83,28.8 129.25,27.22 126.32,27.22 124.24,25.13 124.24,24.43 123.67,23.86 122.79,23.86 122.54,24.11 120.72,24.11 120.28,24.54 115.22,24.54 114.49,23.81 113.62,23.81 113.07,23.26 112.11,23.26 111.58,22.73 108.36,22.73 105.86,20.23 101.69,20.23 101,19.54 98.68,19.54 98.05,20.17 93.48,20.17 93.24,19.93 91.16,19.93 90.98,20.11 90.98,20.46 v2(91.43,20.92)
  IN4 w0.102: v2(60.14,32.17) 62.08,32.17 62.72,32.8 73.72,32.8 74.3,32.22 77.49,32.22 v2(78.17,31.55)
  BOTTOM w0.102: v2(131.16,28.8) 130.54,28.8 RE303.1
  BOTTOM w0.109: RT580.2 59.95,31.97 v2(60.14,32.17) ; UT5.L6 52.29,30.61 51.71,30.61 v2(51.32,30.23) ; JCCG1.6 53.5,38.28 v2(52.22,39.55)
CCG5_SMBDAT: length 127.3
  TOP w0.102: UE1.B4 131.93,28.85 131.93,29.62 131.78,29.78 131.78,30.48 132.14,30.84 v2(132.41,30.84)
  TOP w0.109: v2(51.64,39.55) 51.64,37.51 52.17,36.97 52.17,36.12 52.56,35.73 RT581.1 ; v2(50.86,30.63) 50.86,30.87 v3(50.48,31.25)
  IN1 w0.102: v2(51.64,39.55) 51.64,39.44 52.16,38.92 52.16,36.28 52.83,35.62 53.77,35.62 55.08,34.31 55.08,33.62 54.42,32.96 53.11,32.96 52.33,32.17 52.33,31.55 51.69,30.92 51.15,30.92 v2(50.86,30.63)
  IN2 w0.081: v2(91.45,21.52) 90.37,22.61 90.37,25.47 89.72,26.12 89.06,26.12 86.13,29.05 83.18,29.05 82.98,28.85 80.72,28.85 79.26,30.31 79.26,31.5 v2(78.45,32.31)
  IN3 w0.081: v2(132.41,30.84) 132.11,30.84 131.29,30.01 130.77,30.01 129.17,28.4 128.9,28.4 128.3,27.8 126.26,27.8 123.77,25.31 123.02,25.31 122.4,24.7 121.25,24.7 120.31,25.64 117.63,25.64 117.36,25.37 114.53,25.37 112.88,23.72 111.92,23.72 111.39,23.19 108.17,23.19 105.72,20.74 101.55,20.74 100.88,20.06 98.81,20.06 98.24,20.63 93.98,20.63 93.1,21.52 v2(91.45,21.52) ; v2(50.86,30.63) 50.55,30.94 50.55,32.51 50.6,32.56 50.6,32.56 51.01,32.97 52.97,32.97 53.05,32.9 56.48,32.9 56.59,33.01 59.27,33.01 v2(59.71,32.57)
  IN4 w0.102: v2(78.45,32.31) 78.26,32.5 74.36,32.5 73.84,33.03 62.4,33.03 62.07,32.69 59.84,32.69 v2(59.71,32.57)
  BOTTOM w0.076: UT5.K6 52.61,30.79 51.02,30.79
  BOTTOM w0.109: JCCG1.5 53,38.19 v2(51.64,39.55) ; RT579.2 60.2,33.06 v2(59.71,32.57) ; RE302.1 131.74,29.89 131.74,30.47 132.11,30.84 v2(132.41,30.84) ; 51.02,30.79 v2(50.86,30.63)
CCG5_SWD_CLK1: length 28.1
  TOP w0.109: RT527.1 49.27,38.98 49.63,38.61 RT526.1 50.01,38.89 50.22,39.09 50.88,39.09 51.14,39.36 51.14,39.86 51.46,40.17 52.29,40.17 52.64,39.82 52.64,37.73 52.71,37.67 52.71,37.61 v1(52.75,37.58) 52.8,37.52 52.8,36.58 v2(52.81,36.57)
  IN1 w0.102: v2(52.81,36.57) 52.8,36.56 52.8,36.35 53.06,36.09 53.95,36.09 55.88,34.15 57.95,34.15 58.65,34.85 58.65,35.53 58.96,35.83 59.44,35.83 59.68,35.59 59.68,35.02 59.51,34.85 59.51,33.91 57.14,31.54 57.14,29.72 v2(56.42,29)
  BOTTOM w0.109: v2(56.42,29) 56.37,28.95 56.37,28.54 UT5.C2 ; JCCG1.3 52,37.01 52.48,36.53 52.75,36.53 52.8,36.57 v2(52.81,36.57)
CCG5_VBUS_5V_ON1#: length 46.4
  TOP w0.109: PR2150.1 38.1,10.6 v2(38.1,11.08) 38.7,11.08 v1(39,11.38) ; v2(43.09,24.25) 43.09,24.78 43.22,24.91 43.52,24.91 44.14,25.54 44.14,26.18 44.33,26.37 44.84,26.37 45.42,26.95 47.57,26.95 47.8,26.72 50.65,26.72 51.39,25.98 51.85,25.98 52.04,26.18 52.04,27.34 52.34,27.64 52.34,28.21 52.04,28.51 51.61,28.51 51.46,28.36 50.89,28.36 RT517.2 50.6,28.95 50.97,29.32 53.13,29.32 v2(53.36,29.55)
  IN4 w0.102: v2(43.09,24.25) 43.09,23.83 41.1,21.84 38.83,21.84 38.18,21.18 38.18,14.68 40.2,12.66 40.2,11.63 39.65,11.08 v2(38.1,11.08)
  BOTTOM w0.109: v2(53.36,29.55) 53.28,29.55 52.87,29.14 UT5.K3 ; UT10.2 46.41,26 46.6,25.81 46.6,25.1 46,24.51 45.59,24.51 44.85,23.77 43.58,23.77 v2(43.09,24.25)
CCG5_VBUS_5V_ON2#: length 59.1
  TOP w0.109: v2(39.74,14.72) 40.01,14.99 40.01,17.1 39.42,17.68 PR2106.1 ; v2(62.08,22.73) v1(61.48,22.73)
  IN2 w0.081: v2(62.08,22.73) 62.08,23.55 61.05,24.58 60.33,24.58 58.81,26.1 58.81,27.01 59.01,27.2 59.01,27.98 58.67,28.32 58.67,28.56 58.4,28.83 57.62,28.83 v2(56.35,30.09)
  IN3 w0.081: v2(39.74,14.72) 40.19,15.17 43.67,15.17 45.53,17.03 45.53,19.13 v2(40.54,24.12) ; v2(51.15,31.72) 51.77,31.1 54.28,31.1 55.29,30.09 v2(56.35,30.09)
  IN4 w0.102: v2(40.54,24.12) 40.49,24.12 39.02,25.59 39.02,28.03 40.99,30 43.55,30 44.96,31.41 48.3,31.41 48.6,31.7 49.2,31.7 49.73,32.23 50.42,32.23 50.92,31.72 v2(51.15,31.72)
  BOTTOM w0.109: v2(56.35,30.09) 56.35,30.05 UT5.B4 ; UT12.2 62.57,22.91 62.39,22.73 v2(62.08,22.73) ; v2(51.15,31.72) 50.63,31.72 50.23,32.12 RT519.2
CCG5_VBUS_DISCHARGE_P1: length 34.6
  TOP w0.109: QT6.2 70.86,24.17 RT567.1 69.9,24.17 69.16,24.91 69.16,25.56 v2(68.74,25.98)
  IN3 w0.081: v2(68.74,25.98) 68.59,26.13 68.59,26.91 68.34,27.16 67.93,27.16 67.57,26.8 65.24,26.8 64.38,25.94 59.06,25.94 58.67,26.33 58.67,26.85 59.01,27.19 59.01,27.93 59.52,28.44 59.52,29.82 58.84,30.49 58.84,31.27 59.26,31.68 60.26,31.68 60.55,31.97 60.55,32.56 59.87,33.24 56.47,33.24 56.35,33.13 53.15,33.13 52.37,33.91 v2(52.37,34.28)
  BOTTOM w0.076: 53.02,33.27 53.03,33.27 53.11,33.19 53.11,32.79 UT5.J10
  BOTTOM w0.109: 53.02,33.27 52.55,33.75 52.55,34.1 v2(52.37,34.28)
CCG5_VBUS_DISCHARGE_P2: length 14.3
  TOP w0.109: QT7.2 45.1,37.14 45.48,37.14 45.7,36.92 46.21,36.92 47.02,37.72 47.84,37.72 48.01,37.89 RT568.1 48.16,38.33 49.07,38.33 49.54,37.86 49.54,36.43 50,35.97 50,35.52 50.64,34.88 51.36,34.88 v1(51.58,34.66) 51.72,34.52 51.72,34.35 52.35,33.71 53.25,33.71 v2(53.33,33.79)
  BOTTOM w0.076: 53.61,33.25 53.61,32.79 UT5.H10
  BOTTOM w0.109: 53.61,33.25 53.61,33.34 53.33,33.62 v2(53.33,33.79)
CCG5_XRES1: length 19.6
  TOP w0.109: RT525.2 55.59,30.43 53.76,30.43 v2(53.46,30.73) 53.55,30.82 CT350.2
  IN3 w0.081: v2(53.46,30.73) 53.43,30.73 52.44,29.75 50.52,29.75 50.24,29.47 49.28,29.47 49,29.75 49,31 49.42,31.42 49.52,31.52 49.52,32.26 49.75,32.5 49.75,34.3 49.23,34.83 49.23,35.39 49.75,35.91 49.75,36.26 50.41,36.92 51.08,36.92 51.16,36.84 v2(51.16,36.6)
  BOTTOM w0.109: v2(51.16,36.6) 51.24,36.6 51.5,36.87 JCCG1.2 ; v2(53.46,30.73) 53.66,30.54 UT5.H6
CFG0: length 50.9
  TOP w0.076: v2(256.89,105.46) 257.21,105.13 UC1.BN25
  TOP w0.109: v2(281,80.36) 280.69,80.05 RC126.1 ; JXDP1.9 283.59,81.65 v2(283.28,81.34)
  IN1 w0.102: v2(256.89,105.46) 256.89,105.65 257.25,106.01 258.13,106.01 259.78,104.36 264,104.36 265.42,102.94 265.42,98.49 268.56,95.35 268.56,94.24 269.23,93.57 270.21,93.57 270.71,94.06 273.65,94.06 276.28,91.44 276.28,89.48 279.2,86.56 279.2,85.86 281.9,83.16 282.7,83.16 282.99,82.87 282.99,82.56 283.28,82.27 v2(283.28,81.34)
  BOTTOM w0.109: v1(284.11,80.56) 284.2,80.65 284.2,81.18 283.97,81.41 283.35,81.41 v2(283.28,81.34) 282.87,80.93 281.62,80.93 281.06,80.36 v2(281,80.36) 280.87,80.5 RC321.1
CFG1: length 48.2
  TOP w0.076: UC1.BN27 257.21,106.7 v2(256.89,107.03)
  TOP w0.109: v2(283.82,82.07) 284,82.25 JXDP1.11
  IN1 w0.102: v2(283.82,82.07) 283.24,82.65 283.24,82.97 282.81,83.41 282.25,83.41 281.86,83.8 281.86,84.55 279.24,87.17 279.24,91.18 277.46,92.95 275.16,92.95 273.79,94.32 270.64,94.32 270.12,93.8 269.32,93.8 268.85,94.27 268.85,95.48 265.65,98.68 265.65,103.1 264.16,104.59 259.97,104.59 257.93,106.63 257.29,106.63 v2(256.89,107.03)
  BOTTOM w0.109: v2(283.82,82.07) 283.13,82.07 282.97,82.22 282.16,82.22 RC436.1
CFG2: length 45.7
  TOP w0.076: v2(257.54,105.46) 257.21,105.78 UC1.BN26
  TOP w0.109: v2(282.4,82.71) 282.85,82.71 283.59,83.45 JXDP1.15
  IN1 w0.102: v2(257.54,105.46) 258.86,104.13 263.87,104.13 265.19,102.81 265.19,98.38 268.33,95.24 268.33,94.14 269.13,93.34 270.31,93.34 270.74,93.77 273.57,93.77 276.02,91.33 276.02,87.6 277.62,86 278.01,86 280.1,83.9 280.83,83.9 282.03,82.71 v2(282.4,82.71)
  BOTTOM w0.109: RC181.1 282.4,82.88 v2(282.4,82.71) 282.56,82.54 283.21,82.54 v1(283.33,82.43)
CFG3: length 50.8
  TOP w0.076: UC1.BN28 257.21,107.36 v2(257.54,107.03)
  TOP w0.109: v2(283.71,84.12) 283.79,84.05 JXDP1.17 284.95,84.05 286.35,82.66 RC121.2
  IN1 w0.102: v2(257.54,107.03) 257.92,107.03 258.42,106.53 260.12,106.53 260.54,106.11 261.89,106.11 263.19,104.82 264.31,104.82 265.88,103.25 265.88,98.77 269.06,95.58 270.05,95.58 270.88,94.75 273.75,94.75 275.32,93.18 277.56,93.18 279.47,91.27 279.47,87.26 282.08,84.64 282.08,83.9 282.28,83.7 283.29,83.7 v2(283.71,84.12)
  BOTTOM w0.109: v1(284.04,83.58) 283.71,83.91 v2(283.71,84.12)
CFG4: length 35.2
  TOP w0.076: UC1.BR20 258.81,101.42 259.28,101.42 259.9,100.8 261.84,100.8 262.19,101.15 262.42,101.15
  TOP w0.109: v2(264.39,100.25) 264.39,101.43 RC322.1 263.49,101.15 262.42,101.15 ; v2(283.26,87.38) 283.59,87.05 JXDP1.27
  IN4 w0.102: v2(283.26,87.38) 282.74,87.9 282.74,88.55 281.5,89.79 281.5,90.13 276,95.62 275.33,95.62 273.9,97.06 271.55,97.06 271.13,96.63 269.07,96.63 267.95,97.75 266.89,97.75 v2(264.39,100.25)
  BOTTOM w0.109: v2(264.39,100.25) v1(264.39,100.96)
CFG5: length 39.8
  TOP w0.076: v2(256.89,100.73) 256.56,101.06 UC1.BM20
  TOP w0.109: JXDP1.29 283.58,87.65 283.4,87.83 283.12,87.83 v2(282.68,87.38) ; v1(264.07,97.88) 262.64,97.88 RC323.1 v2(261.33,97.26)
  IN4 w0.102: v2(282.68,87.38) 281.76,86.47 280,86.47 279.44,87.02 279.44,88.35 278.65,89.15 278.36,89.15 277.77,89.74 276.63,89.74 276.41,89.96 276.41,91.46 273.6,94.27 270.71,94.27 270.43,93.99 269.39,93.99 267.26,96.12 265.34,96.12 263.98,97.48 261.55,97.48 v2(261.33,97.26) 260.95,97.26 260.51,97.69 257.48,100.73 v2(256.89,100.73)
CFG6: length 33.3
  TOP w0.076: UC1.BT20 259.7,100.59 262.02,100.59 RC324.1
  TOP w0.109: RC324.1 261.94,100.16 v2(261.58,100.16) ; JXDP1.33 283.26,88.85 v2(283.09,89.02)
  IN4 w0.102: v2(283.09,89.02) 282.94,89.02 276.1,95.85 275.43,95.85 273.99,97.29 271.46,97.29 271.03,96.86 269.16,96.86 268.04,97.98 267.24,97.98 264.5,100.72 262.14,100.72 v2(261.58,100.16)
  BOTTOM w0.109: v2(283.09,89.02) v1(283.83,89.02)
CFG7: length 36.4
  TOP w0.076: v2(260.69,101.78) 260.41,101.78 260.12,101.49 259.54,101.49 259.42,101.62 258.59,101.62 258.39,101.42 258.15,101.42 UC1.BP20
  TOP w0.109: JXDP1.35 282.73,89.45 282.34,89.06 v2(282.34,88.38) ; v2(260.69,101.78) RC325.1
  IN4 w0.102: v2(260.69,101.78) 261.17,101.31 261.17,99.95 261.33,99.79 263.67,99.79 265.94,97.52 267.85,97.52 268.97,96.4 271.22,96.4 271.65,96.83 273.8,96.83 275.24,95.39 275.91,95.39 281.25,90.06 281.25,89.47 v2(282.34,88.38)
  BOTTOM w0.109: v1(282.12,87.72) 282.34,87.94 v2(282.34,88.38)
CFG8: length 41.4
  TOP w0.076: RC437.1 262.64,104.25 v1(262.31,104.25) 259.68,104.25 259.41,103.98 259.01,103.98 UC1.BR23
  TOP w0.109: JXDP1.10 281.69,81.96 282.65,81.96 v2(282.81,81.81) ; RC437.1 263.33,103.63 v2(263.26,103.55)
  IN1 w0.102: v2(263.26,103.55) 263.26,102.4 264.96,100.7 264.96,98.21 267.23,95.94 267.23,94.46 268.58,93.11 270.4,93.11 270.79,93.5 273.49,93.5 275.77,91.22 275.77,86.94 279.29,83.42 280.79,83.42 282.41,81.81 v2(282.81,81.81)
CFG9: length 44.2
  TOP w0.076: 262.79,102.33 258.89,102.33 UC1.BR22
  TOP w0.109: 262.79,102.33 264.3,102.33 264.71,101.92 RC438.1 265.38,101.92 265.76,102.3 266.23,102.3 266.31,102.39 RC439.1 266.84,102.32 266.84,99.98 v3(266.21,99.34) 264.31,97.44 v2(264.31,96.23) ; v2(281.05,82.18) 281.41,82.55 JXDP1.12
  IN4 w0.102: v2(281.05,82.18) 280.67,82.55 280.67,83.59 278.97,85.29 278.97,86.49 278.71,86.75 278.31,86.75 277.95,86.39 277.37,86.39 275.8,87.96 275.8,91.42 273.44,93.78 270.87,93.78 270.51,93.42 268.46,93.42 267.37,94.51 267.37,94.98 266.77,95.58 264.95,95.58 v2(264.31,96.23)
CFG10: length 43.9
  TOP w0.076: UC1.BT23 259.43,103.49 259.85,103.91 261.74,103.91 v2(262.11,103.54)
  TOP w0.109: RC440.1 262.47,103.54 v2(262.11,103.54) ; v2(282.53,84.17) 282.11,83.75 JXDP1.16
  IN4 w0.102: v2(262.11,103.54) 264.47,101.18 264.96,101.18 265.92,100.22 266.84,100.22 267.29,100.66 268.7,100.66 269.59,99.77 272.52,99.77 275.71,96.59 276.38,96.59 279.91,93.06 281.42,93.06 282.83,91.65 283.33,91.65 284.72,90.27 284.72,83.96 284.22,83.46 283.24,83.46 v2(282.53,84.17)
  BOTTOM w0.109: v2(282.53,84.17) 282.3,83.94 v1(282.3,83.49)
CFG11: length 42.1
  TOP w0.076: v2(261.52,103.55) 260.01,103.55 UC1.BT22
  TOP w0.109: RC441.1 261.96,103.18 261.88,103.18 v2(261.52,103.55) ; JXDP1.18 281.95,84.35 282.22,84.62 282.78,84.62 283.12,84.28 v2(283.12,84.16)
  IN4 w0.102: v2(261.52,103.55) 264.12,100.95 264.68,100.95 266.11,99.52 272.45,99.52 275.64,96.33 276.26,96.33 282.83,89.77 284.01,89.77 284.49,89.29 284.49,84.1 284.08,83.68 283.39,83.68 283.12,83.95 v2(283.12,84.16)
  BOTTOM w0.109: v1(282.86,84.65) 283.12,84.38 v2(283.12,84.16)
CFG12: length 38
  TOP w0.076: 260.63,98.83 260.63,99.41 260.19,99.86 258.9,99.86 258.84,99.93 256.97,99.93 UC1.BM19
  TOP w0.109: 260.63,98.83 260.63,97.19 261.08,96.75 261.63,96.75 RC442.1 261.72,96.08 261.5,96.08 v2(261.33,96.24) ; JXDP1.28 281.35,87.35 281.19,87.51 280.75,87.51 280.27,87.99 279.87,87.99 279.62,87.74 v1(279.62,86.97) v2(279.62,86.21)
  IN4 w0.102: v2(261.33,96.24) 261.82,96.74 264.4,96.74 265.26,95.88 267.16,95.88 269.39,93.65 270.41,93.65 270.79,94.03 273.52,94.03 276.18,91.37 276.18,88.93 276.44,88.67 277.18,88.67 277.98,87.87 278.27,87.87 279.62,86.52 v2(279.62,86.21)
CFG13: length 32.1
  TOP w0.076: RC443.1 262.02,98.67 261.68,99 261.03,99 260.87,99.17 260.87,99.52 260.35,100.04 259,100.04 258.7,100.34 UC1.BR19
  TOP w0.109: v1(279.63,88.61) 279.76,88.74 v2(280.34,88.74) 280.34,88.36 280.75,87.95 JXDP1.30 ; v2(261.34,98.47) 261.41,98.4 RC443.1
  IN4 w0.102: v2(261.34,98.47) 261.66,98.79 263.7,98.79 265.68,96.81 267.59,96.81 268.69,95.72 270.9,95.72 271.64,94.97 273.87,94.97 274.14,94.71 275.51,94.71 279.58,90.64 279.58,89.29 280.09,88.77 280.31,88.77 v2(280.34,88.74)
CFG14: length 29.4
  TOP w0.076: 261.33,99.78 261.08,99.78 260.44,100.42 259.57,100.42 259.3,100.69 258.22,100.69 UC1.BP19
  TOP w0.109: JXDP1.34 280.62,89.15 v2(280.21,89.55)
  TOP w0.127: v2(262.72,99.4) 262.34,99.78 261.33,99.78
  IN4 w0.102: v2(280.21,89.55) 280.15,89.62 280.15,90.72 275.87,95 275.7,95.17 274.33,95.17 274.06,95.43 271.88,95.43 271.14,96.17 268.88,96.17 267.76,97.29 265.84,97.29 263.74,99.4 v2(262.72,99.4)
CFG15: length 28.2
  TOP w0.076: v2(261.44,99.4) 261.23,99.4 260.38,100.24 259.26,100.24 UC1.BT19
  TOP w0.109: JXDP1.36 281,89.75 v2(280.84,89.59)
  IN4 w0.102: v2(261.44,99.4) 261.82,99.02 263.79,99.02 265.76,97.05 267.68,97.05 268.78,95.94 271.02,95.94 271.76,95.2 273.97,95.2 274.23,94.94 275.61,94.94 275.91,94.63 279.8,90.74 279.8,89.39 280.04,89.15 280.39,89.15 v2(280.84,89.59)
CFG16: length 47.1
  TOP w0.076: v2(258.19,103.88) 257.86,103.56 UC1.BP23
  TOP w0.109: v2(283.09,80.53) 282.87,80.75 JXDP1.6
  IN4 w0.102: v2(258.19,103.88) 258.32,104.02 262.26,104.02 264.7,101.58 265.21,101.58 265.68,101.11 268.59,101.11 269.59,100.11 275.84,100.11 279.9,96.05 281.1,96.05 281.96,95.19 281.96,93.03 283.05,91.94 283.47,91.94 284.94,90.47 284.94,81.16 284.32,80.53 v2(283.09,80.53)
CFG17: length 53
  TOP w0.076: v2(257.54,103.88) 257.21,103.56 UC1.BN23
  TOP w0.109: v2(282.53,80.15) JXDP1.4
  IN4 w0.102: v2(282.53,80.15) 282.57,80.15 283.69,79.02 284.79,79.02 285.17,79.41 285.17,93.34 283.37,95.14 283.37,96.24 281.68,97.93 278.35,97.93 275.93,100.35 269.68,100.35 268.68,101.34 265.77,101.34 265.48,101.63 265.48,102.56 263.73,104.31 257.97,104.31 v2(257.54,103.88)
  BOTTOM w0.109: v2(257.54,103.88) 257.53,103.88 v1(256.91,104.5)
CFG18: length 33.3
  TOP w0.076: UC1.BN22 257.21,102.63 v2(257.54,102.31)
  TOP w0.109: JXDP1.24 281.3,86.15 v2(280.46,86.98)
  IN4 w0.102: v2(257.54,102.31) 257.54,100.97 260.81,97.7 264.09,97.7 265.44,96.35 267.35,96.35 268.45,95.26 270.64,95.26 271.39,94.52 273.68,94.52 276.81,91.39 277.57,91.39 279.12,89.84 279.12,89.07 279.7,88.48 279.7,87.27 279.99,86.98 v2(280.46,86.98)
CFG19: length 34
  TOP w0.076: UC1.BP22 257.86,102.63 v2(258.19,102.31)
  TOP w0.109: v2(280.15,87.48) 280.02,87.35 280.02,86.46 v1(280.51,85.97) 280.93,85.55 JXDP1.22
  IN4 w0.102: v2(258.19,102.31) 258.19,100.73 260.87,98.05 260.99,97.93 264.23,97.93 265.58,96.58 267.45,96.58 268.55,95.49 270.74,95.49 271.48,94.75 273.78,94.75 274.13,94.4 274.13,94.4 275.5,93.02 276.88,93.02 279.35,90.55 279.35,89.16 280.15,88.36 v2(280.15,87.48)
CHR_USB20_N1: length 3.4
  TOP w0.102: RI60.1 350.91,53.6 LI3.3 350.3,53.44 350.24,53.38 350,53.38 349.68,53.07 349.68,52.59 v4(349.89,52.38) 350.11,52.17 UI1.11
CHR_USB20_N2: length 6.7
  TOP w0.102: UI2.11 349.88,42.05 350.54,42.72 v4(351.22,42.72) 352.52,42.72 352.56,42.76 353.16,42.76 353.2,42.72 353.47,42.72 353.75,42.44 LI4.3 353.91,41.28 RI68.1
CHR_USB20_P1: length 3.4
  TOP w0.102: UI1.10 350.61,51.8 350.53,51.87 350.37,51.87 350.3,51.94 350.3,52.3 349.87,52.73 349.87,52.99 350.08,53.19 350.24,53.19 350.49,52.94 LI3.2 350.91,52.78 RI61.1
CHR_USB20_P2: length 6.7
  TOP w0.102: RI70.1 353.09,41.28 LI4.2 353.25,41.68 353.15,41.78 353.15,41.93 353.25,42.03 353.49,42.03 353.56,42.1 353.56,42.36 353.39,42.53 v4(352.86,42.53) 351.55,42.53 351.51,42.49 350.92,42.49 350.88,42.53 350.62,42.53 350.07,41.98 350.07,41.56 350.12,41.5 350.32,41.5 350.38,41.44 UI2.10
CLK_CNV_PRX_DTX_N: length 209.5
  TOP w0.089: UH1.BD4 v2(175.65,41.69)
  IN4 w0.102: v2(175.65,41.69) 175.55,41.79 174.01,41.79 173.64,41.42 173.64,40.93 174.31,40.26 174.31,36.1 174.72,35.69 174.72,33.51 172.39,31.19 172.39,29.51 174.48,27.42 174.48,24.44 173.23,23.2 173.23,22.17 173.57,21.83 173.57,21.26 175.02,19.8 178.84,19.8 179.35,19.3 179.99,19.3 180.33,18.95 180.33,18.62 181.43,17.52 182.82,17.52 183.92,16.41 187.26,16.41 187.81,15.86 190.97,15.86 191.82,16.71 198.66,16.71 200.03,15.34 208.08,15.34 210.03,13.39 218.24,13.39 219.76,14.92 230.56,14.92 231.06,14.41 237.91,14.41 239.42,12.89 239.42,11.54 241.9,9.06 247.22,9.06 248.25,8.03 248.25,6.15 248.43,5.97 v2(248.71,5.97)
  BOTTOM w0.109: RZ526.1 322.92,6.83 322.92,6.33 322.58,6 321.15,6 320.17,5.02 315.85,5.02 315.04,5.83 314.47,5.83 314.1,5.46 311.61,5.46 310.5,6.56 306.66,6.56 306.04,7.17 290.25,7.17 289.4,6.32 287.19,6.32 284.71,3.85 284.37,3.85 284.36,3.86 283.75,3.86 283.73,3.85 283.1,3.85 282.06,2.81 278.47,2.81 278.07,3.2 277.61,3.2 277.43,3.38 277.43,3.58 277.13,3.89 276.69,3.89 276.39,3.58 276.39,3.38 276.2,3.2 266.55,3.2 265.59,4.16 258.4,4.16 257.05,2.81 250.04,2.81 249.36,3.49 248.48,3.49 247.84,4.12 243.32,4.12 243.08,4.36 243.08,5.85 243.2,5.96 243.92,5.96 244.05,5.83 244.05,5.09 244.35,4.78 245.17,4.78 245.48,5.09 245.48,5.78 245.66,5.96 246.34,5.96 246.53,5.77 246.53,5 246.82,4.72 247.88,4.72 248.2,5.03 248.2,6.1 248.27,6.18 248.5,6.18 v2(248.71,5.97)
CLK_CNV_PRX_DTX_P: length 209.5
  TOP w0.089: v2(175.17,42.4) 174.96,42.53 174.77,42.48 UH1.BE3
  IN4 w0.102: v2(175.17,42.4) 175.17,42.09 175.05,41.98 173.93,41.98 173.45,41.5 173.45,40.85 174.12,40.18 174.12,36.02 174.53,35.61 174.53,33.59 172.21,31.26 172.21,29.43 174.29,27.34 174.29,24.52 173.04,23.27 173.04,22.09 173.38,21.75 173.38,21.18 174.94,19.62 178.76,19.62 179.27,19.11 179.91,19.11 180.14,18.87 180.14,18.54 181.35,17.33 182.74,17.33 183.84,16.22 187.18,16.22 187.73,15.67 191.05,15.67 191.9,16.52 198.58,16.52 199.95,15.15 208,15.15 209.95,13.21 218.31,13.21 219.83,14.73 230.48,14.73 230.99,14.22 237.83,14.22 239.24,12.81 239.24,11.46 241.82,8.87 247.14,8.87 248.06,7.95 248.06,6.27 v2(247.72,5.92)
  BOTTOM w0.109: v2(247.72,5.92) 247.98,5.66 247.98,5.12 247.79,4.93 246.91,4.93 246.75,5.09 246.75,5.86 246.43,6.18 245.57,6.18 245.26,5.87 245.26,5.18 245.08,5 244.44,5 244.26,5.18 244.26,5.92 244.01,6.18 243.11,6.18 242.86,5.94 242.86,4.27 243.23,3.9 247.75,3.9 248.39,3.27 249.27,3.27 249.95,2.59 257.14,2.59 258.49,3.94 265.5,3.94 266.46,2.98 276.29,2.98 276.6,3.29 276.6,3.49 276.78,3.67 277.04,3.67 277.22,3.49 277.22,3.29 277.53,2.98 277.99,2.98 278.38,2.59 282.15,2.59 283.19,3.63 v4(284.08,3.63) 284.8,3.63 287.28,6.11 289.49,6.11 290.34,6.95 305.95,6.95 306.57,6.34 310.42,6.34 311.52,5.24 314.19,5.24 314.56,5.62 314.95,5.62 315.76,4.81 320.26,4.81 321.24,5.78 322.67,5.78 323.13,6.24 323.13,6.8 RZ525.1
CLK_CNV_PTX_DRX_N: length 204.1
  TOP w0.109: UH1.BC5 175.73,41 175.73,40.54 v2(175.7,40.5)
  IN4 w0.102: v2(175.7,40.5) 175.73,40.54 175.88,40.54 176,40.43 176,40.06 175.8,39.86 175.19,39.86 174.72,39.38 174.72,36.27 175.12,35.86 175.12,33.34 172.96,31.18 172.96,29.54 174.9,27.6 174.9,24.25 173.64,22.98 173.64,22.39 174.64,21.39 174.64,21.01 174.93,20.72 175.43,20.72 175.63,20.52 179.7,20.52 181.56,18.66 182.82,18.66 182.99,18.83 183.6,18.83 183.71,18.73 183.71,18.2 183.51,18 183.51,17.49 184.17,16.82 187.43,16.82 187.98,16.26 190.79,16.26 192.83,18.3 197.97,18.3 200.51,15.77 208.41,15.77 210.37,13.8 218.07,13.8 219.61,15.35 230.82,15.35 231.35,14.82 239.85,14.82 241.07,13.6 245.34,13.6 249.52,9.42 249.52,8.06 249.82,7.75 250.13,7.75 v2(250.43,7.45)
  BOTTOM w0.109: v2(250.43,7.45) 250.33,7.55 250.33,7.7 250.43,7.8 250.89,7.8 251.14,8.05 251.14,11.02 255.39,15.27 258.46,15.27 258.8,15.62 258.8,17.15 258.91,17.26 259.44,17.26 259.55,17.15 259.55,15.62 259.89,15.27 260.38,15.27 260.72,15.62 260.72,17.62 260.94,17.84 261.25,17.84 261.47,17.62 261.47,15.62 261.81,15.27 262.3,15.27 262.64,15.62 262.64,17.62 262.86,17.84 263.17,17.84 263.39,17.62 263.39,15.62 263.73,15.27 264.22,15.27 264.56,15.62 264.56,17.62 264.78,17.84 265.09,17.84 265.31,17.62 265.31,15.62 265.65,15.27 266.14,15.27 266.48,15.62 266.48,17.62 266.7,17.84 267.01,17.84 267.23,17.62 267.23,15.62 267.57,15.27 268.58,15.27 269.81,14.04 269.81,12.4 271.01,11.2 274.94,11.2 277.31,13.58 285.9,13.58 285.92,13.56 286.56,13.56 286.57,13.58 286.95,13.58 288.01,14.65 293.27,14.65 293.93,13.99 v4(295.72,13.99) 298.5,13.99 300.06,12.42 309.91,12.42 310.06,12.28 311.08,12.28 311.14,12.34 311.81,12.34 311.92,12.23 311.92,12.06 RZ524.1
CLK_CNV_PTX_DRX_N_R: length 34.2
  BOTTOM w0.109: RZ524.2 311.93,11.02 311.93,10.71 311.7,10.49 311.7,8.78 310.99,8.07 310.99,7.08 v4(311.2,6.86) 311.7,6.37 312.44,6.37 313.09,7.02 314.48,7.02 315.27,6.24 317.09,6.24 318.13,7.28 318.79,7.28 319.66,8.15 319.66,8.81 320.46,9.61 320.46,10.68 321.43,11.65 324.16,11.65 324.59,12.08 332.66,12.08 333.06,11.69 334.09,11.69 334.2,11.58 334.2,11.09 334.48,10.81 334.4,10.73 JNGFF1.63
CLK_CNV_PTX_DRX_P: length 204.1
  TOP w0.109: UH1.BB6 176.19,40.54 v2(176.19,41.05)
  IN4 w0.102: v2(250.46,8.23) 250.16,7.94 249.9,7.94 249.71,8.13 249.71,9.49 245.42,13.78 241.15,13.78 239.93,15.01 231.43,15.01 230.9,15.54 219.54,15.54 217.99,13.99 210.45,13.99 208.49,15.95 200.59,15.95 198.05,18.49 192.75,18.49 190.71,16.45 188.06,16.45 187.5,17.01 184.25,17.01 183.69,17.56 183.69,17.92 183.89,18.12 183.89,18.8 183.68,19.02 182.91,19.02 182.74,18.85 181.64,18.85 179.78,20.71 175.71,20.71 175.51,20.91 175.01,20.91 174.83,21.09 174.83,21.47 173.82,22.47 173.82,22.91 175.09,24.17 175.09,27.68 173.15,29.62 173.15,31.1 175.31,33.26 175.31,35.94 174.9,36.34 174.9,39.31 175.27,39.67 175.88,39.67 176.19,39.98 v2(176.19,41.05)
  BOTTOM w0.109: RZ523.1 312.14,12.06 312.14,12.32 311.9,12.56 311.05,12.56 310.99,12.49 310.15,12.49 310,12.64 300.15,12.64 298.59,14.2 296.1,14.2 296.06,14.24 295.38,14.24 295.34,14.2 294.02,14.2 293.36,14.86 287.92,14.86 286.86,13.8 v4(286.29,13.8) 277.22,13.8 274.85,11.42 271.1,11.42 270.03,12.49 270.03,14.13 268.67,15.49 267.66,15.49 267.44,15.71 267.44,17.71 267.1,18.05 266.61,18.05 266.27,17.71 266.27,15.71 266.05,15.49 265.74,15.49 265.52,15.71 265.52,17.71 265.18,18.05 264.69,18.05 264.35,17.71 264.35,15.71 264.13,15.49 263.82,15.49 263.6,15.71 263.6,17.71 263.26,18.05 262.77,18.05 262.43,17.71 262.43,15.71 262.21,15.49 261.9,15.49 261.68,15.71 261.68,17.71 261.34,18.05 260.85,18.05 260.51,17.71 260.51,15.71 260.29,15.49 259.98,15.49 259.76,15.71 259.76,17.24 259.53,17.48 258.82,17.48 258.59,17.24 258.59,15.71 258.37,15.49 255.3,15.49 250.92,11.11 250.92,8.14 250.8,8.02 250.67,8.02 v2(250.46,8.23)
CLK_CNV_PTX_DRX_P_R: length 34.2
  BOTTOM w0.109: JNGFF1.65 334.9,10.7 334.42,11.18 334.42,11.67 334.18,11.9 333.15,11.9 332.75,12.3 324.5,12.3 324.07,11.87 321.34,11.87 320.24,10.77 320.24,9.69 319.45,8.9 319.45,8.23 318.72,7.51 v4(318.42,7.51) 318.06,7.51 317,6.46 315.36,6.46 314.57,7.24 313,7.24 312.35,6.58 311.79,6.58 311.58,6.79 311.58,6.81 311.2,7.19 311.2,7.98 311.92,8.69 311.92,10.4 312.15,10.62 312.15,11.03 RZ523.2
CLK_PCIE_N1: length 207.7
  TOP w0.094: v2(182.22,39.54) 182.56,39.21 182.63,39.21 UH1.AH9
  IN4 w0.102: v2(21.62,10.51) 21.87,10.25 22.24,10.25 24.48,12.49 26.19,12.49 26.52,12.16 27.03,12.16 27.28,11.92 29.86,11.92 30.68,12.73 33.33,12.73 34.6,11.46 35.13,11.46 36.09,12.42 36.09,13.55 36.89,14.34 36.89,18.77 36.56,19.1 36.56,22.19 37.5,23.13 40.29,23.13 40.93,23.78 40.93,25.08 40.4,25.61 40.4,26.29 41.01,26.9 41.75,26.9 42.87,28.03 45.43,28.03 46.73,26.73 49.75,26.73 51.17,25.31 52.87,25.31 54.21,23.97 57.92,23.97 59.47,25.52 62.42,25.52 64.07,27.17 67.36,27.17 68.52,28.34 72.14,28.34 73.72,26.76 79.52,26.76 80.12,26.16 82.67,26.16 83.65,27.13 86.21,27.13 86.5,27.42 92.6,27.42 93.98,28.79 99.08,28.79 100,27.87 110.51,27.87 111.35,27.03 117.07,27.03 117.45,26.65 119.07,26.65 120.54,28.12 122.52,28.12 123.48,29.08 124.35,29.08 126.06,30.8 127.17,30.8 127.67,31.29 130.37,31.29 130.93,30.72 131.24,30.72 131.97,31.45 132.15,31.45 132.52,31.82 133.34,31.82 133.58,31.58 134.33,31.58 135.68,30.23 137.77,30.23 137.94,30.4 139.16,30.4 139.55,30.02 141.14,30.02 141.61,29.54 142.03,29.54 142.55,29.03 145.51,29.03 145.79,29.3 147.11,29.3 147.39,29.03 149.75,29.03 151.51,30.79 153.03,30.79 155.18,32.94 156.75,32.94 157.37,33.56 157.37,35.13 163.06,40.82 165.56,40.82 166.87,42.14 166.87,43.06 166.29,43.64 166.29,44.67 169.96,48.34 172.06,48.34 172.61,47.78 175.42,47.78 176.65,46.55 176.65,46.13 181.07,41.71 181.07,40 181.71,39.36 182.04,39.36 v2(182.22,39.54)
  BOTTOM w0.102: UR1.8 21.49,11.72 21.7,11.51 21.7,11.13 22.05,10.78 22.05,10.41 21.9,10.26 21.71,10.26 21.62,10.36 v2(21.62,10.51)
CLK_PCIE_N2: length 141.6
  TOP w0.102: UH1.AE14 183.93,36.96 v2(183.71,37.18)
  IN4 w0.102: v2(183.71,37.18) 183.95,36.94 184.26,36.94 184.57,36.63 184.57,35.07 184.68,34.95 187.67,34.95 188.37,34.25 188.37,31.74 189.29,30.82 189.29,28.75 189.76,28.28 191.92,28.28 192.12,28.08 192.6,28.08 192.76,27.92 193.18,27.92 193.44,27.67 196.4,27.67 198.6,25.46 199.32,25.46 201.92,22.85 202.52,22.85 203.75,21.62 204.61,21.62 205.79,20.45 211.04,20.45 213.17,18.32 231.33,18.32 232.5,17.15 245.1,17.15 252.45,9.8 252.45,8.76 255.06,6.15 258.28,6.15 260.32,4.1 273.82,4.1 274.66,3.26 277.94,3.26 278.7,2.51 285.1,2.51 285.43,2.18 292.71,2.18 293.07,2.54 294.26,2.54 294.49,2.31 301.86,2.31 302.66,3.1 302.66,3.63 302.4,3.88 v2(302.27,3.88)
  BOTTOM w0.102: v2(302.27,3.88) 302.5,3.66 JNGFF2.45
CLK_PCIE_N3: length 117.8
  TOP w0.094: v2(184.7,40.4) 184.7,40.44 UH1.AE6
  IN1 w0.102: v2(201.71,115.63) 201.53,115.63 201.23,115.33 200.83,115.33 200.69,115.47 199.38,116.78 199.38,118.35 195.98,121.76 193.55,121.76 191.11,124.2 189.48,124.2 188.82,124.86 188.82,125.36 v2(188.62,125.56)
  IN2 w0.094: v2(184.7,40.4) 184.3,40.8 184.3,41.15 185.42,42.26 192.15,42.26 193.65,43.76 193.65,46.96 193.18,47.43 193.18,49.93 195.09,51.83 197.13,51.83 197.73,52.44 197.73,53.86 198.65,54.78 198.65,57.13 200.24,58.72 200.24,59.2 200.06,59.38 200.06,60.9 201.91,62.75 201.91,64.7 201.33,65.28 201.33,67.49 202.06,68.22 202.06,77.29 200.01,79.35 200.01,81.06 198.16,82.9 198.16,85.82 196.57,87.42 196.57,88.39 193.6,91.36 193.6,93.06 193,93.66 193,97.12 193.39,97.51 193.39,101.74 194.35,102.69 194.35,104.86 195.48,105.99 195.48,108.62 195.96,109.11 195.96,111.5 197.14,112.68 197.54,112.68 199.52,114.67 199.52,115.06 199.97,115.51 201.26,115.51 201.39,115.63 v2(201.71,115.63)
  BOTTOM w0.102: UL1.45 188.75,124.83 188.87,124.95 188.87,125.45 188.76,125.56 v2(188.62,125.56)
CLK_PCIE_N4: length 193.6
  TOP w0.102: v2(32.61,35.04) 32.76,34.89 32.76,34.68 33.74,33.69 35.87,33.69 36.89,32.68 36.89,31.48 37.59,30.78 37.59,29.05 39.11,27.52 39.95,27.52 40.09,27.37 40.74,27.37 40.76,27.39 v2(41.51,27.39) ; v2(185.73,48.04) 185.81,48.13 185.81,48.3 185.71,48.4 185.56,48.4 185.35,48.19 185.35,45.62 185.64,45.33 185.64,44.26 185.56,44.18 185.56,42.85 185.81,42.61 185.81,42.39 185.69,42.28 185.61,42.28 185.48,42.41 UH1.AC2
  IN4 w0.102: v2(185.73,48.04) 185.73,48.12 185.91,48.3 186.04,48.3 186.28,48.06 186.28,47.74 186.03,47.49 185.47,47.49 185.06,47.89 185.06,48.36 182.59,50.84 180.39,50.84 178.85,52.38 174.45,52.38 171.82,49.75 169.48,49.75 164.73,45.01 164.73,43.71 164.54,43.51 164.54,43.03 163.67,42.17 162.48,42.17 152.9,32.59 151.35,32.59 149.7,30.94 145.76,30.94 145.14,31.56 144.41,31.56 143.79,30.94 142.13,30.94 141.2,31.87 137.43,31.87 137.37,31.93 136.1,31.93 135.24,32.79 135.24,33.32 134.7,33.85 132.14,33.85 131.32,33.03 131.02,33.03 130.76,33.29 129.53,33.29 128.87,32.63 127.24,32.63 126.66,33.22 126.04,33.22 123.97,31.15 120.98,31.15 120,30.17 118.21,30.17 117.47,29.42 112.19,29.42 111.64,29.97 106.69,29.97 106.26,29.55 100.72,29.55 100.11,30.17 93.27,30.17 92.77,29.67 87.43,29.67 86.76,29 83.41,29 82.86,28.44 81.18,28.44 80.46,29.16 76.23,29.16 75.47,28.4 73.32,28.4 72.64,29.08 68.25,29.08 67.13,27.96 63.35,27.96 61.63,26.24 59.24,26.24 57.98,24.98 54.14,24.98 53.15,25.98 51.45,25.98 49.91,27.51 49.12,27.51 48.86,27.77 46.66,27.77 45.99,28.44 45.99,29.15 45.46,29.67 44.84,29.67 44.05,28.88 42.14,28.88 41.87,28.61 41.09,28.61 40.8,28.32 40.8,27.77 40.93,27.63 41.27,27.63 v2(41.51,27.39)
  BOTTOM w0.102: UT1.T19 v2(32.61,35.04)
