# Allegro board LAH271PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GPU_EDP_AUXP_C: length 2.6
  BOTTOM w0.109: CV827.2 104.8,40.57 105.37,40.57 v4(105.58,40.36) 105.84,40.1 106.22,40.1 106.29,40.17 UV64.30
GPU_EDP_HPD: length 105.3
  TOP w0.109: JDGFF1.E1 177.54,83.06 178.65,81.95 178.65,75.23 179.25,74.63 179.25,72.75 160.82,54.33 v1(160.82,53.57) 160.82,52.81 v2(161.19,52.45)
  IN2 w0.081: v2(137.79,39.9) 137.4,39.9 135.22,42.08 129.38,42.08 126.03,38.73 122.49,38.73 120.02,36.26 117.74,36.26 116.2,34.72 110.4,34.72 v2(110.13,34.99)
  BOTTOM w0.109: UV64.13 110.26,35.12 v2(110.13,34.99) ; v2(161.19,52.45) 161.51,52.13 161.51,51.58 161.06,51.14 160.23,51.14 159.6,51.77 158.02,51.77 155.18,48.93 151.99,48.93 151.67,48.61 141.92,48.61 139.5,46.19 139.5,41.1 138.29,39.9 v2(137.79,39.9)
GPU_EDP_N0: length 126.3
  TOP w0.109: JDGFF1.G9 172.27,79.94 172.44,80.11 172.44,80.37 v2(172.3,80.51)
  IN1 w0.102: v2(101.8,31.43) 102.25,30.98 103.01,30.98 103.79,31.76 103.79,35.12 104.97,36.3 104.97,38.36 105.84,39.23 105.84,39.61 107.42,41.19 107.42,42.51 108.15,43.24 113.47,43.24 116.09,40.62 117.24,40.62 119.28,42.66 123.05,42.66 124.36,43.97 125.14,43.97 127.74,46.57 128.12,46.57 129.2,47.65 133.43,47.65 133.79,48.01 134.74,48.01 135.26,47.49 136.65,47.49 137.03,47.88 137.03,48.1 137.48,48.55 138.88,48.55 139.42,48.01 153.37,48.01 154.03,48.67 155.47,48.67 179.17,72.37 179.17,74.3 177.79,75.68 177.04,75.68 173.76,78.96 173.21,78.96 172.66,79.5 172.66,80.14 v2(172.3,80.51)
  BOTTOM w0.109: CV820.1 109.92,32.32 110.02,32.22 110.02,30.67 108.95,29.6 103.52,29.6 102.62,30.5 102.62,30.77 102.36,31.03 102.2,31.03 v2(101.8,31.43)
GPU_EDP_N0_C: length 3.5
  BOTTOM w0.109: CV820.2 109.9,33.21 109.9,33.65 110.8,34.55 110.8,35.28 110.66,35.42 UV64.12
GPU_EDP_N1: length 115.4
  TOP w0.109: JDGFF1.B3 175.87,88.5 176.04,88.33 176.04,88.14 v2(175.85,87.96)
  IN1 w0.102: v2(107.82,30.56) 108.02,30.76 108.02,31.76 109.03,32.77 110.3,32.77 113.44,35.91 113.44,37.25 114.06,37.88 115.08,37.88 115.43,38.23 117.38,38.23 120.32,41.16 123.61,41.16 124.79,42.35 125.56,42.35 128.33,45.11 135.94,45.11 136.73,45.91 139.64,45.91 140.05,46.32 142.62,46.32 143.17,45.76 150.97,45.76 151.84,44.89 152.45,44.89 153.87,46.31 156.85,46.31 160.77,50.24 160.77,50.7 164.05,53.98 164.05,54.56 175.98,66.49 177.25,66.49 180.59,69.82 180.59,70.77 181.46,71.65 181.46,75 181.04,75.42 181.04,77.56 179.4,79.21 179.4,84.64 176.8,87.23 176.38,87.23 176.03,87.58 176.03,87.79 v2(175.85,87.96)
  BOTTOM w0.109: CV822.1 108.04,31.3 108.04,30.78 v2(107.82,30.56)
GPU_EDP_N1_C: length 4.4
  BOTTOM w0.109: CV822.2 108.07,32.47 108.07,33.08 v4(108.41,33.43) 109.34,34.35 109.34,35.27 109.46,35.39 UV64.15
GPU_EDP_N2: length 126.3
  TOP w0.109: v2(172.91,87.17) 173.04,87.04 173.04,86.7 172.87,86.53 JDGFF1.C8
  IN1 w0.102: v2(101.62,33.42) 101.62,33.31 101.8,33.13 102.06,33.13 102.11,33.18 102.11,34.58 103.94,36.41 103.94,38.98 106.58,41.62 106.58,42.72 107.86,44.01 116.29,44.01 116.89,43.41 122.77,43.41 124.06,44.69 124.84,44.69 125.91,45.77 125.91,47.68 126.61,48.38 132.89,48.38 133.36,48.85 136.75,48.85 137.18,49.28 139.19,49.28 139.7,48.77 153.04,48.77 153.72,49.45 155.22,49.45 177.12,71.35 177.12,73.61 173.85,76.88 171.7,76.88 171.06,77.53 171.06,81.67 171.95,82.55 171.95,85.18 173.28,86.51 173.28,86.8 v2(172.91,87.17)
  BOTTOM w0.109: v2(101.62,33.42) 103.41,31.64 103.41,30.82 103.83,30.4 105.6,30.4 106.38,31.18 106.38,32.12 106.3,32.19 CV824.1
GPU_EDP_N2_C: length 4.6
  BOTTOM w0.109: CV824.2 106.25,33.09 106.25,33.7 106.65,34.1 107.31,34.1 108.66,35.44 UV64.17
GPU_EDP_N3: length 117.8
  TOP w0.109: JDGFF1.C5 174.67,86.61 174.84,86.78 174.84,87.04 v2(174.71,87.17)
  IN1 w0.102: v2(174.71,87.17) 174.89,86.98 174.89,86.48 175.08,86.29 176.71,86.29 178.67,84.33 178.67,78.86 179.75,77.78 179.75,75.56 180.68,74.63 180.68,72.86 155.64,47.81 154.3,47.81 153.72,47.23 139.94,47.23 139.45,46.74 133.8,46.74 133.61,46.93 129.51,46.93 128.41,45.84 128.03,45.84 125.26,43.07 124.49,43.07 123.31,41.9 119.95,41.9 117.95,39.89 115.56,39.89 114.97,40.48 107.8,40.48 106.94,39.61 106.94,33.88 104.41,31.36 104.41,31.05 v2(104.19,30.83)
  BOTTOM w0.109: CV826.1 104.39,31.4 104.39,31.03 v2(104.19,30.83)
GPU_EDP_N3_C: length 5.4
  BOTTOM w0.109: UV64.20 107.46,35.36 107.07,34.97 106.37,34.97 v4(104.85,33.45) 104.37,32.97 104.37,32.57 CV826.2
GPU_EDP_P0: length 126.3
  TOP w0.109: JDGFF1.G8 172.87,79.96 172.7,80.13 172.7,80.33 v2(172.88,80.51)
  IN1 w0.102: v2(172.88,80.51) 172.88,79.59 173.29,79.17 173.85,79.17 177.13,75.9 177.88,75.9 179.38,74.39 179.38,72.28 155.56,48.45 154.12,48.45 153.46,47.79 139.33,47.79 138.79,48.34 137.57,48.34 137.25,48.01 137.25,47.79 136.74,47.27 135.17,47.27 134.65,47.79 133.88,47.79 133.52,47.44 129.29,47.44 128.21,46.35 127.83,46.35 125.23,43.75 124.45,43.75 123.14,42.44 119.37,42.44 117.33,40.4 116,40.4 113.38,43.02 108.24,43.02 107.64,42.42 107.64,41.1 106.05,39.52 106.05,39.14 105.19,38.27 105.19,36.21 104.01,35.03 104.01,31.67 103.1,30.76 v2(101.8,30.76)
  BOTTOM w0.109: CV819.1 110.28,32.13 110.28,30.56 109.06,29.34 103.41,29.34 102.35,30.4 102.35,30.66 102.25,30.76 v2(101.8,30.76)
GPU_EDP_P0_C: length 3.5
  BOTTOM w0.109: CV819.2 110.16,33.21 110.16,33.54 v4(110.84,34.22) 111.06,34.44 UV64.11
GPU_EDP_P1: length 115.4
  TOP w0.109: JDGFF1.B2 176.47,88.51 176.3,88.34 176.3,88.1 v2(176.44,87.96)
  IN1 w0.102: v2(108.43,30.56) 108.24,30.76 108.24,31.67 109.12,32.56 110.39,32.56 113.65,35.82 113.65,37.16 114.15,37.66 115.17,37.66 115.52,38.01 117.47,38.01 120.41,40.95 123.7,40.95 124.88,42.13 125.65,42.13 128.42,44.9 136.03,44.9 136.82,45.69 139.73,45.69 140.14,46.1 142.53,46.1 143.09,45.55 150.88,45.55 151.75,44.68 152.54,44.68 153.96,46.1 156.94,46.1 160.99,50.15 160.99,50.61 164.26,53.89 164.26,54.47 176.06,66.27 177.34,66.27 180.8,69.73 180.8,70.68 181.68,71.56 181.68,75.09 181.26,75.51 181.26,77.65 179.61,79.3 179.61,84.73 176.89,87.45 176.47,87.45 176.24,87.67 176.24,87.76 v2(176.44,87.96)
  BOTTOM w0.109: CV821.1 108.3,31.23 108.3,30.69 v2(108.43,30.56)
GPU_EDP_P1_C: length 4.5
  BOTTOM w0.109: UV64.14 109.86,35.42 109.6,35.16 v4(109.6,34.64) 109.6,34.24 108.33,32.97 108.33,32.49 CV821.2
GPU_EDP_P2: length 126.4
  TOP w0.109: v2(173.49,87.17) 173.3,86.98 173.3,86.68 173.47,86.51 JDGFF1.C7
  IN1 w0.102: v2(173.49,87.17) 173.49,86.42 172.16,85.09 172.16,82.46 171.27,81.58 171.27,77.61 171.79,77.1 173.94,77.1 177.33,73.7 177.33,71.26 155.31,49.23 153.81,49.23 153.13,48.56 139.61,48.56 139.1,49.06 137.27,49.06 136.84,48.63 133.45,48.63 132.98,48.16 126.7,48.16 126.12,47.59 126.12,45.68 124.93,44.48 124.15,44.48 122.86,43.19 116.8,43.19 116.2,43.79 107.95,43.79 106.8,42.63 106.8,41.53 104.15,38.89 104.15,36.32 102.32,34.49 102.32,33.09 102.15,32.91 101.78,32.91 v2(101.62,32.76)
  BOTTOM w0.109: v2(101.62,32.76) 101.91,32.76 103.15,31.53 103.15,30.71 103.72,30.14 105.71,30.14 v4(106.13,30.56) 106.64,31.07 106.64,32 CV823.1
GPU_EDP_P2_C: length 4.7
  BOTTOM w0.109: CV823.2 106.52,33.09 106.52,33.59 106.76,33.84 107.42,33.84 v4(108.3,34.71) 109.06,35.47 UV64.16
GPU_EDP_P3: length 117.9
  TOP w0.109: JDGFF1.C4 175.27,86.62 175.1,86.79 175.1,86.98 v2(175.29,87.17)
  IN1 w0.102: v2(104.85,30.83) 104.63,31.05 104.63,31.27 107.15,33.79 107.15,39.52 107.89,40.26 114.88,40.26 115.47,39.67 118.03,39.67 120.04,41.68 123.4,41.68 124.58,42.86 125.35,42.86 128.12,45.62 128.5,45.62 129.6,46.71 133.52,46.71 133.71,46.52 139.54,46.52 140.03,47.02 153.81,47.02 154.39,47.6 155.73,47.6 180.9,72.77 180.9,74.72 179.97,75.65 179.97,77.87 178.89,78.95 178.89,84.42 176.8,86.51 175.17,86.51 175.11,86.57 175.11,86.98 v2(175.29,87.17)
  BOTTOM w0.109: CV825.1 104.65,31.4 104.65,31.03 v2(104.85,30.83)
GPU_EDP_P3_C: length 5.5
  BOTTOM w0.109: UV64.19 107.86,35.39 107.18,34.71 v4(106.83,34.71) 106.48,34.71 104.63,32.86 104.63,32.62 CV825.2
GPU_EVENT#: length 88.4
  TOP w0.109: UH1.BE9 174.54,38.96 173.36,38.96 v2(173.09,38.69) ; v2(188.76,93.99) 188.49,94.26 188.49,95.38 188.64,95.53 188.64,99.05 187.1,100.59 DV44.1
  IN3 w0.081: v2(173.09,38.69) 173.09,41.88 172.36,42.61 172.36,43.59 170.66,45.29 170.66,48.14 171.98,49.46 174.54,49.46 v2(175.03,49.95)
  BOTTOM w0.109: v2(175.03,49.95) 175.03,50.2 177.42,52.59 177.42,53.27 178.01,53.85 178.01,60.61 v1(179.87,62.47) 180.9,63.5 182.91,63.5 186.15,66.75 186.15,70.66 188.12,72.63 188.12,77.43 194.98,84.3 197.13,84.3 197.77,84.94 197.77,86.95 196.94,87.79 195.23,87.79 194.21,88.8 192.38,88.8 191.79,89.39 191.79,93.13 191.29,93.64 189.11,93.64 v2(188.76,93.99)
GPU_GC6_FB_EN: length 94.4
  TOP w0.102: UH1.BF9 172.43,39.18
  TOP w0.109: v2(188.76,93.33) 188.25,93.84 188.25,95.47 188.4,95.62 188.4,98.94 188.03,99.32 RV485.2 ; 172.43,39.18 v2(172.28,39.33)
  BOTTOM w0.109: v2(188.76,93.33) 188.84,93.4 191.11,93.4 191.56,92.95 191.56,89.29 192.28,88.57 193.24,88.57 194.87,86.94 196.69,86.94 197,86.62 197,85.22 196.83,85.05 194.43,85.05 187.35,77.98 187.35,75.03 185.38,73.06 185.38,67.06 182.86,64.53 v1(181.52,64.53) 179.51,64.53 176.84,61.86 176.84,54.3 173.25,50.71 173.25,49.58 172.98,49.31 171,49.31 166.04,44.36 166.04,41.39 166.69,40.75 169.75,40.75 170.42,40.07 170.42,39.72 170.69,39.45 172.17,39.45 v2(172.28,39.33)
GPU_GC6_FB_EN_R: length 15.1
  TOP w0.109: v2(170.98,97.78) 171.04,97.84 JDGFF2.F10 ; v2(180.13,98.81) 180.65,98.81 181.61,99.78 v1(182.91,99.78) 183.87,99.78 RV485.1
  IN4 w0.102: v2(180.13,98.81) 177.38,98.81 176.35,97.78 170.99,97.78 v2(170.98,97.78)
GPU_PWR_LEVEL: length 223.4
  TOP w0.109: v2(98.47,31.42) 98.08,31.81 98.08,34.29 98.4,34.61 v2(98.73,34.61) ; RE557.1 115.83,13.25 115.59,13.5 115.59,14.31 115.27,14.63 115.27,15.2 v1(114.97,15.49) 114.57,15.9 114.57,17.34 v2(115.14,17.92) 114.66,18.4 114.66,18.77 113.69,19.74 110.5,19.74 110,20.25 107.04,20.25 106.2,21.09 106.2,21.96 105.77,22.39 105.77,24.32 103.86,26.23 102.09,26.23 v2(101.57,26.75) ; v2(141.17,27.99) 141.43,27.73 141.43,26.76 140.91,26.24 140.18,26.24 140.06,26.36 139.4,26.36 139.09,26.05 UE1.E12 ; UV60.2 184.06,97.45 183.69,97.82 183.69,98.84 183.19,99.34 181.61,99.34 180.67,98.4 180.67,96.97 180.33,96.62 v2(179.49,96.62)
  IN1 w0.102: v2(134.88,50.07) 134.36,50.59 133.11,50.59 132.58,50.06 126.17,50.06 124.26,48.15 124.26,46.79 122.28,44.81 117.44,44.81 114.25,48 114.25,48.85 112.7,50.39 101.33,50.39 99.16,48.23 99.16,46.88 101.7,44.34 101.7,39.07 101.32,38.69 101.32,38.39 101.1,38.17 100.95,38.17 98.73,35.95 v2(98.73,34.61)
  IN2 w0.081: v2(98.47,31.42) 98.47,29.93 100.24,28.17 100.24,27.42 100.71,26.94 101.38,26.94 v2(101.57,26.75)
  IN3 w0.081: v2(179.49,96.62) 180.33,95.78 180.33,94.23 180.98,93.58 180.98,91.7 181.39,91.28 181.39,89.02 181.96,88.46 181.96,83.95 176.31,78.31 176.31,76.38 176.9,75.79 176.9,70.64 158.86,52.6 157.67,52.6 155.48,50.4 154.92,50.4 153.72,49.2 140.18,49.2 139.56,49.83 138.09,49.83 137.85,50.06 136.89,50.06 136.48,50.47 135.28,50.47 v2(134.88,50.07)
  IN4 w0.102: v2(119.96,20.12) 119.28,20.8 119.28,24.08 119.47,24.27 121.88,24.27 122.46,24.86 124.06,24.86 126.44,27.24 129.4,27.24 130.31,28.14 130.31,28.97 130.78,29.44 133.78,29.44 133.99,29.24 136.85,29.24 137.37,28.72 139.56,28.72 140.3,27.99 v2(141.17,27.99)
  BOTTOM w0.109: v2(119.96,20.12) 118.84,20.12 117.39,18.67 116.76,18.67 116.42,18.33 115.56,18.33 v2(115.14,17.92)
GPU_SMBCLK_R: length 13
  TOP w0.109: RV804.2 188.45,104.28 QV30.4 186.65,104.28 186.16,103.79 185.01,103.79 182.68,101.46 v1(181.31,101.46) 178.08,101.46 178.01,101.53 177.6,101.53 JDGFF2.C1
GPU_SMBDAT_R: length 11.6
  TOP w0.109: JDGFF2.C2 176.47,102.4 176.72,102.65 177.3,102.65 177.77,102.18 178.27,102.18 178.5,101.95 179.78,101.95 v1(182.42,104.6) 183.57,105.74 RV805.2 184.67,105.58 QV30.1
GPU_SMCLK: length 120.3
  TOP w0.102: v2(135.13,27.28) 135.09,27.24 135.09,27.21 135.06,27.18 135.06,26.48 135.16,26.39 135.16,25.94 134.73,25.52 UE1.F7
  TOP w0.109: v2(182.68,102.52) 184.44,104.28 QV30.3
  IN3 w0.081: v2(182.68,102.52) 183.33,103.17 185.47,103.17 186.1,102.54 186.1,97.76 185.54,97.2 185.54,94.78 186.28,94.03 186.28,89.08 185.54,88.33 185.54,85.56 184.7,84.73 184.7,83.42 183.8,82.52 181.59,82.52 178.81,79.74 178.81,77.56 178.19,76.94 178.19,75.51 179.14,74.55 179.14,71.91 158.87,51.63 158.87,51.07 v2(159.33,50.6)
  BOTTOM w0.109: v2(135.13,27.28) 134.74,27.67 134.74,28.48 134.52,28.7 134.52,29.79 134.69,29.96 135.34,29.96 135.49,30.11 135.49,31.97 135.84,32.31 135.84,33.32 136.11,33.59 137.01,33.59 137.65,34.23 137.65,35.58 137.57,35.67 137.57,36.1 RE730.1 137.57,37.11 137.57,38 139.97,40.4 139.97,46 142.11,48.14 151.87,48.14 152.19,48.46 155.44,48.46 157.94,50.96 158.98,50.96 v2(159.33,50.6)
GPU_SMDAT: length 124.2
  TOP w0.109: QV30.6 186.88,105.58 186.18,106.28 182.3,106.28 v1(182.01,105.98) 181.14,105.98 v2(181.07,106.06) ; v2(133.5,28.84) 133.89,28.45 UE1.B6
  IN3 w0.081: v2(159.75,51.02) 159.37,51.4 159.37,51.81 179.37,71.81 179.37,74.65 178.42,75.61 178.42,76.84 179.04,77.47 179.04,79.65 181.68,82.29 183.89,82.29 184.93,83.33 184.93,84.63 185.76,85.47 185.76,88.24 186.51,88.99 186.51,94.13 185.77,94.87 185.77,97.11 186.32,97.67 186.32,102.63 185.54,103.42 181.47,103.42 181.07,103.83 v2(181.07,106.06)
  BOTTOM w0.109: v2(159.75,51.02) 159.41,51.36 158,51.36 155.34,48.69 152.09,48.69 151.77,48.37 142.01,48.37 139.73,46.09 139.73,40.5 137.33,38.1 137.33,37.07 RE731.1 137.33,36.14 137.33,35.57 137.42,35.48 137.42,34.33 136.91,33.83 136.01,33.83 135.6,33.42 135.6,32.55 134.46,31.41 134.16,31.41 133.78,31.03 133.78,29.83 133.5,29.55 v2(133.5,28.84)
GT_SW1: length 0.9
  TOP w0.109: v2(264.12,130.87) v3(263.26,130.87)
H_CATERR#: length 10.2
  TOP w0.076: UC1.BM30 256.86,108.71 259.45,108.71 259.56,108.81
  TOP w0.109: 259.56,108.81 259.69,108.94 260.69,108.94 260.76,109.01 262.69,109.01 v1(262.9,108.8) 263.06,108.8 264.88,106.98 264.88,106.79 264.91,106.76 264.91,106.56 RC79.2
H_PECI: length 295.5
  TOP w0.109: UC1.BT34 259.61,111.28 259.74,111.41 262.49,111.41 v2(262.93,111.85) ; v2(185.18,107.4) v1(186.11,107.4) 187.03,107.4 189.31,105.12 v2(189.31,104.43) ; RH73.2 182.32,54.32 v2(182.32,54.55) ; RE60.2 145.14,23.79 144.54,23.79 v2(144.2,24.13)
  IN2 w0.081: v2(189.31,104.43) 188.48,103.59 188.48,97.24 190.48,95.24 190.48,93.19 189.26,91.97 189.26,91.04 190.26,90.03 190.26,88.89 190.62,88.54 190.62,78.06 191.23,77.45 191.23,75.1 193.51,72.82 193.51,65.67 194.24,64.94 194.24,62.09 191.48,59.33 190.1,59.33 189.72,58.95 187.73,58.95 187.21,58.43 186.9,58.43 184.18,55.71 183.21,55.71 182.32,54.82 v2(182.32,54.55) 182.32,54.04 178.37,50.09 178.37,47.36 176.77,45.76 176.77,43.41 175.09,41.72 175.09,41.47 173.77,40.15 173.77,38.59 173.15,37.98 170.57,37.98 169.91,37.32 169.6,37.32 168.91,36.63 168.62,36.63 167.8,35.82 167.8,35.2 167.1,34.5 164.14,34.5 162.92,33.27 162.92,32.71 162.71,32.5 161.97,32.5 161.36,33.11 160.44,33.11 160.21,32.88 159.74,32.88 156,29.14 149.77,29.14 144.76,24.13 v2(144.2,24.13) ; v2(262.93,111.85) 262.93,111.86 268.18,111.86 268.81,111.23 272.24,111.23 274.97,113.96 274.97,141.63 265.69,150.91 260.36,150.91 260,151.26 241.63,151.26 239.95,149.58 230.19,149.58 228.83,148.22 228.83,145.55 225.65,142.37 223.55,142.37 215.64,134.46 207.57,134.46 206.32,133.21 194.23,133.21 192.75,131.73 192.75,126.27 189.5,123.02 189.01,123.02 188.68,122.69 188.5,122.69 187.26,121.46 187.26,121.1 185.2,119.04 185.2,114.6 185.47,114.32 185.47,110.97 184.75,110.24 184.75,107.83 v2(185.18,107.4)
H_PM_DOWN: length 247.9
  TOP w0.089: 184.48,48.87 184.48,48.39 184.72,48.14 184.72,47.7 184.46,47.44 184.46,42.64 184.42,42.6 UH1.AE2
  TOP w0.109: 184.48,48.87 184.48,50.25 184.69,50.46 184.69,53.27 184.34,53.62 184.34,57.28 184.97,57.91 184.97,58.39 186.2,59.62 186.2,60.93 193.16,67.89 v1(193.16,69.97) 193.16,74.1 195.7,76.63 v2(195.7,78.13) ; RC168.1 266.44,109.78 v2(266.88,109.78)
  IN2 w0.081: v2(266.88,109.78) 267.86,110.76 272.46,110.76 275.38,113.68 275.38,141.8 271.42,145.76 271.41,145.76 265.86,151.31 260.52,151.31 260.17,151.67 241.39,151.67 239.71,149.98 230.02,149.98 228.43,148.39 228.43,145.71 225.5,142.79 223.4,142.79 215.48,134.86 207.4,134.86 206.15,133.62 194.06,133.62 192.35,131.9 192.35,126.5 189.98,124.13 189.3,124.13 188.85,123.69 188.85,123.41 188.52,123.08 188.34,123.08 186.88,121.62 185.9,121.62 185.56,121.28 185.56,120.2 184.36,119 184.36,111.81 v2(185.04,111.13)
  IN4 w0.102: v2(195.7,78.13) 195.7,79.3 197.81,81.42 197.81,87.66 197.56,87.91 197.56,88.89 198.05,89.38 198.05,91.37 196.01,93.41 196.01,94.06 195.32,94.76 191.6,94.76 189.91,96.45 189.59,96.45 188.85,97.18 188.85,99.56 192.23,102.94 192.23,104.01 189.86,106.38 187.91,106.38 185.9,108.39 185.9,110.27 v2(185.04,111.13)
H_PM_DOWN_R: length 8.4
  TOP w0.076: UC1.BP31 258.2,110.13 258.67,110.13 258.76,110.04 260.03,110.04 260.63,110.64 260.92,110.64
  TOP w0.109: RC168.2 264.97,109.58 v1(264.4,110.15) 263.84,110.71 260.99,110.71 260.92,110.64
H_PM_SYNC: length 242.8
  TOP w0.076: v2(256.89,111.75) 256.56,111.43 UC1.BM34
  TOP w0.102: 192.68,74.2 192.68,68.08 186.15,61.55
  TOP w0.109: RH156.2 183.93,52.91 183.93,57.46 184.55,58.08 184.55,58.56 185.78,59.79 185.78,61.19 186.15,61.55 ; 192.68,74.2 195.23,76.75 v2(195.23,77.72)
  IN2 w0.081: v2(185.18,108.54) 185.18,110.01 185.91,110.75 185.91,114.52 185.62,114.82 185.62,118.88 187.71,120.97 187.71,121.35 188.66,122.31 188.84,122.31 189.17,122.63 189.66,122.63 193.16,126.13 193.16,131.56 194.4,132.8 206.49,132.8 207.74,134.05 215.81,134.05 223.72,141.96 225.82,141.96 229.24,145.38 229.24,148.05 230.36,149.17 240.12,149.17 241.8,150.85 259.83,150.85 260.19,150.5 265.52,150.5 274.56,141.46 274.56,114.35 271.89,111.68 268.93,111.68 268.35,112.26 257.27,112.26 256.89,111.88 v2(256.89,111.75)
  IN4 w0.102: v2(195.23,77.72) 195.23,79.41 197.41,81.59 197.41,87.49 197.16,87.74 197.16,89.16 197.64,89.65 197.64,91.2 195.61,93.24 195.61,93.89 195.15,94.35 191.43,94.35 189.74,96.04 189.32,96.04 188.45,96.92 188.45,99.76 191.79,103.11 191.79,103.88 189.7,105.98 187.74,105.98 v2(185.18,108.54)
  BOTTOM w0.109: v2(195.23,77.72) v3(195.23,77.03)
H_PM_SYNC_R: length 9.9
  TOP w0.089: UH1.AF3 184.01,42.33 184.01,42.72 184.08,42.8 184.08,47.37 183.98,47.47 183.98,48.17 184.06,48.25 184.06,48.81
  TOP w0.109: 184.06,48.81 184.06,50.64 v1(184.09,50.67) 184.2,50.78 RH156.1
H_PROCHOT#_R: length 8
  TOP w0.076: UC1.BR30 258.79,109.28 259.4,109.28 259.49,109.18 259.62,109.18
  TOP w0.102: 259.62,109.18 260.55,109.18 260.77,109.4 v1(261.13,109.4) 261.63,109.4
  TOP w0.109: RC84.2 265.05,107.43 264.82,107.43 262.85,109.4 261.63,109.4
H_PWRGD: length 191.8
  TOP w0.089: v2(184.34,47.97) 184.26,47.88 184.26,42.72 184.24,42.71 184.24,42.69 184.2,42.65 184.2,42.36 184.26,42.3 UH1.AE3
  TOP w0.102: UC1.BT31 259.19,109.79 260.27,109.79 260.82,110.34
  TOP w0.109: 260.82,110.34 263.67,110.34 CC300.1 265.64,108.36 v2(265.64,108.04)
  IN4 w0.102: v2(265.64,108.04) 265.64,108.01 265.01,107.38 265.01,104.36 267.16,102.21 269.86,102.21 271.08,100.98 275.86,100.98 277.36,102.48 279.44,102.48 v2(282.42,99.51)
  BOTTOM w0.109: v2(184.34,47.97) 184.34,49.66 186.68,52 v3(186.68,53.59) 186.68,55.09 190.71,59.12 191.84,59.12 194.04,61.32 194.04,64.78 193.34,65.49 193.34,68.19 194.04,68.9 194.04,73.87 198.39,78.21 203.05,78.21 208.5,72.77 251.62,72.77 252.25,72.13 275.52,72.13 278.05,74.67 284.06,74.67 285.49,76.1 285.49,94.56 284.23,95.83 284.23,97.7 v2(282.42,99.51)
H_SKTOCC#: length 8.3
  TOP w0.076: UC1.BR33 258.61,110.57 258.97,110.21 259.89,110.21 260.09,110.42
  TOP w0.109: RC319.2 265.32,111.09 264.87,111.54 v1(263.93,111.54) 263.13,111.54 262.68,111.08 260.76,111.08 260.53,110.85 260.09,110.42
H_THERMTRIP#: length 205.7
  TOP w0.102: v2(184.84,55.33) 184.85,55.32 184.85,53.74 185.1,53.48 185.1,50.3 184.95,50.14 RH75.2
  TOP w0.109: v2(159.54,30.49) 159.54,30.04 159.03,29.53 QE4.3 ; v2(240.25,67.47) 236.39,71.33 212.95,71.33 202.63,81.65 198.82,81.65 197.05,79.88 197.05,77.4 194.82,75.17 v3(194.82,71.91) 194.82,67.59 v2(194.63,67.39) ; v2(197.25,102.68) 196.8,102.24 196.27,102.24 194.06,104.45 189.95,104.45 v2(189.34,103.84)
  IN2 w0.081: v2(189.34,103.84) 188.7,103.2 188.7,97.34 190.71,95.33 190.71,93.1 189.49,91.88 189.49,91.14 190.49,90.14 190.49,88.99 190.89,88.59 190.89,78.14 194.63,74.4 v2(194.63,67.39) 194.75,67.28 194.75,61.7 191.87,58.83 190.27,58.83 189.93,58.49 187.92,58.49 187.4,57.97 187.09,57.97 184.84,55.71 v2(184.84,55.33) 184.84,54.14 184.67,53.97 184.67,51.08 183.63,50.03 182.44,50.03 181.76,49.34 181.02,49.34 180.39,48.72 180.39,48.21 178.05,45.86 178.05,45.47 177.15,44.57 177.15,42.59 176.62,42.06 176.62,40.62 176.07,40.08 174.82,40.08 173.99,39.25 173.99,38.5 173.25,37.75 170.75,37.75 170.21,37.21 170.21,36.52 169.97,36.28 168.59,36.28 168.03,35.72 168.03,35.11 167.22,34.29 164.35,34.29 163.16,33.11 163.16,31.17 162.48,30.49 v2(159.54,30.49) ; v2(200.23,114.9) 201.02,114.9 201.83,114.09 201.83,113.33 199.3,110.8 199.3,108.07 197.25,106.01 v2(197.25,102.68)
  BOTTOM w0.102: RD21.2 RD45.2 RD7.2
  BOTTOM w0.109: v2(200.23,114.9) 199.89,114.9 RC80.2 198.91,115.88 CC323.1 RC169.1 ; RD29.2 242.19,65.54 RD7.2 ; RD21.2 240.67,65.86 240.17,66.35 240.17,67.39 v2(240.25,67.47)
H_THERMTRIP#_R: length 36.5
  TOP w0.076: v2(223.12,110.03) 223.12,109.99 223.45,109.66 UC1.J31
  BOTTOM w0.102: v2(223.12,110.03) 223.08,110.03 222.68,110.44 222.68,111.26 222.34,111.59 222.16,111.59 ; 221.93,113.42 221.16,114.19 214.68,114.19 212.38,116.48
  BOTTOM w0.109: 222.16,111.59 221.93,111.82 221.93,113.42 ; RC169.2 v1(199.82,120.1) 199.82,120.65 202.79,123.61 207.53,123.61 209.32,121.83 209.32,121.31 209.81,120.81 209.81,119.05 212.38,116.48
H_VCCST_PWRGD_XDP: length 7.6
  TOP w0.109: JXDP1.39 283.99,90.65 283.94,90.7 v2(283.39,90.7)
  BOTTOM w0.109: v2(283.39,90.7) 282.96,90.7 v1(282.54,90.28) 281.4,89.14 281.4,88.39 281,87.99 279.66,87.99 CC307.1 279.5,87.83 279.5,86.97 RC124.2
HDA_BIT_CLK: length 9.1
  TOP w0.102: UH1.BD11 175.22,37.93 174.7,37.93 174.68,37.95 173.46,37.95 173.29,37.78 173.01,37.78
  TOP w0.109: RH46.2 168.42,41.05 168.89,40.58 169.38,40.58 v1(169.61,40.35) 170.59,39.37 RH637.2 170.59,38.61 170.91,38.28 171.8,38.28 172.3,37.78 173.01,37.78
HDA_BIT_CLK_R: length 233.5
  TOP w0.109: UA1.14 343.56,19.67 343.41,19.51 342.88,19.51 342.71,19.68 341.39,19.68 RA17.1 341.05,20.24 340.86,20.44 339.8,20.44 339.69,20.32 339.69,19.85 v1(338.53,18.7) 338.17,18.33 337.12,18.33 v2(336.57,18.88) ; v2(165.13,41.68) 166.1,41.68 166.44,41.34 CH268.2 166.83,41.09 166.87,41.05 RH46.1
  IN2 w0.081: v2(337.38,22.45) 336.78,22.45 336.41,22.81 335.13,22.81 333.42,24.53 331.96,24.53 331.52,24.09 331.52,23.23 331.2,22.9 330.7,22.9 330.02,22.22 330.02,21.33 328.44,19.76 327.99,19.76 327.32,19.08 323.56,19.08 322.77,19.87 320.53,19.87 317.45,16.79 317.45,14.54 316.76,13.85 316.76,12.74 314.79,10.77 312.06,10.77 311.35,11.48 307.83,11.48 307.31,10.96 301.48,10.96 299.21,13.23 295.37,13.23 295.14,13 289.71,13 286.35,16.36 277.94,16.36 277.47,16.83 277.47,17.28 270.37,24.38 243.05,24.38 v2(241.02,22.34)
  IN3 w0.081: v2(165.13,41.68) 166.04,42.6 166.04,43.58 166.12,43.66 166.12,44.42 167.91,46.21 167.91,47.42 173.36,52.86 174.65,52.86 178.03,56.24 185.96,56.24 186.57,55.63 192.88,55.63 194.9,53.61 195.27,53.61 195.75,53.14 196.62,53.14 198.6,51.15 198.6,49.58 202.12,46.06 202.12,43.62 204.23,41.51 204.23,40.67 206.37,38.52 206.37,38.17 207.49,37.05 208.54,37.05 209.72,35.88 209.88,35.88 212.82,32.93 213.91,32.93 214.59,32.25 218.75,32.25 222.04,28.96 228.52,28.96 229.04,29.48 230.62,29.48 231.19,28.91 234.95,28.91 241.02,22.85 v2(241.02,22.34) ; v2(337.38,22.45) 337.91,21.91 337.91,18.72 337.44,18.24 336.86,18.24 336.57,18.53 v2(336.57,18.88)
HDA_RST#: length 9.2
  TOP w0.102: 173.27,38.3 173.09,38.3
  TOP w0.109: UH1.BE10 174.82,38.76 173.72,38.76 173.27,38.3 ; 173.09,38.3 172.58,38.3 171.83,39.05 171.83,39.74 170.58,41 170.58,41.2 v1(170.27,41.51) 170.18,41.6 169.09,41.6 RH636.2 168.59,42.09 RH50.2
HDA_RST#_R: length 215.1
  TOP w0.109: v2(166.46,42.6) 166.63,42.6 RH50.1 ; v2(333.4,25.59) 334.42,25.59 335.73,26.91 v1(336.53,26.91) 336.92,26.52 RA50.1
  IN2 w0.081: v2(333.4,25.59) 332.98,25.17 331.58,25.17 331.44,25.02 330.2,25.02 329.56,24.39 329.56,21.52 328.25,20.22 327.77,20.22 327.09,19.54 325.38,19.54 324.23,20.7 323.55,20.7 323.18,20.33 320.34,20.33 316.99,16.98 316.99,14.73 316.3,14.04 316.3,12.93 314.6,11.23 312.25,11.23 311.54,11.94 307.53,11.94 307.38,11.79 301.32,11.79 299.29,13.82 289.6,13.82 286.53,16.9 278.18,16.9 277.94,17.14 277.94,17.46 270.56,24.84 242.55,24.84 240.37,22.66 v2(240.37,22.34)
  IN3 w0.081: v2(240.37,22.34) 240.37,22.75 234.69,28.43 216.1,28.43 209.86,34.67 207.56,34.67 205.57,36.66 205.57,38.23 203.52,40.28 203.52,41.2 201.03,43.69 201.03,45.82 199.28,47.58 198.89,47.58 197.55,48.91 197.55,49.09 197.2,49.44 197.2,50.43 196.18,51.46 194.94,51.46 193.92,52.48 193.92,53.47 192.59,54.79 184.67,54.79 184.19,55.27 179.77,55.27 176.34,51.84 173.04,51.84 168.49,47.3 168.49,45.88 168.33,45.71 168.33,44.27 166.65,42.6 v2(166.46,42.6)
HDA_SDIN0: length 222.1
  TOP w0.102: UH1.BE11 173.4,38.16 173.31,38.06 173.05,38.06
  TOP w0.109: 173.05,38.06 172.54,38.06 v1(171.44,39.17) 171.4,39.2 171.4,39.41 v2(170.91,39.9) 170.48,39.9 169.55,40.83 169.04,40.83 168.71,41.17 168.71,41.3 168.44,41.57 166.76,41.57 CA73.1 ; RA9.1 341.35,17.97 v2(339.92,16.53)
  IN2 w0.081: v2(318.17,11.12) 318.17,10.97 317.03,9.82 313.42,9.82 312.86,9.26 309.68,9.26 308.92,10.02 300.05,10.02 299.64,10.42 290.65,10.42 287.81,13.26 278.97,13.26 276.51,15.72 276.51,16.84 270.38,22.97 243.32,22.97 241.71,21.35 239.2,21.35 v2(238.2,22.36)
  IN3 w0.081: v2(170.91,39.9) 171.65,39.9 172.21,40.46 172.21,41.09 170.09,43.2 170.09,44.42 170.41,44.73 170.41,48.23 173.25,51.07 177,51.07 177.37,51.44 185.47,51.44 187.8,49.11 191.99,49.11 192.72,48.38 196.17,48.38 198.15,46.4 198.8,46.4 199.2,46 199.2,43.41 201.26,41.36 201.26,40.38 201.82,39.82 203.01,39.82 204.88,37.95 204.88,36.38 207.3,33.95 209.61,33.95 216.02,27.54 233.37,27.54 238.2,22.71 v2(238.2,22.36)
  IN4 w0.102: v2(339.92,16.53) 339.92,16.67 339.53,17.06 332.09,17.06 328.33,13.3 324.9,13.3 322.13,10.53 318.76,10.53 v2(318.17,11.12)
HDA_SDIN0_R: length 3
  TOP w0.203: RA9.2 343.56,18.9 344.36,19.7 UA1.16
HDA_SDOUT: length 9.9
  TOP w0.089: RH45.2 RH328.2
  TOP w0.102: 173.05,37.55 173.34,37.55 173.49,37.7 173.78,37.7 173.82,37.66 UH1.BF12
  TOP w0.109: CA76.1 166.88,40.6 168.33,40.6 168.61,40.33 RH45.2 ; RH328.2 168.61,39.12 169.47,38.26 v1(170.28,38.26) 170.35,38.26 170.52,38.09 171.72,38.09 172.25,37.55 173.05,37.55
HDA_SDOUT_R: length 226
  TOP w0.089: RH45.1 167.31,40.16
  TOP w0.102: 167.31,40.16 167.2,40.16 167.13,40.09 v2(167.11,40.09)
  TOP w0.109: UA1.17 344.76,19.42 v2(344.56,19.22)
  IN1 w0.102: v2(344.56,19.22) 344.56,19.39 340.95,23.01 340.95,24.16 v2(337.81,27.3)
  IN2 w0.081: v2(333.75,23.34) 333.75,21.85 330.13,18.24 321.53,18.24 318.72,15.43 318.72,13.85 318.07,13.2 318.07,12.52 317.55,12 317.55,11.07 316.78,10.3 311.84,10.3 311.13,11.02 308.16,11.02 307.61,10.47 300.24,10.47 299.85,10.86 290.87,10.86 288.01,13.72 279.16,13.72 276.99,15.89 276.99,17.06 270.58,23.47 243.18,23.47 241.54,21.83 240.18,21.83 v2(239.68,22.34)
  IN3 w0.081: v2(333.75,23.34) 333.75,24.57 336.48,27.3 v2(337.81,27.3) ; v2(167.11,40.09) 167.11,42.6 168.55,44.04 168.55,45.6 168.76,45.81 168.76,47.25 173.13,51.61 176.7,51.61 177.07,51.99 185.57,51.99 187.07,50.49 191.26,50.49 192.91,48.84 196.55,48.84 198.43,46.95 199.44,46.95 200.38,46.01 200.38,45.13 200.05,44.8 200.05,44.05 202.44,41.66 202.44,40.62 202.77,40.29 203.19,40.29 205.34,38.14 205.34,36.57 207.48,34.42 209.78,34.42 216.02,28.19 233.37,28.19 238.73,22.83 239.19,22.83 v2(239.68,22.34)
  BOTTOM w0.109: v2(337.81,27.3) v1(337.81,28.4)
HDA_SYNC: length 12.1
  TOP w0.109: CA74.1 163.78,40.85 164.54,40.09 v1(164.54,39.3) 165,38.84 168.15,38.84 RH48.2 168.98,38.38 169.47,37.89 171.59,37.89 172.2,37.28 173.44,37.28 UH1.BG13
HDA_SYNC_R: length 221.7
  TOP w0.109: v2(339.9,17.3) 340.9,18.31 340.9,19.25 341.08,19.42 342.59,19.42 342.75,19.26 343.5,19.26 343.96,19.72 UA1.15 ; v2(166.5,38.41) 166.52,38.38 RH48.1
  IN1 w0.102: v2(339.9,17.3) 339.9,18.26 337.09,21.07 335.04,21.07 v2(334.93,21.17)
  IN2 w0.081: v2(238.87,22.33) 239.61,21.59 241.62,21.59 243.27,23.23 270.49,23.23 276.76,16.96 276.76,15.8 279.07,13.49 287.91,13.49 290.74,10.65 299.74,10.65 300.14,10.24 309.02,10.24 309.77,9.49 312.77,9.49 313.33,10.05 316.85,10.05 317.77,10.98 317.77,11.93 318.28,12.44 318.28,13.08 318.95,13.76 318.95,15.3 321.65,18.01 330.23,18.01 333.12,20.9 334.66,20.9 v2(334.93,21.17)
  IN3 w0.081: v2(238.87,22.33) 238.87,22.36 233.29,27.94 215.94,27.94 209.7,34.18 207.4,34.18 205.11,36.47 205.11,38.04 203.09,40.06 201.91,40.06 201.49,40.48 201.49,41.45 199.43,43.51 199.43,46.09 198.87,46.65 198.22,46.65 196.27,48.61 192.81,48.61 191.16,50.26 186.97,50.26 185.53,51.71 177.31,51.71 176.99,51.38 173.23,51.38 170.18,48.34 170.18,44.86 168.68,43.36 168.68,42.49 167.54,41.36 167.54,39.05 166.9,38.41 v2(166.5,38.41)
HDD_DET#: length 195.5
  TOP w0.089: v2(182.59,18.03) 181.99,18.63 181.99,20.49 182.07,20.57 UH1.AK47
  TOP w0.109: v2(182.59,18.03) 182.77,17.84 182.77,17.75 183.62,16.9 RH324.2
  IN2 w0.081: v2(217.8,17) 218.14,16.65 250.03,16.65 250.94,17.57 265.67,17.57 267.65,15.59 268.42,15.59 269.79,14.23 269.79,12.48 270.22,12.05 270.55,12.05 271.52,11.08 274.07,11.08 278.09,7.06 280.85,7.06 281.37,7.58 284.36,7.58 286.78,5.16 290.08,5.16 291.07,6.15 305.39,6.15 306.55,5 308.65,5 308.87,4.78 312.72,4.78 313.42,4.08 320.66,4.08 323.97,7.39 325.12,7.39 326.98,9.24 328.54,9.24 329.01,9.72 334.39,9.72 340.92,9.72 344.01,12.81 345.53,12.81 349.38,8.96 353.6,8.96 354.65,7.9 JNGFF4.34 ; v2(189.01,17.86) 187.45,17.86 187.19,18.11 185.94,18.11 185.05,19 183.25,19 182.59,18.34 v2(182.59,18.03)
  IN3 w0.081: v2(189.01,17.86) 190.14,16.73 200.29,16.73 201.56,18.01 204.06,18.01 205.07,17 v2(217.8,17)
  BOTTOM w0.109: v2(189.01,17.86) 189.01,17.91 v1(188.62,18.31)
HDD_FALL_INT: length 268.1
  TOP w0.102: v2(177.46,30.24) 177.46,30.68 UH1.AW26
  IN1 w0.102: v2(288.08,71.92) 289.54,71.92 308.28,53.18 312.06,53.18 315.44,49.8 334.72,49.8 338,46.52 339.57,46.52 344.54,41.55 344.54,40.21 345,39.75 v2(345.95,39.75)
  IN3 w0.081: v2(345.95,39.75) 345.64,39.75 342.86,36.97 v2(342.86,32.14) ; v2(177.46,30.24) 177.46,30.47 177.62,30.63 178.4,30.63 178.8,31.03 178.8,31.59 178.51,31.87 178.24,31.87 177.82,32.29 177.82,32.78 177.44,33.16 171.74,33.16 170.29,34.6 168.74,34.6 168.43,34.9 168.43,36.37 167.22,37.58 166.26,37.58 165.84,38 165.84,38.7 166.16,39.02 166.71,39.02 166.89,39.21 166.89,39.69 166.51,40.07 165.69,40.07 164.64,41.12 164.64,41.95 165.56,42.88 165.56,43.78 165.64,43.86 165.64,44.67 167.41,46.45 167.41,47.62 173.18,53.4 174.47,53.4 177.8,56.72 186.16,56.72 186.77,56.11 189.39,56.11 v2(189.84,56.56)
  BOTTOM w0.102: v2(177.46,30.24) 177.28,30.24 176.89,30.64 174.48,30.64 174.29,30.46 RH355.2
  BOTTOM w0.109: v2(288.08,71.92) 288.08,72.14 286.71,73.51 278.79,73.51 276.98,71.7 250.73,71.7 250.09,72.33 208.34,72.33 202.88,77.8 198.66,77.8 v3(197.15,76.29) 196.64,75.78 196.64,74.49 195.48,73.33 195.48,64.34 194.99,63.85 194.99,61.01 191.13,57.16 190.43,57.16 v2(189.84,56.56) ; v2(342.86,32.14) 342.3,31.58 342.3,27.93 341.98,27.61 LGA1.12
HDD_IFDET: length 29.3
  TOP w0.109: UZ60.1 330.48,26.03 330.87,25.64 331.4,25.64 331.71,25.95 RZ541.1 332.08,27.02 332.5,26.6 v2(332.5,25.58)
  IN1 w0.102: v2(332.5,25.58) 332.5,25.18 332.7,24.98 332.7,23.07 333.14,22.63 334.7,22.63 336.04,21.29 337.25,21.29 340.33,18.21 340.33,16.05 v2(339.97,15.69)
  BOTTOM w0.109: v2(339.97,15.69) 341.38,15.69 342.63,14.44 342.63,11.49 v1(343.4,10.72) 344.4,9.72 JNGFF4.75
HOST_DEBUG_TX: length 109
  TOP w0.102: UE1.G11 v2(138.33,24.85)
  IN3 w0.081: v2(66.98,5.18) 67.53,5.18 69.33,6.98 70.39,7.4 73.1,7.4 75.46,5.04 79.83,5.04 81.27,3.6 82.01,3.6 82.85,4.45 82.85,5.99 83.65,6.78 91.38,6.78 92.15,7.55 92.97,7.55 93.53,8.11 93.53,8.66 96.35,11.48 109.65,11.48 111.91,9.22 114.94,9.22 115.71,9.99 119.15,9.99 119.59,10.43 120.74,10.43 122.07,9.1 125.74,9.1 127.25,7.58 129.09,7.58 129.52,8.02 134.05,8.02 135.34,9.3 136.36,9.3 137.74,10.68 137.74,10.95 138.46,11.67 138.46,12.25 139.08,12.88 139.08,14.38 139.93,15.23 139.93,18.7 139.56,19.07 139.56,20.83 139.18,21.22 139.18,23.52 138.33,24.36 v2(138.33,24.85)
  BOTTOM w0.109: JDEG1.8 59.25,4.3 60.69,5.74 62.42,5.74 RE73.2 RE306.2 62.61,6.71 63.08,7.18 63.77,7.18 64.58,6.37 v1(65.17,6.37) 66.37,6.37 66.98,5.76 v2(66.98,5.18)
HOST_SD_WP#: length 212.1
  TOP w0.102: RH214.2 165.79,44.1 166.66,43.23 ; UH1.BE8 174.56,39.89 174.29,39.63 173.99,39.63 173.81,39.45 173.05,39.45 172.79,39.71
  TOP w0.109: 172.79,39.71 172.46,40.04 171.92,40.04 170.77,41.18 170.77,41.42 170.39,41.8 169.43,41.8 169.09,42.14 169.09,42.82 168.68,43.23 166.66,43.23 ; RH214.2 164.83,43.58 v1(162.87,43.58) 162.52,43.58 v2(162.05,44.05)
  IN3 w0.081: v2(39.74,28.12) 37.81,26.19 36.41,26.19 34.97,24.74 32.94,24.74 30.5,22.3 28.59,22.3 27.36,21.07 27.36,20.32 24.97,17.92 24.97,10.4 25.76,9.61 25.76,7.54 24.53,6.31 v2(23.68,6.31) ; v2(162.05,44.05) 161.98,43.98 155.01,43.98 153.58,45.41 153.58,46.09 152.77,46.9 151.13,46.9 150.05,45.83 149.19,45.83 148.81,45.45 142.78,45.45 141.63,46.59 139.4,46.59 139.04,46.95 137.44,46.95 137.22,47.18 135.13,47.18 134.62,47.69 130.45,47.69 127.95,45.18 124.71,45.18 122.99,43.46 119.21,43.46 118.24,44.43 117.32,44.43 116.47,45.27 116.47,46.18 114.3,48.36 110,48.36 109.31,49.06 96.1,49.06 89.4,42.36 84.8,42.36 83.45,43.71 81.17,43.71 80.13,44.75 77.46,44.75 75.54,46.66 70.64,46.66 69.4,45.43 69.13,45.43 68.74,45.04 68.74,42.98 68.74,42.81 66.79,40.87 66.67,40.75 66.13,40.75 65.42,40.05 57.04,40.05 56.77,40.32 56.76,40.32 56.71,40.37 54.6,40.37 54.38,40.59 49.94,40.59 48.72,39.36 47.52,39.36 47.36,39.52 v2(47.36,39.75)
  BOTTOM w0.109: v2(39.74,28.12) 39.99,28.37 39.99,31.69 39.4,32.28 39.4,32.91 40.87,34.39 43.12,34.39 43.39,34.65 44.81,34.65 44.87,34.71 46.03,34.71 46.31,35 46.31,37.45 47.36,38.5 v2(47.36,39.75) ; v2(23.68,6.31) 24.62,5.37 26.14,5.37 26.58,5.81 28.47,5.81 29.67,7.01 31.43,7.01 32.34,7.92 32.34,10.04 32.7,10.41 QR1.2
HP_OUT_L: length 13.8
  TOP w0.203: v2(350.16,20.85) 350.16,20.85 349.77,20.85 v1(349.65,20.97) 348.79,21.83 UA1.27
  TOP w0.381: RA7.2 350.96,21.27 350.54,20.85 v2(350.16,20.85)
  TOP w0.508: CA43.2 352.28,25.39 v2(352.74,25.39)
  IN2 w0.508: v2(350.16,20.85) 352.49,20.85 353.29,21.65 353.29,22.45 351.99,23.74 351.99,25.06 352.32,25.39 v2(352.74,25.39)
  BOTTOM w0.381: v2(350.16,20.85) 350.82,20.85 CA224.1
HP_OUT_R: length 14.1
  TOP w0.203: UA1.26 348.77,21.43 349.11,21.09 349.11,21 349.91,20.2 v2(350.14,20.2)
  TOP w0.381: v2(350.14,20.2) 350.94,20.2 RA8.2
  TOP w0.508: v2(352.63,24.72) 352.63,24.42 351.97,23.77 CA44.2
  IN2 w0.508: v2(350.14,20.2) 352.81,20.2 353.98,21.36 353.98,22.73 352.63,24.08 v2(352.63,24.72)
  BOTTOM w0.381: v2(350.14,20.2) 351.1,20.2 CA225.1
HW_ACAVIN_NB: length 87.9
  TOP w0.109: v2(60.26,7.35) 60.26,7.18 60.55,6.89 JIO1.19 ; UE1.N6 133.86,19.57 v2(133.86,18.99) ; v2(66.71,9.12) v1(66.71,10.03)
  IN2 w0.081: v2(60.26,7.35) 60.67,7.76 64.05,7.76 64.62,8.34 65.57,8.34 66.34,9.12 v2(66.71,9.12)
  IN3 w0.081: v2(133.86,18.99) 133.43,19.42 132.84,19.42 132.6,19.18 132.6,18.82 132.77,18.66 132.77,18.08 131.61,16.92 130.63,16.92 129.98,16.27 127.4,16.27 125.21,14.08 119.65,14.08 119.39,13.82 113.09,13.82 112.18,14.73 104.62,14.73 104.33,14.45 95.52,14.45 93.06,11.98 89.14,11.98 88.25,11.09 83.56,11.09 82.94,10.47 81.22,10.47 80.88,10.13 80.88,8.41 80.68,8.21 80.68,7.3 79.78,6.39 77.89,6.39 75.94,8.35 71.07,8.35 69.29,10.13 67.72,10.13 v2(66.71,9.12)
HW_GPS_DISABLE#_R: length 13.9
  BOTTOM w0.109: DZ6.2 284.9,9.31 284.9,10.25 v1(285.1,10.46) 285.36,10.71 287.94,10.71 288.87,11.64 291.01,11.64 291.48,11.17 295.37,11.17 295.75,10.78 JNGFF2.18
I2C1_SCK_TP: length 191.5
  TOP w0.102: v2(165.01,32.56) 165.01,32.69 165.24,32.93 167.26,32.93 167.68,33.34 170,33.34 170.56,33.9 171.05,33.9 171.52,33.43 173.36,33.43 173.44,33.51 174.26,33.51 174.47,33.3 UH1.BE21
  TOP w0.109: v2(268.92,13.58) 269.35,14.01 273.94,14.01 275.3,12.65 275.3,11.46 273.45,9.61 v1(273.45,7.74) 273.45,6.23 273.6,6.07 274.27,6.07 RZ21.2 274.86,6.66 RZ29.1
  IN3 w0.081: v2(268.92,13.58) 267.86,14.64 264,14.64 259.89,18.75 259.89,26.65 257.06,29.48 249.1,29.48 248.47,28.85 240.68,28.85 238.78,30.75 232.74,30.75 232.45,31.04 227.83,31.04 226.81,30.02 222.65,30.02 219.32,33.34 215.2,33.34 214.26,34.27 213.52,34.27 213.29,34.51 213.29,36.06 212.36,36.98 209.89,36.98 208.88,37.99 207.88,37.99 207.31,38.56 207.31,39 206.05,40.27 206.05,43.59 206.13,43.67 206.13,47.13 203.14,50.12 201.62,50.12 201.21,49.71 199.95,49.71 199.55,50.11 199.55,51.54 197.15,53.94 197.15,54.58 195.1,56.63 194.25,56.63 191.47,59.41 190.4,59.41 189.38,58.39 186.62,58.39 185.35,59.67 184.68,59.67 182.29,62.05 179.56,62.05 174.92,57.41 172.86,57.41 170.87,55.42 169.28,55.42 163.89,50.03 163.89,46.6 162.5,45.21 162.5,43.11 162,42.61 162,39.83 163.15,38.69 163.15,37.04 162.69,36.58 162.69,34.78 163.42,34.04 163.97,34.04 165.01,33 v2(165.01,32.56)
I2C1_SCK_TP_R: length 20.6
  TOP w0.109: v2(279.74,5.48) 279.74,6.56 279.11,7.19 278.07,7.19 277.58,6.7 RZ117.2 276.74,6.56 RZ29.2 276.65,7.4 RZ347.2 ; v2(281.44,12.2) 282.33,11.31 284.52,11.31 284.66,11.45 JKBTP1.19
  BOTTOM w0.109: v2(279.74,5.48) 279.74,5.23 279.54,5.03 278.66,5.03 278.49,5.2 v3(278.49,5.63) 278.49,5.7 278.88,6.1 278.88,10.76 279.82,11.7 280.94,11.7 v2(281.44,12.2)
I2C1_SDA_TP: length 190.1
  TOP w0.102: 167.83,33.13 170.05,33.13 170.59,33.66 170.96,33.66 171.39,33.24 173.44,33.24 173.51,33.32 173.89,33.32 173.94,33.27 UH1.BF21
  TOP w0.109: 167.83,33.13 167.43,32.72 165.78,32.72 v2(165.61,32.56) ; RZ26.1 RZ20.2 274.32,5.83 273.18,5.83 v1(272.96,6.05) 272.96,6.29 273.09,6.42 273.09,9.59 275.05,11.55 275.05,12.57 273.84,13.78 270.15,13.78 269.57,13.2 v2(269.37,13.2)
  IN3 w0.081: v2(269.37,13.2) 269.21,13.04 268.58,13.04 267.27,14.36 263.91,14.36 259.62,18.64 259.62,26.54 256.95,29.21 249.21,29.21 248.58,28.58 240.57,28.58 238.65,30.5 231.01,30.5 230.88,30.64 229.19,30.64 228.34,29.79 222.5,29.79 219.19,33.1 214.99,33.1 214.13,33.95 213.52,33.95 213.06,34.41 213.06,35.97 212.27,36.75 209.82,36.75 208.81,37.76 207.78,37.76 207.08,38.46 207.08,38.91 205.82,40.17 205.82,43.68 205.9,43.76 205.9,46.85 203,49.75 202.03,49.75 201.7,49.43 199.77,49.43 199.32,49.87 199.32,51.44 196,54.76 196,55.4 195.01,56.4 194.15,56.4 191.39,59.16 190.47,59.16 189.47,58.17 186.53,58.17 185.25,59.44 184.58,59.44 182.2,61.82 179.69,61.82 175.02,57.15 172.93,57.15 170.94,55.16 169.48,55.16 164.12,49.8 164.12,46.51 162.73,45.11 162.73,42.86 162.25,42.38 162.25,39.89 163.36,38.78 163.36,36.96 162.9,36.5 162.9,34.87 163.42,34.35 163.96,34.35 165.61,32.69 v2(165.61,32.56)
I2C1_SDA_TP_R: length 19.9
  TOP w0.109: v2(275.76,10.5) 275.77,10.51 RZ346.2 ; JKBTP1.18 285.16,11.34 284.89,11.07 281.95,11.07 v2(280.83,12.19) ; v2(275.95,5.99) 276.16,5.99 276.67,5.48 RZ26.2 277.55,5.34 RZ116.2
  BOTTOM w0.109: v2(280.83,12.19) 277.29,12.19 275.76,10.66 v2(275.76,10.5) 274.95,9.69 274.95,6.58 275.53,5.99 v2(275.95,5.99)
I2C_ADDR_MUX1: length 3.5
  TOP w0.109: UV66.6 v2(69.26,37.03)
  BOTTOM w0.109: v2(69.26,37.03) 69.62,37.39 70.24,37.39 RV849.1 70.91,37.65 v1(71.48,37.09)
I2C_ADDR_MUX2: length 13.9
  TOP w0.109: UV67.6 v2(148.7,46.43)
  BOTTOM w0.109: RV862.1 155.8,45.05 157.03,46.28 157.03,47.29 156.33,47.98 v1(155.84,47.98) 152.38,47.98 152.07,47.67 149.42,47.67 148.7,46.94 148.7,46.43 v2(148.7,46.43)
I_ADP: length 254.9
  TOP w0.102: v2(138.36,29.66) 138.38,29.64 138.38,29.09 137.93,28.64 UE1.B11
  TOP w0.109: v2(284.9,36.88) 285.01,36.77 PR717.1 ; v2(275.44,86.69) 275.01,86.27 275.01,85.17 274.22,84.38 270.3,84.38 259.67,73.74 213.13,73.74 203.33,83.54 199.66,83.54 191.39,75.28 191.39,72.2 191.7,71.9 191.7,68.65 183.54,60.5 183.54,59.3 v1(183.84,59) 184.07,58.77 v2(184.07,58.2)
  IN2 w0.081: v2(284.9,36.88) 284.9,37.44 288.09,40.64 288.09,44.68 290.04,46.62 290.04,51.05 296.28,57.29 296.28,60.15 288.69,67.74 288.69,70.64 287.63,71.69 287.63,73.03 285.83,74.83 282.78,74.83 282.16,74.21 278.1,74.21 273.5,78.82 273.5,85.68 274.51,86.69 v2(275.44,86.69) ; v2(184.07,58.2) 183.65,58.61 182.5,58.61 181.86,57.97 181.86,56.8 175.92,50.87 175.92,49.03 175.14,48.25 173.86,48.25 173.04,47.44 173.04,45.83 172.94,45.72 172.94,44.03 172.45,43.54 172.45,42.83 169.96,40.35 169.19,40.35 168.06,39.22 168.06,38.73 167.28,37.95 167.28,37.52 166.89,37.13 166.06,37.13 165.78,36.85 163.52,36.85 162.64,35.96 160.14,35.96 158.11,33.93 158.11,33.2 157.38,32.46 156.19,32.46 155.31,31.58 152.57,31.58 152.14,31.15 146.56,31.15 145.49,30.09 144.36,30.09 144.23,30.21 142.52,30.21 142.08,29.77 139.46,29.77 139.01,29.32 138.54,29.32 138.36,29.5 v2(138.36,29.66)
I_BATT: length 201.9
  TOP w0.109: v2(282.41,32.21) 282.6,32.4 PR719.1 ; v2(269.5,16.46) 268.89,15.85 267.09,15.85 v2(264.46,13.21)
  IN1 w0.102: v2(282.41,32.21) 281.42,32.21 280.2,30.99 280.2,25.84 274.28,19.92 270.64,19.92 268.12,17.39 268.12,16.6 268.41,16.31 269.35,16.31 v2(269.5,16.46)
  IN2 w0.081: v2(264.46,13.21) 264.03,12.79 253.47,12.79 250.97,10.29 238.32,10.29 236.7,11.92 228.45,11.92 227.93,12.44 220.58,12.44 218.48,10.35 215.55,10.35 214.32,9.12 214.32,6.86 213.83,6.37 213.17,6.37 212.07,5.27 212.07,4.17 210.89,2.99 206.44,2.99 204.92,4.51 197.68,4.51 197.12,3.95 191.7,3.95 190.95,3.2 189.54,3.2 188.79,2.45 178.95,2.45 176.25,5.15 172.31,5.15 170.06,7.4 166.08,7.4 165.51,6.83 161.25,6.83 157.67,10.4 156.52,10.4 155.49,9.37 148.49,9.37 145.79,6.67 145.79,5.88 145.48,5.57 141.17,5.57 140.37,4.78 140.1,4.78 136.83,1.5 130.47,1.5 129.86,2.12 129.86,4.25 129.32,4.79 127.76,4.79 126.42,6.14 v2(126.15,6.14)
  BOTTOM w0.109: RE64.2 132.03,13.04 131.76,12.76 131.76,12.26 131.41,11.92 v1(130.81,11.92) 130.07,11.92 126.15,7.99 v2(126.15,6.14)
I_BATT_R: length 11.6
  TOP w0.102: UE1.J4 v2(131.93,22.45)
  BOTTOM w0.109: 131.19,13.98 131.19,14.25 131.34,14.4 131.34,14.76 131.1,15 130.61,15 130.23,15.38 130.23,17.03 130.58,17.39 130.58,18.25 130.33,18.5 130.33,19.37 v1(131.2,20.23) 131.55,20.58 131.55,21.89 131.93,22.28 v2(131.93,22.45) ; 131.19,13.98 RE64.1 ; 131.19,13.98 CE3.1
I_SYS: length 353
  TOP w0.109: v2(255.78,4.95) v1(255.78,6.16) 256.2,6.58 256.2,9.05 257.93,10.79 259.64,10.79 264.67,15.82 266.38,15.82 266.91,16.35 268.14,16.35 v2(268.56,16.77) ; PR714.1 281.73,31.54 PR723.1 281.69,30.89 v2(281.74,30.84)
  TOP w0.203: PU1100.24 264.98,141.33 265.53,140.77 v2(265.53,140.47)
  IN1 w0.102: v2(125.59,4.91) 125.59,4.4 128.73,1.27 157.88,1.27 159.36,2.75 159.36,5.16 160,5.8 165.45,5.8 165.66,6.02 169.75,6.02 171.89,3.88 171.89,2.55 173.17,1.27 198.23,1.27 198.32,1.37 253.09,1.37 255.78,4.05 v2(255.78,4.95) ; v2(268.56,16.77) 268.82,16.77 271.44,19.38 274.51,19.38 280.76,25.63 280.76,29.86 v2(281.74,30.84)
  IN2 w0.081: v2(283.42,56.95) 282.86,57.52 280.37,57.52 277.72,60.17 277.72,61.95 263.08,76.59 263.08,93 263.47,93.39 263.47,94.84 263,95.31 263,97.04 266.08,100.13 266.39,100.13 269.24,102.98 269.24,107.37 271.03,109.15 273.81,109.15 274.78,110.13 274.78,112.18 275.78,113.19 v2(275.78,143.35)
  IN3 w0.081: v2(281.74,30.84) 282.32,31.42 284.31,31.42 286.78,33.9 286.78,35.63 289.6,38.45 289.6,42.18 289.94,42.52 289.94,43.17 288.71,44.41 285.73,44.41 284.19,45.95 284.19,47.9 283.42,48.66 v2(283.42,56.95) ; v2(275.78,143.35) 275.07,142.64 267.71,142.64 v2(265.53,140.47)
  BOTTOM w0.109: v2(125.59,4.91) 127,4.91 130.62,8.53 130.62,9.24 131.28,9.89 132.35,9.89 132.67,10.21 132.67,10.89 133.26,11.48 133.26,12.62 133.03,12.85 132.66,12.85 132.5,13.01 132.5,13.25 132.5,13.25 132.5,13.96 132.5,13.96 132.5,14.49 132.23,14.76 131.97,14.76 131.34,15.39 RE312.2
  BOTTOM w0.203: PR1153.1 266.4,140.99 265.88,140.47 v2(265.53,140.47)
I_SYS_R: length 7.8
  TOP w0.102: v2(132.73,22.45) 132.83,22.55 UE1.J5
  BOTTOM w0.109: v2(132.73,22.45) 132.34,22.05 132.34,20.31 v1(132.58,20.07) 132.33,19.82 132.33,17.46 CE4.1 132.25,16.47 RE313.1 132.26,15.59 RE312.1
ILIM_1PH: length 3.7
  TOP w0.203: PR1116.2 PC1100.2 261.58,149.95 v1(261.58,149.29) 261.58,149.16 262.18,148.56 PU1100.49
ILIM_2PH: length 2.8
  TOP w0.203: PU1100.32 267.59,144.53 v1(267.92,144.2) PR1139.1
ILIM_4PH: length 3.1
  TOP w0.203: PR1138.2 258.18,144.55 v1(258.67,144.55) 259.04,144.93 PU1100.7
ILIM_CHG: length 14.6
  TOP w0.109: v2(289,27.53) 289.42,27.53 v1(289.83,27.12) ; PR726.1 281.89,21.79 PQ704.1 282.67,22.47 PR720.2 v2(282.29,23.68)
  TOP w0.203: v2(289,27.53) 288.67,27.86 PU700.21
  IN1 w0.102: v2(282.29,23.68) 282.29,24.34 283.65,25.7 283.65,26.99 284.43,27.77 288.76,27.77 v2(289,27.53)
ILIM_SEL1: length 5.1
  TOP w0.254: RI13.1 351.7,44.37 352.12,44.78 v1(352.12,46.3) 352.12,46.75 351.11,47.77 UI1.4
ILIM_SEL2: length 1.6
  TOP w0.254: UI2.4 350.88,37.41 351.3,36.99 RI67.1
IMON_1PH: length 4.2
  TOP w0.203: PU1100.46 263.38,148.92 v2(263.21,149.09)
  BOTTOM w0.109: v2(263.21,149.09) 263.08,149.22 262.75,149.22 v1(262.61,149.36)
  BOTTOM w0.203: PC1106.2 264.02,148.37 PR1112.2 262.76,148.64 v2(263.21,149.09)
IMVP_VR_ON: length 225.1
  TOP w0.109: UE4.2 158.81,19.68 v2(158.7,19.57) 158.7,19.57 158.25,19.12 UE3.4 ; v2(163.17,20.01) 163.17,19.5 RE304.1 ; v2(265.52,151.74) 265.33,151.94 PR1198.2
  IN1 w0.102: v2(158.7,19.57) 159.36,19.57 159.66,19.27 160.93,19.27 161.27,19.61 162.77,19.61 163.17,20.01 v2(163.17,20.01)
  IN3 w0.081: v2(186.84,77.98) 189.81,80.95 189.81,83.23 191.18,84.6 191.18,89.51 191.66,89.99 191.66,101.83 192.14,102.31 192.14,106.26 191.56,106.84 191.56,107.8 193.39,109.64 193.39,121.92 192.87,122.43 192.87,123.41 193.46,123.99 193.46,126.04 192.98,126.52 192.98,129.52 195.88,132.42 207.52,132.42 209.35,134.25 216.83,134.25 222.29,139.71 225.23,139.71 234.79,149.27 241.23,149.27 243.17,151.21 260.91,151.21 261.27,150.85 264.63,150.85 v2(265.52,151.74)
  BOTTOM w0.109: v2(163.17,20.01) 163.17,19.68 162.73,19.25 162.73,18.63 162.22,18.13 161.79,18.13 161.29,18.62 161.28,18.62 160.77,19.13 160.77,19.99 160.96,20.18 160.96,21.18 159.9,22.24 159.9,23.4 159.7,23.59 159.7,25.01 160.12,25.43 160.12,26.12 159.3,26.94 159.3,27.87 160.01,28.57 160.01,30.74 160.4,31.12 160.4,33.98 160.16,34.22 160.16,34.53 160.88,35.24 161.78,35.24 163.27,36.72 163.27,38.53 v1(165.1,40.37) 165.79,41.05 165.79,44.44 171.05,49.7 171.9,49.7 176.51,54.31 176.51,61.87 179.51,64.86 182.86,64.86 185.15,67.16 185.15,73.24 187.12,75.21 187.12,77.71 v2(186.84,77.98)
IMVP_VR_ON_EC: length 47.8
  TOP w0.109: UE1.N7 134.68,19.6 v2(134.68,18.96) ; UE3.1 160.22,17.82 160.44,18.04 161.86,18.04 162.23,18.41 v2(162.23,18.73) 162.69,18.73 RE304.2 ; RE737.2 147.66,16.48 147.27,16.08 146.34,16.08 145.7,15.43 144.36,15.43 143.92,15.88 v1(143.92,16.64) 142.8,17.76 142.28,17.76 v2(141.83,18.2)
  IN4 w0.102: v2(162.23,18.73) 161.8,18.73 161.18,19.35 161.18,20.99 160.46,21.72 160,21.72 159.3,21.02 158.29,21.02 157.95,21.36 155.56,21.36 154.16,22.76 153.65,22.76 152.59,23.82 148.47,23.82 147.37,22.71 147.37,22.71 144.82,20.16 143.68,19.03 142.22,19.03 141.83,18.65 v2(141.83,18.2) 141.26,18.2 140.12,19.34 138,19.34 137.15,18.5 135.26,18.5 134.8,18.96 v2(134.68,18.96)
INT_SPK_L+: length 38.8
  IN2 w1.016: 345.57,26.16 345.56,26.16 343.09,26.16 342.47,25.54 342.47,21.58 342.06,21.17 342.06,13.72 340.16,11.83 336.09,11.83 335.39,12.53 326.39,12.53 323.61,9.74 321.46,9.74 321.02,9.3
  vias: v2(320.16,8.73) v2(320.79,8.72) v2(345.53,27.63) v2(345.54,27.05) v3(321.68,7.94)
INT_SPK_L-: length 36.1
  IN2 w1.016: 343.93,27.4 342.62,27.4 341.31,26.08 341.31,22.03 340.91,21.64 340.91,14.19 339.69,12.97 336.56,12.97 335.86,13.67 325.87,13.67 323.15,10.94 323.13,10.94
  BOTTOM w0.109: v2(345.01,27.29) 345.01,26.79 v1(345.51,26.29)
  vias: v2(321.59,11.15) v2(322.18,11.15) v2(345,27.9)
INT_SPK_R+: length 31.5
  IN2 w1.016: 321.96,14.15 323.99,16.19 331.06,16.19 331.71,16.83 338.09,16.83 339.5,18.24 339.5,22.06 340.16,22.73 340.16,26.83 342.58,29.24
  vias: v2(321.1,13.87) v2(321.31,13.24) v2(343.82,29.47) v2(343.82,28.88) v3(343.82,28.08)
INT_SPK_R-: length 31.9
  IN2 w1.016: 321.84,15.82 323.35,17.33 330.59,17.33 331.23,17.97 337.61,17.97 338.35,18.71 338.35,22.64 339.02,23.3 339.02,27.29 342.15,30.43 343.02,30.43
  vias: v2(321.13,15.3) v2(321.12,14.7) v2(344.59,29.86) v2(344.58,29.27)
INT_SPKR_L+:
  vias: v3(327.55,8.86)
INT_SPKR_L-:
  vias: v3(328.51,10.69)
INT_SPKR_R+:
  vias: v3(327.88,13.11)
INT_SPKR_R-:
  vias: v3(328.17,16.49)
IR_CAM_DET#: length 142.4
  TOP w0.102: RH373.1 169.02,36.32 169.02,36.8 169.33,37.11 169.63,37.11 170.04,36.7 170.38,36.7 171.42,35.66 171.77,35.66 172.39,36.27 173.99,36.27 174.17,36.1 174.48,36.1 174.6,36.21 175.01,36.21 UH1.BD16
  TOP w0.109: JIR1.1 70.57,43.91 69.78,43.12 69.78,41.67 69.12,41.01 v2(69.12,39.17) ; v2(169.13,35.25) RH373.1
  IN2 w0.081: v2(169.13,35.25) 168.95,35.07 168.95,34.75 167.67,33.46 167.1,33.46 165.75,32.11 165.03,32.11 164.13,31.21 164.13,30.72 162.65,29.24 162.05,29.24 161.14,28.33 160.43,28.33 160.12,28.01 159.83,28.01 159.68,27.86 159.04,27.86 158.78,27.61 157.97,27.61 157.36,27 155.05,27 154.37,26.32 153.42,26.32 152.4,25.3 149.23,25.3 146.65,22.72 146.19,22.72 144.44,20.98 141.93,20.98 141.42,20.47 141.42,20.38 140.11,19.06 140.11,18.4 139.56,17.85 138.55,17.85 137.54,16.84 135.89,16.84 135.66,17.08 133.62,17.08 133.18,17.51 132.43,17.51 132.01,17.1 130.39,17.1 129.69,16.39 126.47,16.39 125.93,15.85 124.37,15.85 123.94,16.28 120.15,16.28 119.43,17 119.43,17.42 117.94,18.9 116.89,18.9 116.49,19.31 115.3,19.31 115.06,19.56 113.7,19.56 111.23,22.03 105.86,22.03 105.39,22.5 105.34,22.5 101.9,25.94 101.48,25.94 100.9,26.52 100.54,26.52 99.8,27.27 99.8,27.99 97.71,30.08 97.71,31.69 91.75,37.65 v2(91.13,37.65)
  IN3 w0.081: v2(91.13,37.65) 90.58,38.21 88.68,38.21 88.16,38.72 87.31,38.72 87.31,38.72 86.81,38.72 86.81,38.72 85.08,38.72 84.2,37.85 79.14,37.85 78.85,38.13 78.85,39.6 78.42,40.03 77.02,40.03 76.42,40.63 74.19,40.63 72.72,42.1 72.03,42.1 71,41.06 71,40.68 70.03,39.72 69.36,39.72 69.12,39.48 v2(69.12,39.17)
  BOTTOM w0.109: v1(70.63,39.72) 69.66,39.72 v2(69.12,39.17)
ISH_UART0_CTS#: length 3.3
  TOP w0.109: UH1.BF14 174.09,36.99 173.96,36.85 172.07,36.85 171.67,37.24 RZ80.2
