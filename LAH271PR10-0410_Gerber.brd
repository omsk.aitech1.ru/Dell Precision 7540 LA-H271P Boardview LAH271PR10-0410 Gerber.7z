# Allegro board LAH271PR10-0410_Gerber.brd (continued)
## Nets (continued)
N65849459: RT607.1 UT5.A11(LSRX_P1/GPIO_A11)
N65849624: RT589.1 UT5.B8(VCON_OCP_TRIP_P1 / GPIO_B8)
N65849626: RT590.1 UT5.B9(VCON_OCP_TRIP_P2 / GPIO_B9)
N65849665: UT9.2(EN) UT10.4(Y)
N65849719: CT377.1 UT9.5(VREG)
N65849795: QT9.1(D) RT588.2
N65849809: QT8.1(D) RT586.2
N65849918: RT571.2 UT9.12(VLIM)
N65849972: CT378.2 UT9.10(DV/DT)
N65850130: RT573.2 UT9.9(IMON)
N65850368: QT6.1(D) RT565.2
N65850372: QT7.1(D) RT566.2
N65850533: RT580.1 UT5.A8(UART_TX_P1/GPIO_A8)
N65850562: RT579.1 UT5.A9(UART_RX_P1/GPIO_A9)
N65850646: UT11.2(EN) UT12.4(Y)
N65850648: CT379.1 UT11.5(VREG)
N65850674: RT575.2 UT11.12(VLIM)
N65850690: CT380.2 UT11.10(DV/DT)
N65850724: RT577.2 UT11.9(IMON)
N65851353: RT581.2 UT5.J11(UART_RX_P2/GPIO_J11)
N65851357: RT582.2 UT5.H11(UART_TX_P2/GPIO_H11)
N65851472: CT348.2 UT5.B10(VCCD)
N65854016: JKBTP1.11 RZ1484.1
N65860844: JNGFF1.56 RZ371.1
N66104468: QZ3.1(C) RZ25.1
N66179590: PR1216.2 PU1200.17(THWN)
N66179919: PR1217.2 PU1200.16(DISB#)
N66180146: PR1219.2 PU1201.16(DISB#)
N66180155: PR1218.2 PU1201.17(THWN)
N66180292: PR1221.2 PU1202.16(DISB#)
N66180301: PR1220.2 PU1202.17(THWN)
N66180583: PR1223.2 PU1203.16(DISB#)
N66180592: PR1222.2 PU1203.17(THWN)
N66492810: RT499.2 UT34.1(IN1)
N66492814: RT500.2 UT34.2(IN2)
N66628280: QV23.2(G) RV907.2 RV908.1
N66686075: QV23.5(G) QV23.6(D) RV909.2
N66765158: QZ18.5(G) QZ18.6(D) RZ381.2
N66765204: QZ17.5(G) QZ17.6(D) RZ377.2
N66985757: T297.1 UC1.BL31(RSVD12)
N66985767: T298.1 UC1.AJ8(RSVD3)
N66985777: T299.1 UC1.G13(RSVD25)
N66985787: T300.1 UC1.C38(RSVD22)
N66985797: T301.1 UC1.C1(RSVD20)
N66985807: T302.1 UC1.BR2(RSVD17)
N66985817: T303.1 UC1.BP1(RSVD16)
N66985819: T304.1 UC1.B38(RSVD8)
N66985837: T305.1 UC1.B2(RSVD6)
N66986008: T18.1 UC1.B30(RSVD7)
N66986010: T19.1 UC1.C30(RSVD21)
N66986012: T21.1 UC1.G3(RSVD26)
N66986014: T20.1 UC1.J3(RSVD29)
N66986016: T24.1 UC1.BR31(RSVD18)
N66986018: T22.1 UC1.BH30(RSVD9)
N66986020: T23.1 UC1.BR35(RSVD19)
N66986604: T1.1 UC1.D1(RSVD_TP3)
N66986606: T13.1 UC1.R14(RSVD31)
N66986608: T14.1 UC1.N29(RSVD30)
N66986610: T15.1 UC1.AE29(RSVD2)
N66986612: T12.1 UC1.AA14(RSVD1)
N66986614: T10.1 UC1.H24(RSVD27)
N66986616: T9.1 UC1.J24(RSVD28)
N66986618: T11.1 UC1.BN33(RSVD14)
N66986620: T8.1 UC1.BL34(RSVD13)
N66986622: T7.1 UC1.BN35(RSVD15)
N66986624: T6.1 UC1.BT2(RSVD_TP2)
N66986626: T5.1 UC1.BR1(RSVD_TP1)
N66986628: T4.1 UC1.E2(RSVD_TP5)
N66986633: T2.1 UC1.E1(RSVD_TP4)
N66986635: T27.1 UC1.AP14(RSVD4)
N66986637: T28.1 UC1.AP29(RSVD5)
N66986743: T29.1 UC1.BK28(RSVD11)
N66986745: T30.1 UC1.BJ28(RSVD10)
N66986975: T26.1 UC1.AT13(ZVM#)
N66986977: T25.1 UC1.AW13(MSM#)
N66986979: T31.1 UC1.AU13(RSVD1)
N66986981: T32.1 UC1.AY13(RSVD2)
N67164217: CD25.2 RD12.1
N67172576: RD34.2 RD36.2 RD37.1
N67172641: CD87.2 RD33.1
N67430793: CV954.1 QZ1.2(G) RZ545.2
N67987936: C193.2 UZ44.12(CT1)
N67987971: C195.1 UZ7.6(CT)
N67988016: C192.2 UZ44.10(CT2)
N67988067: C202.2 UZ9.12(CT1)
N67988081: C201.2 UZ9.10(CT2)
N67988141: C207.1 UZ58.6(CT)
N67988280: QN1.5(G) QN1.6(D) RN2.2
N69253627: T286.1 UH1.A25(RSVD1)
N69724739: QV44.1(S) RV742.1
N69725252: QV44.5(G) RV741.1

Pads without a net: FD1 1; FD2 1; FD3 1; FD4 1; FD5 1; FD6 1; JAPS1 16 17 18; JDG1 3; JDGFF1 C10 F10; JDGFF2 A10 C10; JDGFF4 C1 C6 G2 G3 G5 G6 G8 G9 H1 H2 H4 H5 H7 H8 H10; JEDP1 5; JIO1 31 54 58 62 66 70; JIR1 4; JKBTP1 4; JNGFF1 6 8 9 11 12 13 14 17 18 19 20 23 24 26 50 52 54 58 60 62; JNGFF2 10 12 14 16 17 20 30 32 34 36 38 40 48 50 51 53 55 57 59; JNGFF3 6 20 22 24 26 28 30 32 34 36 40 42 44 46 48 56 58 59; JNGFF4 6 20 22 24 26 28 30 36 48 56 58 67; JNGFF5 6 20 22 24 26 28 30 32 34 36 38 40 42 44 46 48 56 58 59; JPB1 3 6; JSIM1 1 5; JSPI1 17; JUSH1 2 25; PBATT1 11 12; PD10 3; PQ704 3 4 5; PQ2102 3 4 5; PQ2106 3 4 5; PU100 10 15; PU101 10; PU400 5; PU500 10; PU501 10 15; PU700 4; PU900 5; PU1200 6 13 19; PU1201 6 13 19; PU1202 6 13 19; PU1203 6 13 19; PU1700 6 13 17 19; PU1800 6 13 17 19; RE749 2; RH99 2; RZ78 1; RZ79 1; RZ80 1; RZ81 1; RZ114 1; RZ364 1; RZ525 2; RZ526 2; RZ527 2; RZ528 2; RZ529 2; RZ530 2; RZ531 1; RZ532 1; RZ533 1; RZ534 1; RZ535 1; RZ536 1; RZ1483 1; UA1 1 6 7 8 9 10 11 12 13 47; UC1 BM31 BT30; UD1 1; UE1 K1 K7; UE4 1; UE11 1; UE12 1 3 6 9 17 20 25; UH1 AA1 AA45 AB2 AB3 AB48 AC6 AC7 AC9 AC11 AC39 AC43 AC44 AD47 AD48 AE9 AE11 AE39 AE44 AE48 AF47 AG45 AH40 AH46 AH47 AH48 AJ46 AJ47 AL15 AL48 AM7 AN4 AN29 AN37 AN40 AN46 AP2 AP3 AP21 AP41 AP47 AP48 AR13 AR48 AT10 AU46 AV7 AV18 AV21 AW3 AW18 AW21 B14 B15 B38 B40 B41 BA33 BA36 BC17 BD8 BD12 BD17 BD21 BD34 BD38 BE12 BE19 BE23 BE29 BE33 BE34 BF10 BF33 BF36 C14 C15 C16 C17 C38 C39 C40 C41 C45 C46 C47 D39 D46 E45 F14 F44 G1 G2 G14 J13 J15 K3 K4 K13 K16 L3 L4 L41 L46 L47 L48 M40 M45 N2 N3 N47 N48 P47 P48 R46 R47 T1 T2 T45 T46 T48 U47 U48 V2 V3 V47 V48 W46 W47 Y2 Y46 Y47 Y48; UI1 9 15; UI2 9 15; UT1 AB3 AB5 AB15 AB17 AB19 AB21 AB23 AC3 AC5 AC15 AC17 AC19 AC21 B23 H5 J9 J11 N4 N5 V8; UT5 B3 B6 B7 F10 G8 G10 H4 H5 H8 J1 K5 K8 L2; UT7 3; UT9 6 7 14; UT11 6 7 14; UV8 2 4 14 58; UV64 22 23 24 25 50 53; UV66 30 33 34 35 36 63 64 65 66; UV67 30 33 34 35 36 63 64 65 66; UV69 1; UZ12 2 4 5 6 7 10 11 12 15 25 26 28 30 31; UZ61 1

## Via types
v1: diameter 0.305, hole 0.152, TOP to BOTTOM, 976 vias
v2: diameter 0.457, hole 0.203, TOP to BOTTOM, 9170 vias
v3: diameter 0.406, hole 0.203, TOP to BOTTOM, 289 vias
v4: diameter 0.508, hole 0.254, TOP to BOTTOM, 231 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0.6V_DDR_VTT_ON: length 137
  TOP w0.254: v2(235.03,27.1) 248.75,27.1 249.42,27.76 252.8,27.76 254.61,29.57 260.26,29.57 263.17,32.47 264.6,32.47 264.84,32.23 269.07,32.23 270.32,33.47 275.95,33.47 278.55,36.08 278.55,62.29 v2(280.71,64.44) ; v2(196.23,12.23) v3(197.09,12.23) 197.64,12.78 199.24,12.78 PR210.1
  BOTTOM w0.254: v2(235.03,27.1) 231.25,23.32 215.36,23.32 207.1,15.06 201.93,15.06 199.1,12.23 v2(196.23,12.23) ; v2(280.71,64.44) 280.71,65.08 281.93,66.3 281.93,67.38 280.55,68.75 280.55,71.15 281.36,71.96 RD17.2 282.54,72.43 283.07,72.43 283.28,72.22 UD1.4
1.2V_SUS_PWRGD: length 2.2
  TOP w0.203: PU200.10 201.7,10.73 200.42,9.45 PR205.2
3.3V_CAM_EN#: length 10.8
  TOP w0.109: RH736.2 165.55,33.94 RZ545.1 165.85,33.63 v1(166.55,33.63) 166.91,33.63 167.27,33.99 169.84,33.99 170.32,34.48 171.35,34.48 171.58,34.71 172.41,34.71 172.61,34.92 173.35,34.92 173.42,34.84 173.84,34.84 174.16,34.52 174.39,34.52 174.65,34.79 UH1.BE18
3.3V_RUN_GFX_ON: length 165.9
  TOP w0.102: UE1.K9 v2(136.75,21.63)
  TOP w0.109: v2(167.57,52.05) 167.24,52.37 v1(167.24,52.7) 167.24,55.09 185.5,73.35 185.5,75.65 v2(185.89,76.05) ; v2(90.85,9.15) 91.13,9.15 91.46,8.83 91.46,8.19 91.37,8.1 QZ20.2 91.37,6.58 RZ547.1
  TOP w0.254: v2(180.96,88.05) 181.14,88.05 181.54,87.65 RZ548.1
  IN2 w0.081: v2(155.6,30.71) 155.19,31.12 152.75,31.12 152.33,30.69 146.74,30.69 144.75,28.71 142.67,28.71 141.95,27.98 141.83,27.98 141.82,27.99 v2(141.75,27.99)
  IN3 w0.081: v2(90.85,9.15) 91.6,9.15 92.01,9.56 92.52,9.56 95.85,12.88 110.18,12.88 111.68,11.39 118.6,11.39 119.01,11.8 124.43,11.8 125.54,10.69 128.22,10.69 129.18,11.66 131.53,11.66 131.66,11.78 134.86,11.78 135.21,11.43 136.46,11.43 137.12,12.1 137.12,12.74 137.78,13.4 137.78,17.11 136.87,18.02 136.87,19.03 137.25,19.41 137.25,20.14 136.95,20.45 136.56,20.45 136.36,20.64 136.36,21.25 v2(136.75,21.63)
  IN4 w0.254: v2(185.89,76.05) 185.37,76.57 185.37,79.83 183.68,81.52 183.68,82.15 183.25,82.58 182.7,82.58 181.66,83.63 181.66,87.79 181.4,88.05 v2(180.96,88.05)
  BOTTOM w0.102: v2(136.75,21.63) 137.15,22.03 137.15,23.46 137.62,23.93 138.04,23.93 138.72,24.62 138.72,25.76 139.83,26.87 139.83,27.46 140.11,27.74 140.56,27.74
  BOTTOM w0.109: v2(155.6,30.71) 154.81,31.51 154.81,34.77 159.99,39.96 159.99,43.25 164.06,47.32 165.11,47.32 167.63,49.85 167.63,51.64 167.57,51.7 v2(167.57,52.05) ; 140.56,27.74 140.75,27.54 141.31,27.54 v2(141.75,27.99)
  BOTTOM w0.203: UZ41.5 181.24,87.92 181.11,88.05 v2(180.96,88.05)
3.3V_TS_EN: length 86.7
  TOP w0.109: UE1.J7 v2(134.33,23.25) ; RV323.1 79.81,30.91 v2(80.07,30.91)
  IN2 w0.081: v2(124,26.92) 124.26,26.92 125.26,27.93 125.26,28.45 126.2,29.39 128.03,29.39 128.17,29.54 128.17,30.44 127.77,30.84 126.03,30.84 125.32,31.55 125.32,33.72 125.55,33.95 126.02,33.95 126.23,33.75 126.23,33.56 126.55,33.25 126.64,33.25 126.79,33.11 127.36,33.11 127.98,33.73 129.33,33.73 130.1,34.5 134.61,34.5 134.87,34.76 v2(134.87,34.96) ; v2(100.01,32.08) 100.01,31.87 102.94,28.94 108.32,28.94 109.71,27.55 v2(111.5,27.55)
  IN3 w0.081: v2(111.5,27.55) 112.17,28.23 121.58,28.23 122.88,26.92 v2(124,26.92)
  IN4 w0.102: v2(100.01,32.08) 91.54,32.08 90.54,31.08 82.93,31.08 82.5,31.51 80.67,31.51 v2(80.07,30.91)
  BOTTOM w0.102: 134.74,25.42 134.74,25.8 134.44,26.09 134.14,26.09 133.92,26.31 133.92,28.29 133.76,28.45 133.14,28.45 133.01,28.58 133.01,29.38 133.54,29.91 133.54,31.2 134.06,31.72
  BOTTOM w0.109: v2(134.33,23.25) 134.7,23.62 134.7,25.38 134.74,25.42 ; v2(134.87,34.96) 135,35.09 135.23,35.09 RE547.1 135.16,34.51 135.16,32.82 v1(134.59,32.25) 134.06,31.72
3.3V_TS_EN_R: length 6
  TOP w0.109: RV323.2 78.39,30.42 RV326.2 77.54,30.76 76.88,31.42 v1(76.81,31.42) 76.43,31.04 76.43,30.51 RV324.2 77.03,29.91 77.03,29.11 76.46,28.54 QV7.2
3.3V_WWAN_EN: length 295.6
  TOP w0.102: UE1.C6 v2(133.53,28.05)
  TOP w0.109: v2(333.84,8.32) 333.67,8.49 333.67,9.49 334.23,10.05 334.23,10.21 334.09,10.36 334.09,11.73 333.16,12.65 333.16,14.84 332.62,15.38 332.62,15.6 332.29,15.93 331.18,15.93 330.53,16.58 330.53,16.84 R129.1 329.36,18.11 330.05,18.11 330.53,18.6 330.53,19.37 v2(330.95,19.79) ; UZ44.5 326.39,21.93 326.48,21.84 v2(326.48,21.31) ; v1(209.35,5.86) 209.22,5.73 v2(209.22,4.74)
  IN2 w0.081: v2(333.84,8.32) 333.53,8.63 333.53,8.69 333.45,8.77 329.36,8.77 328.92,8.33 327.38,8.33 326.02,6.97 326.02,5.25 322.97,2.2 314.12,2.2 313.07,3.25 310.47,3.25 309.89,2.68 300.88,2.68 299.13,4.43 294.8,4.43 294.34,4.89 291.48,4.89 290.1,3.51 286.81,3.51 284.36,5.97 283.49,5.97 283.24,5.72 283.24,4.91 282.56,4.23 276.51,4.23 274.51,6.23 274.51,7.78 273.12,9.16 271.18,9.16 269.89,10.45 269.35,10.45 268.99,10.81 267.72,10.81 265.74,12.78 265.74,14.09 264.76,15.07 260.93,15.07 260.12,14.27 251.38,14.27 251.04,13.94 239.39,13.94 238.79,14.53 225.72,14.53 225.1,13.91 220.55,13.91 219.73,13.1 213.21,13.1 211.53,11.42 211.53,10.15 212.11,9.56 212.11,7.81 211.96,7.66 211.51,7.66 211.08,7.23 210.63,7.23 210.29,6.89 210.29,5.81 v2(209.22,4.74)
  IN3 w0.081: v2(326.48,21.31) 326.48,20.64 326.83,20.28 330.46,20.28 v2(330.95,19.79)
  IN4 w0.102: v2(133.53,28.05) 133.53,28.26 132.95,28.85 131.73,28.85 131.28,28.4 131.11,28.4 129.32,26.62 128.07,26.62 126.95,25.49 126.95,24.05 126.54,23.64 124.98,23.64 124.36,23.02 124.36,20.43 123.66,19.74 122.78,19.74 122.19,19.15 120.4,19.15 120.19,18.94 120.19,18.51 121.69,17.01 121.69,15.66 126.29,11.06 129.17,11.06 130.21,10.02 134.53,10.02 134.72,9.84 140.5,9.84 141.7,11.04 145.53,11.04 147.16,12.67 147.16,12.97 147.92,13.73 147.92,15.44 148.33,15.86 151.74,15.86 153.41,14.18 154.22,14.18 154.82,13.59 155.73,13.59 156.6,12.72 158.28,12.72 159.01,12 159.53,12 160.07,11.46 160.07,10.63 161.67,9.04 165.31,9.04 165.87,8.48 171.66,8.48 174.96,5.18 177.86,5.18 178.42,4.62 179.2,4.62 179.94,3.88 182.52,3.88 183.38,4.74 194.29,4.74 194.6,4.43 205.7,4.43 205.94,4.18 208.66,4.18 v2(209.22,4.74)
3V_FB: length 1.5
  TOP w0.254: PC112.1 112.49,10.12 PU100.13
+0.6V_DDR_VTT: length 26.7
  TOP w0.305: 210.37,34.54 210.37,35.41 209.18,36.61 JDIMM2.258
  BOTTOM w0.109: 201.5,40.12 201.01,40.61 200.14,40.61 199.66,40.12 v3(199.66,39.91)
  BOTTOM w0.254: JDIMM3.258 209.18,60.86 209.49,61.17 CD93.1
  BOTTOM w0.381: CD93.1 CD30.1
  BOTTOM w0.508: 204.62,50.55 204.66,50.6 204.66,60.53 208.23,64.09 CD30.1
  vias: v2(202.29,39.37) v2(206.34,51.54) v2(206.34,50.91) v2(206.34,50.27)
+0.6V_P:
  vias: v1(205.95,14.94)
+0.9V_LAN: length 14.6
  TOP w0.381: CL10.1 188.81,131.37 v2(188.75,131.43) ; v2(191.33,131.68) 191.1,131.45 191.1,130.67 191.09,130.67 CL4.1 ; v2(185.92,128.12) 185.97,128.18 187.06,128.18 CL9.1 ; CL11.1 187.06,129.39 186.12,129.39 v2(185.94,129.57)
  BOTTOM w0.203: UL1.8 185.94,128.14 v2(185.92,128.12) ; UL1.43 189.55,123.65 v2(189.36,123.46) ; UL1.16 v2(188.75,131.43) ; v2(192.88,124.03) 192.14,124.03 191.95,124.23 UL1.37 ; v2(191.33,131.68) 191.15,131.5 UL1.22 ; v2(191.18,122.91) 190.75,123.34 UL1.40 ; UL1.11 186.17,129.34 v2(185.94,129.57)
  BOTTOM w0.508: CL3.1 184.99,123.13 v2(184.99,122.51)
  vias: v2(180.69,127.41) v2(181.28,127.41) v2(188.36,123.47) v3(180.08,127.37)
+0.9V_TBT_LC: length 2
  TOP w0.109: v1(29.47,41.46) 29.36,41.35 v2(29.36,40.89) 30.01,40.24 CT333.1
  BOTTOM w0.109: UT1.J8 v2(29.36,40.89)
+0.9V_TBT_LVR_OUT: length 0.9
  BOTTOM w0.203: UT1.H6 29.03,41.21 v2(28.71,40.89) 29.03,40.57 UT1.H8
  vias: v3(27.97,41.83)
+0.9V_TBT_PCIE: length 2.8
  BOTTOM w0.254: UT1.J18 v2(30.01,35.69) ; UT1.L18 v2(30.66,35.69) UT1.L19 ; UT1.M19 v2(30.66,35.04) ; UT1.M18 31.3,36.33 v2(31.3,36.35) UT1.M16
  vias: v2(36.3,32.68) v3(33.21,32.76)
+0.9V_TBT_SVR: length 22.6
  TOP w0.254: CT319.2 29.19,37.16 v2(29.36,36.99) ; CT316.2 v2(30.01,38.94) ; CT306.1 v2(32.61,36.34) ; CT305.1 31.29,37.64 v2(31.96,37.64) ; CT308.1 v2(31.96,38.94) ; v2(30.66,37.64) CT307.1 ; CT309.1 v2(32.61,39.59) ; CT322.2 v2(30.01,38.29)
  TOP w0.305: CT317.2 30.64,39.61 v2(30.66,39.59) ; CT311.1 CT318.2 27.51,40.14 v2(27.41,40.24)
  TOP w0.33: CT321.2 33.32,38.37 v2(33.25,38.3) ; v2(29.36,38.29) 29.29,38.36 CT320.2
  TOP w0.381: v2(31.31,40.89) 31.31,40.77 31.57,40.5 CT310.1
  BOTTOM w0.203: UT1.J13 v2(30.01,38.29) UT1.L13 ; UT1.L11 v2(30.01,38.94) ; UT1.H11 v2(28.71,39.59) UT1.H9 ; UT1.N8 v2(31.96,40.89) UT1.R8 ; UT1.M13 v2(30.66,37.64) ; UT1.R16 v2(32.61,36.34) UT1.T16 ; UT1.T15 UT1.T13 32.93,37.98 v2(33.25,38.3) UT1.T12 ; UT1.N6 v2(31.31,40.89) UT1.M8 ; UT1.R13 v2(31.96,37.64) UT1.N13 ; UT1.H15 v2(29.36,36.99) UT1.H16 ; UT1.H12 v2(29.36,38.29) UT1.H13 ; UT1.T11 v2(32.61,39.59) UT1.T9 UT1.T8 ; UT1.E8 v2(27.41,40.24) ; UT1.M11 v2(30.66,39.59) ; UT1.R11 v2(31.96,38.94) ; UT1.N11 v2(31.31,38.94)
  vias: v2(19.09,53.53) v2(19.07,52.94) v2(19.79,53.51) v2(19.78,52.91) v2(20.53,53.5) v2(20.52,52.9) v2(21.91,44.28) v2(22.37,43.88) v2(22.85,43.51) v2(26.49,52.63) v2(26.49,52.04) v2(27.08,52.63) v2(27.08,52.04) v2(27.66,52.63) v2(27.66,52.04) v3(26.68,50.91)
+1.0V_ALW_PCH: length 16.8
  IN2 w0.254: v2(186.15,18.51) 185.22,19.44 184.84,19.44 183.66,20.61 178.62,20.61 178.21,20.2 176,20.2 175.55,20.66 173.36,20.66 173.17,20.85 v2(171.86,20.85)
  BOTTOM w0.254: v2(171.86,20.85) 171.85,20.85 171.38,20.38 RH255.1
  vias: v2(194.63,12.25) v2(195.1,12.75) v2(196.08,15.37) v2(196.71,15.37) v2(198.19,49.81) v2(198.19,49.18) v2(201.22,19.84) v2(201.87,19.84) v3(195.33,12.16)
+1.0V_AMPHYPLL: length 1.6
  TOP w0.109: 197.64,16.35 v1(197.64,14.71)
+1.0V_AZPLL: length 7.1
  TOP w0.254: v2(196.45,44.94) 194.91,43.4 UH1.D1 UH1.E1
  BOTTOM w0.109: v1(196.62,48.32) 197.04,47.9 RH241.2
  BOTTOM w0.508: v2(196.45,44.94) 196.98,44.94 CH32.1 CH46.1 197.16,46.51 197.04,46.62 RH241.2
+1.0V_BCLKPLL2: length 1
  TOP w0.109: RH259.2 199.39,50.7 199.39,51.62 v1(199.42,51.65)
+1.0V_BCLKPLL2_R: length 0.6
  TOP w0.109: 197.89,48.06 v1(197.89,48.66)
+1.0V_CLPLLEBB: length 0.6
  TOP w0.254: v2(186.82,28.68) 187.2,28.3 UH1.W31
  vias: v3(191.19,20.38)
+1.0V_DSW: length 7.4
  TOP w0.254: UH1.BG45 UH1.BG46
  TOP w0.356: 171.53,20.34 171.33,20.54 170.03,20.54 169.9,20.41 CH35.1 169.4,19.75 v2(169.44,19.72)
  TOP w0.381: 171.53,20.34 172.48,20.34 173.08,20.94 UH1.BG46
  BOTTOM w0.109: v1(169.01,19.16) 169.01,19.22 169.44,19.64 v2(169.44,19.72)
  BOTTOM w0.254: v2(169.44,19.72) 169.92,20.21 RH255.2
+1.0V_DUSB: length 1.1
  TOP w0.254: UH1.W22 187.3,32.95 v2(187.63,32.62) 187.27,32.27 UH1.W23
  vias: v1(193.42,34.95)
+1.0V_MPHY: length 8.1
  TOP w0.203: UH1.V30 188.05,28.98 v2(188.34,28.69) 188.05,28.4 UH1.V31 187.96,28.3 v2(187.57,28.69) 187.96,29.08 UH1.V30 ; UH1.V30 UH1.U29 UH1.V28 ; UH1.V30 187.69,29.43 v2(187.69,29.49) UH1.V28 ; UH1.U26 188.32,31.08 UH1.V25 188.05,31.34 v2(187.69,30.98) UH1.V27 ; v2(187.63,30.28) 187.63,30.21 187.99,29.85 UH1.V28
  TOP w0.254: v2(187.63,30.28) 187.7,30.28 UH1.V27 188.33,30.35 v2(188.33,30.24)
  vias: v2(197.15,24.22) v2(197.65,24.56) v2(197.67,23.95) v2(198.24,24.56) v2(198.28,23.96) v2(198.92,23.96) v3(196.61,26.55)
+1.0V_OC: length 0.5
  TOP w0.254: v2(187.66,34.11) UH1.V19
  vias: v1(192.57,36.61)
+1.0V_OCPLL1: length 1.2
  BOTTOM w0.109: 198.63,43.34 199.54,43.34 v1(199.75,43.55)
+1.0V_OCPLL1_R: length 3.4
  TOP w0.254: v2(196.76,44.12) 196.24,44.12 195.41,43.3 UH1.C1 UH1.C2
  BOTTOM w0.109: LC3.2 198.72,44.73 v1(199.05,45.06)
+1.0V_PRIM_CNV_HVLO: length 0.8
  TOP w0.254: v2(183.69,35.7) 183.96,35.44 UH1.AE17
  vias: v1(183.02,43.76)
+1.0V_PRIM_FUSE: length 0.5
  TOP w0.203: UH1.AD31 v2(185.34,28.69)
  vias: v3(185.61,21.89)
+1.0V_PRIM_XDP: length 31.6
  TOP w0.254: v2(276.47,92.4) 276.54,92.32 RC115.2 277.95,92.32 CC29.1 CC28.1 279.75,91.5 280.4,92.15 JXDP1.44 282.6,92.15 282.9,91.85 JXDP1.43 ; v2(267.36,103.41) RC216.2 266.84,104.37 266.11,105.11 RC138.1
  BOTTOM w0.254: v2(276.47,92.4) 275.88,92.4 274.49,93.79 272.91,94.47 271.86,94.47 269.99,96.33 269.03,96.33 268.3,97.06 268.3,99.47 268.11,99.67 266.37,99.67 v1(265.75,100.29) 265.55,100.48 265.55,101.87 265.72,102.04 265.72,102.16 266.97,103.41 v2(267.36,103.41)
+1.0V_SRC: length 2.2
  TOP w0.203: UH1.W20 v2(186.89,34.11) UH1.W19
  BOTTOM w0.109: RH258.2 186.07,45.57 v1(186.32,45.83)
+1.0V_VCCSFR: length 31.6
  TOP w0.381: v2(188.97,86.85) 189.3,86.85 189.47,87.02 RC304.2
  IN3 w1.016: 196.49,84 196.49,84.44 199.5,87.46 204.97,87.46 206.38,88.87 206.38,93.46 207.85,94.92 207.85,106.15
  BOTTOM w0.109: v2(196.14,82.93) v3(195.54,82.93)
  vias: v2(196.7,83.13) v2(207.77,107.45) v2(208.19,107.01)
+1.0V_VCCSFR_R: length 15.3
  IN3 w0.254: 221.83,109.28 222.05,109.28 ; 222.05,109.28 222.43,109.28 222.53,109.38 223.6,109.38 224.24,108.74 224.24,108.27 224.14,108.27 223.78,108.63 223.22,108.63 222.96,108.37 222.5,108.37 222.05,108.83 222.05,109.28
  IN3 w0.508: 224.24,108.27 v2(224.24,107.18)
  IN3 w1.016: 221.83,109.28 221.7,109.41 219.02,109.41 218.49,108.89 217.32,108.89 216.63,109.58 215.93,109.58 215.33,110.18 214.68,110.18
  vias: v2(213.23,110.23) v2(213.82,110.01) v2(224.54,106.65) v3(212.26,110.23)
+1.0V_VCCST: length 362
  TOP w0.203: UC1.H30 223.09,109.29 v2(222.49,109.89)
  TOP w0.254: v2(186.99,72.86) 186.99,71.83 182.9,67.74 181.38,67.74 176.85,63.21 176.85,58.94 172.8,54.89 171.98,54.89 161.57,44.47 161.57,41.92 163.27,40.23 v2(163.27,40.15)
  TOP w0.381: v2(266.71,106.5) 266.33,106.5 RC79.1 ; v2(159.66,25.81) 159.66,24.74 159.37,24.45 RE90.2
  TOP w0.508: v2(262.78,118.14) 262.78,118.69 v2(260.77,120.7) ; RZ151.2 268.65,110.09 v2(269.04,109.7) ; RC166.1 v2(282.49,100.87)
  IN1 w0.508: v2(211.13,109.35) 207.62,109.35 205.98,107.71 205.98,105.35 205.23,104.6 v2(205.23,103.94) ; v2(182.88,93.15) 182.88,92.52 184.7,90.71 187.59,90.71 188.05,91.16 v2(188.63,91.16)
  IN2 w0.254: v2(186.99,72.86) 188.19,74.06 188.19,76.6 189.13,77.54 189.13,85.41 v2(188.95,85.59)
  IN2 w0.508: v2(277.02,91.82) 280.73,91.82 281.67,92.77 281.67,96.72 283.44,98.48 283.44,100.22 282.79,100.87 v2(282.49,100.87) ; v2(260.77,120.7) 262.65,118.82 269.73,118.82 272.47,121.56 272.47,140.5 266.58,146.39 266.58,148.22 265.09,149.71 v2(264.3,149.71) ; v2(266.71,106.5) 266.71,106.59 267.53,107.4 267.8,107.4 269.29,108.89 269.29,109.44 v2(269.04,109.7) ; v2(209.92,113.25) 211.13,112.04 v2(211.13,109.35)
  IN3 w0.508: v2(264.3,149.71) 264.3,150.13 264.06,150.37 260.93,150.37 260.58,150.72 243.96,150.72 241.59,148.35 234.58,148.35 225.51,139.28 222.47,139.28 217.01,133.82 209.53,133.82 205.88,130.17 205.88,124.6 209.41,121.07 209.41,119.8 212.26,116.95 212.26,115.7 210.99,114.43 210.99,114.33 v2(209.92,113.25) ; v2(205.23,103.94) 205.23,100.3 198.48,93.55 198.48,91.83 v2(196.81,90.16) ; v2(262.78,118.14) 262.78,117.35 269.04,111.09 v2(269.04,109.7) 270.27,109.7 270.76,110.19 278.07,110.19 283.93,104.33 283.93,101.14 283.66,100.87 v2(282.49,100.87)
  IN4 w0.254: v2(143.9,25.2) 145.07,25.2 146.99,27.13 152.5,27.13 153.65,28.28 157.78,28.28 158.87,27.19 158.87,26.37 159.43,25.81 v2(159.66,25.81)
  IN4 w0.381: v2(188.96,86.19) 188.61,86.19 188.36,86.44 188.36,87.43 187.72,88.07 187.72,90.83 188.05,91.16 v2(188.63,91.16) 188.63,92.39 189.51,93.27 193.32,93.27 194.69,91.91 194.69,91.65 195.05,91.28 195.7,91.28 v2(196.81,90.16)
  BOTTOM w0.254: v2(163.27,40.15) 162.96,39.84 162.96,36.86 161.65,35.55 160.75,35.55 159.25,34.05 159.25,32.68 v3(158.97,32.4) 158.9,32.33 158.9,26.57 v2(159.66,25.81)
  BOTTOM w0.381: RC71.1 196.62,90.35 v2(196.81,90.16) ; v2(209.92,113.25) 209.43,113.73 CC569.1 200.18,115.84 RC80.1 ; RC152.1 260.95,120.52 v2(260.77,120.7)
  BOTTOM w0.508: RC218.1 277.25,92.05 v2(277.02,91.82) ; v2(143.9,25.2) 143.64,25.2 142.92,24.48 RE59.1 ; RC157.1 v2(262.78,118.14)
+1.0V_VCCST_C: length 2.4
  TOP w0.109: v3(193.44,84.69) 192.46,85.67 192.46,86.66
+1.0V_VCCSTG: length 222.6
  TOP w0.254: UC1.H29 223.09,108.39 223.33,108.14 v2(223.54,108.14)
  TOP w0.508: v2(267.96,109.7) 267.96,110.18 RZ151.1 ; v2(180.4,50.11) 180.45,50.16 RH315.2 ; v2(183.83,62.73) 182.16,61.07 182.16,56.73 183.19,55.7 v2(183.19,54.52) ; RC135.2 266.47,103.99 266.61,103.85 v2(266.62,103.85) ; RC83.1 268.17,108.46 v2(267.93,108.69)
  IN2 w0.254: v2(267.96,109.7) 267.96,108.71 v2(267.93,108.69) 267.92,108.69 265.6,106.37 265.6,105.69 266.62,104.67 v2(266.62,103.85) ; v2(223.54,108.14) 223.62,108.07 223.62,105.01 222.8,104.2 217.73,104.2 212.67,99.13 v2(201.22,99.13)
  IN2 w0.508: v2(180.4,50.11) 180.4,50.82 181.17,51.59 182.12,51.59 183.19,52.67 v2(183.19,54.52)
  IN3 w0.254: v2(223.54,108.14) 223.33,107.93 222.26,107.93 221.61,108.58 219.26,108.58 218.63,107.94 217.91,107.94 217.37,107.4 217.37,107.02 217.07,106.73 216.71,106.73 216.28,106.3 216.28,94.68 217.17,93.78 217.17,92.28 215.37,90.48 215.37,85.96 224.36,76.97 259.63,76.97 267.74,85.08 267.74,89.39 264.83,92.3 264.83,94.4 v2(264.2,95.04)
  IN3 w0.508: v2(183.83,62.73) 182.66,63.9 182.66,67.62 188.71,73.68 188.71,77.31 192.92,81.52 192.92,86.62 192.23,87.32 192.23,97.65 v2(192.41,97.83)
  IN4 w0.508: v2(192.41,97.83) 194.43,99.85 200.76,99.85 201.22,99.4 v2(201.22,99.13)
  BOTTOM w0.102: v3(184.6,63.5) v2(183.83,62.73)
  BOTTOM w0.254: v2(266.62,103.85) 265.25,102.49 265.25,102.11 264.96,101.82 263.87,101.82 263.15,101.1 263.15,99.95 263.23,99.86 263.23,97.93 263.06,97.76 263.06,95.65 263.67,95.04 v2(264.2,95.04)
  BOTTOM w0.305: CC195.2 223.64,106.76 CC186.2 223.65,108.03 v2(223.54,108.14)
  BOTTOM w0.508: v2(183.19,54.52) 183.19,54.01 RH314.2 ; v2(180.4,50.11) 180.4,49.77 RH312.2
+1.0V_VCCSTG_C: length 1.3
  TOP w0.109: 192.66,96.23 v1(194.01,96.23)
+1.0V_XTAL: length 24
  TOP w0.109: v1(195,53.61) v2(195,54.16)
  TOP w0.152: UH1.P3 189.88,42.11 UH1.P2
  TOP w0.254: v2(188.98,44.11) 189.12,44.11 189.62,43.61 189.62,42.76
  TOP w0.508: v2(195,54.16) 195,54.2 195.34,54.53 195.34,54.87 CH45.2
  IN2 w0.254: v2(195,54.16) 194.96,54.16 194.85,54.27 188.75,54.27 188.13,53.65 188.13,48.78 188.7,48.21 188.7,47.73 189.81,46.63 189.81,44.87 189.46,44.52 189.46,44.47 189.11,44.11 v2(188.98,44.11)
  BOTTOM w0.508: LH421.2 194.11,53.31 194.96,54.16 v2(195,54.16)
+1.0VS_VCCIO: length 219.6
  TOP w0.203: UC1.AG12 237.33,95.07 v2(237.2,95.1)
  TOP w0.381: QE11.1 157.04,27.39 157.61,27.96 157.61,29.76 157.07,30.3 157.07,32.46 156.03,33.5 156.03,35.24 159.36,38.57 159.36,48.11 163.48,52.23 163.48,55.79 180.85,73.16 180.85,74.43 180,75.28 180,77.37 179.58,77.79 179.58,82.41 v2(178.22,83.76)
  TOP w0.508: RC439.2 264.93,102.85 v2(264.73,102.65) ; v2(207.45,113.13) 207.45,113.47 207.12,113.8 203.1,113.8 201.9,112.6 198.96,112.6 196.59,110.23 196.59,109.55 193.37,106.33 189.05,106.33 185.62,109.76 179.01,109.76 v2(178.79,109.54)
  IN2 w0.508: v2(207.45,113.13) 210.12,110.46 210.12,106.45 203.7,100.03 197.88,100.03 197.58,99.73 197.58,98.96 198.24,98.3 199.86,98.3 200.65,97.5 218.14,97.5 219.37,96.27 222.78,96.27 223.31,96.79 223.31,98.06 222.77,98.6 v2(222.76,98.6)
  IN3 w0.508: 265.57,93.4 265.57,92.63 266.61,91.59 268.14,91.59 270.24,93.69 273.49,93.69 274.32,92.87 275.67,92.87 276.25,93.45 278.1,93.45 278.91,92.65 v2(280.53,92.65) ; 176.91,97.55 176.91,100.54 177.17,100.8 177.17,103.26 179.32,105.41 179.32,109.01 v2(178.79,109.54)
  IN4 w0.381: v2(217.69,88.79) 218.73,89.84 218.73,95.81 219.14,96.22 222.95,96.22 224.3,97.57 v2(224.37,97.57)
  BOTTOM w0.254: RC1.2 206.59,112.27 v2(207.45,113.13)
  BOTTOM w0.508: v2(217.69,88.79) 215.25,86.36 215.25,84.18 216.43,83 221.26,83 RC2.1 ; v2(280.53,92.65) 280.2,92.98 278.83,92.98 278.51,92.66 RC132.1
  vias: v2(222.1,100.2) v2(222.09,98.58) v2(222.7,101.75) v2(222.76,100.99) v2(222.71,100.17) v2(224.39,98.2) v2(225.05,106.37) v2(248.1,96.88) v2(260.12,105.4) v2(262.08,99.38) v2(262.17,108.03) v2(263.43,109.84) v2(263.89,109.45) v2(264.33,109) v2(264.69,108.54) v2(266.68,105.82) v2(267.09,105.17) v2(267.33,106.32) v2(267.33,105.73) v3(264.75,104.42)
+1.0VS_VCCIOP: length 10.6
  TOP w0.109: v3(271.59,109.75) 271.76,109.58 v2(272.5,109.58)
  IN2 w0.254: v2(272.5,109.58) 271.02,109.58 268.73,107.29 v2(268.73,103.14)
  BOTTOM w0.254: PR303.1 v2(268.73,103.14)
  vias: v2(273.09,109.58)
+1.2V_MEM: length 359.1
  TOP w0.203: UC1.AJ12 v2(239.94,94.42) UC1.AL11 ; v2(237.14,90.47) UC1.AF5 ; v2(237.14,90.47) UC1.AF6 ; v2(237.14,90.47) UC1.AG5 ; v2(231.71,94.42) 231.75,94.46 231.88,94.46 UC1.Y12 ; v2(244.67,90.51) 244.35,90.84 UC1.AR6 ; UC1.AY6 v2(247.19,90.5) UC1.AW6
  TOP w0.254: UC1.AR12 244.27,94.96 244.75,94.96 UC1.AT12 244.98,94.69 v2(245.42,94.41) ; v2(254.44,63.36) 255.42,63.36 256.93,61.85 JDIMM4.75 ; v2(224.56,90.51) 224.63,90.51 UC1.L6 ; v2(266.94,48.8) 267.43,48.31 JDIMM2.33 ; v2(237.2,93.12) 237.52,92.8 UC1.AG9 ; v2(223.6,94.46) 223.85,94.71 223.85,94.75 UC1.K12 224.16,94.9 224.71,94.9 UC1.L12 ; v2(229.59,90.51) 229.27,90.84 UC1.T6 UC1.R6 ; UC1.K6 UC1.J6 223.22,90.84 v2(222.88,90.5) 223.2,90.19 UC1.J5 ; v2(244.91,61.3) 244.93,61.29 JDIMM4.123 ; JDIMM4.129 243.43,61.52 ; UC1.AE12 v2(235.39,95.07) ; v2(245.33,49.53) 244.51,49.53 243.18,50.87 JDIMM4.130
  TOP w0.305: UC1.AR6 UC1.AP6 243.14,91.1 UC1.AP7 ; JDIMM2.159 233.93,46.9 234.29,47.26 ; v2(228.27,49.6) 228.79,49.6 229.18,49.98 JDIMM4.178 ; v2(247.04,35.41) 247.27,35.41 247.68,35.81 JDIMM2.112 ; v2(238.92,48.8) 238.92,49.24 240.18,50.49 JDIMM4.142 ; JDIMM4.33 267.43,61.82 267.49,61.89 267.49,62.43 268.19,63.13 v2(271.13,63.13) ; JDIMM2.199 223.93,48.26 224.46,48.8 v2(224.85,48.8) ; 236.71,47.65 236.93,47.44 JDIMM2.147 ; JDIMM4.199 223.93,61.88 224.61,62.56 v2(225.91,62.56) ; v2(244.97,35.68) 244.68,35.98 JDIMM2.124 ; v2(239.88,35.74) 240.18,36.03 JDIMM2.142 ; JDIMM4.241 213.43,61.39 214.41,62.37 v2(215.78,62.37) ; v2(219.05,48.76) 218.67,49.14 218.67,49.62 218.68,49.62 JDIMM4.220 ; JDIMM2.111 247.93,47.09 247.63,47.39 v2(246.9,47.39) 246.43,46.91 JDIMM2.117 ; JDIMM2.241 213.42,45.9 213.42,48.01 213.73,48.32 v2(213.96,48.32) ; 243.43,61.52 v2(243.43,61.53) ; JDIMM2.118 246.18,36.76 246.83,36.1 v2(247.04,36.1) ; JDIMM4.12 272.68,49.89 272.94,49.63 v2(273.22,49.63) ; v2(242.42,50.13) 241.68,50.87 JDIMM4.136 ; JDIMM4.159 233.93,61.32 v2(233.7,61.55) 233.25,61.1 233.25,61.06 232.93,60.73 JDIMM4.163 ; JDIMM2.148 236.68,36.55 v2(237.29,35.94) 237.25,35.9 235.92,35.9 235.18,36.65 JDIMM2.154 ; v2(235.23,61.61) 235.28,61.61 235.43,61.47 JDIMM4.153 ; v2(217.46,35.59) 218.16,35.59 218.68,36.11 JDIMM2.220 ; JDIMM2.130 243.18,36.06 v2(242.8,35.69) ; JDIMM2.96 251.68,35.32 v2(251.07,34.77) ; v2(242.78,48.77) 242.43,48.77 241.19,47.53 240.89,47.53 240.43,47.06 JDIMM2.141 ; v2(245.37,47.71) 244.93,47.27 JDIMM2.123 ; 236.69,50.22 236.68,50.24 JDIMM4.148 ; JDIMM4.96 251.68,50.65 252.45,49.88 v2(252.56,49.88) ; v2(237.29,35.3) 237.3,35.3 237.29,35.29 235.19,35.29 233.68,36.8 JDIMM2.160 ; JDIMM4.112 247.68,50.54 246.97,49.83 246.97,49.54 246.96,49.53 v2(246.96,49.49) ; v2(262.88,48.72) 262.57,48.72 262.18,49.12 JDIMM4.54 ; JDIMM2.178 229.18,36.41 228.96,36.19 228.96,35.32 v2(229.45,34.83) ; v2(257.09,47.42) 256.93,47.26 JDIMM2.75 ; JDIMM2.12 272.68,36.44 272.2,35.97 272.2,35.32 v2(272.74,34.78) ; JDIMM2.54 262.18,36.26 262.55,35.89 262.55,35.46 262.07,34.96 261.89,34.77 v2(261.91,34.77) ; v2(240.18,61.81) 240.18,61.42 240.43,61.17 JDIMM4.141 ; 240.91,61.58 241.59,61.58 241.93,61.24 JDIMM4.135 ; JDIMM4.118 246.18,50.55 245.84,50.21 v2(245.38,50.21) 245.18,50.21 244.68,50.72 JDIMM4.124 ; UC1.W6 231.78,90.84 v2(232.11,90.51) 232.18,90.51 UC1.AA6 ; JDIMM4.147 236.84,59.98 236.84,60.97 236.93,61.05 237,61.05 v2(237.29,61.34) ; JDIMM2.163 232.93,46.79 233.68,47.54 ; JDIMM4.160 233.68,50.45 v2(233.61,50.38) ; 235.58,47.6 235.43,47.45 JDIMM2.153 ; JDIMM2.129 243.43,47.01 243.05,47.39 242.75,47.39 v2(242.75,47.38) 242.74,47.39 242.13,47.39 241.93,47.19 JDIMM2.135 ; v2(247.71,61.58) 247.93,61.37 JDIMM4.111 ; 246.43,61.03 JDIMM4.117 ; v2(241.68,35.49) JDIMM2.136 ; JDIMM4.154 235.18,50.05 v2(234.85,49.72)
  BOTTOM w0.254: v2(246.96,49.49) 247.93,50.46 JDIMM3.111 ; v2(234.87,49.13) 234.95,49.21 236.12,49.21 236.93,50.02 JDIMM3.147 ; v2(238.96,48.19) 239.27,47.89 ; 239.27,47.89 240.97,47.89 241.68,47.18 JDIMM1.136 ; 239.27,47.89 239.27,47.72 240.18,46.82 JDIMM1.142 ; JDIMM1.178 229.18,47.86 228.63,48.41 v2(228.28,48.41) ; v2(257.11,49.05) 257.12,49.05 257.61,49.54 257.61,50.05 256.93,50.74 JDIMM3.75 ; JDIMM1.75 256.93,36.79 257.62,36.09 v2(257.62,35.16) ; JDIMM1.12 272.68,47.78 v2(273.27,48.38) ; v2(237.29,35.94) 236.25,35.94 235.43,36.77 JDIMM1.153 ; JDIMM3.129 243.43,50.51 244.4,49.53 v2(245.33,49.53) 245.82,49.53 246.43,50.14 JDIMM3.117 ; JDIMM3.123 244.93,50.66 v2(245.38,50.21) ; JDIMM1.159 233.93,36.26 v2(233.52,35.86) 232.93,36.45 JDIMM1.163 ; JDIMM1.96 251.68,47.55 251.18,48.05 v2(251.07,48.05) ; JDIMM1.154 235.18,47.63 v2(234.92,47.89) 234.81,47.78 234.44,47.78 233.68,47.02 JDIMM1.160 ; v2(219.05,48.76) 218.59,48.3 218.59,47.88 218.68,47.8 JDIMM1.220 ; v2(234.91,48.51) 236.13,48.51 236.68,47.97 JDIMM1.148 ; v2(242.75,47.38) 242.76,47.38 243.18,46.97 JDIMM1.130
  BOTTOM w0.279: CD74.1 241.68,62.52 JDIMM3.136 ; JDIMM3.124 244.68,60.77 244.39,61.05 244.39,61.55 244.73,61.89 v2(244.92,61.89) ; JDIMM1.54 262.18,47.36 v2(262.85,48.03) ; v2(243.43,61.53) 243.18,61.27 JDIMM3.130 ; JDIMM3.54 262.18,61.93 261.12,62.99 CD106.1 ; v2(235.23,61.61) 235.23,61.49 235.18,61.43 JDIMM3.154 ; JDIMM3.96 251.68,62.19 252.19,62.7 v2(252.54,62.7) ; v2(247.71,61.58) 247.68,61.54 JDIMM3.112 ; CD105.1 272.68,62.55 JDIMM3.12 ; JDIMM3.220 218.68,63.03 218.7,63.05 CD72.1 ; v2(229.36,62.66) 229.2,62.66 228.74,62.2 228.74,61.25 229.18,60.82 JDIMM3.178 ; v2(233.7,61.55) 233.68,61.53 JDIMM3.160 ; JDIMM3.142 v2(240.18,61.81) ; v2(237.29,61.34) 236.68,60.72 JDIMM3.148 ; v2(244.91,61.3) 245.77,61.3 246.18,60.9 JDIMM3.118
  BOTTOM w0.305: JDIMM3.241 213.43,48.54 213.64,48.32 v2(213.96,48.32) ; v2(244.97,35.68) 244.93,35.73 JDIMM1.123 ; v2(266.94,48.8) 267.43,49.28 267.43,49.3 267.45,49.32 267.45,49.74 267.43,49.77 JDIMM3.33 ; JDIMM1.135 241.93,36.56 v2(242.8,35.69) 243.43,36.31 JDIMM1.129 ; JDIMM1.199 223.93,36.34 223.93,36.33 224.48,35.79 224.48,35.36 224.12,35 v2(223.9,35) ; JDIMM3.153 235.43,50.41 235.15,50.13 235.15,50.02 v2(234.85,49.72) ; v2(267.44,34.94) 267.35,35.02 267.24,35.02 266.89,35.37 266.89,35.85 267.43,36.39 JDIMM1.33 ; v2(237.29,35.94) 236.93,36.3 JDIMM1.147 ; v2(245.37,47.71) 245.06,47.71 244.68,47.33 JDIMM1.124 ; v2(238.92,48.8) 239.99,49.88 239.99,50.39 240.43,50.82 JDIMM3.141 ; v2(239.88,35.74) 239.88,36.28 240.43,36.82 JDIMM1.141 ; JDIMM3.135 241.93,50.62 v2(242.42,50.13) ; v2(247.04,35.41) 246.82,35.41 246.43,35.8 JDIMM1.117 ; JDIMM1.112 247.68,46.93 247.22,47.39 v2(246.9,47.39) 246.44,47.39 246.18,47.12 JDIMM1.118 ; v2(224.85,48.8) 224.19,48.8 223.93,49.06 JDIMM3.199 ; JDIMM3.159 233.93,50.7 v2(233.61,50.38) 233.43,50.38 233.43,50.38 232.93,50.88 JDIMM3.163 ; JDIMM1.111 247.93,36.54 247.49,36.1 v2(247.04,36.1) ; JDIMM1.241 213.43,36.42 213.17,36.17 213.17,35.3 v2(213.71,34.76)
  BOTTOM w0.381: v2(263.18,63.29) 263.18,63.3 CD86.1 262.21,63.27 CD106.1 ; CD69.1 229.63,63.89 CD83.1 CD82.1 ; v2(271.13,63.13) 271.41,63.13 271.62,62.92 CD105.1
  BOTTOM w0.508: v2(244.91,62.53) CD119.1 244.85,63.27 CD111.1 CD110.1 ; v2(225.91,62.56) 225.91,63 226.31,63.4 CD70.1 ; CD69.1 230.1,63.4 v2(229.36,62.66) ; v2(277.49,84.09) 276.6,83.19 275.79,83.19 271.95,79.35 RD30.1 CD77.1 ; v2(219.32,61.75) 220.4,61.75 220.98,62.34 CD75.1 ; v2(219.33,62.41) 219.84,62.92 CD80.1 ; CD74.1 240.31,63.14 v2(240.07,62.91) 239.52,62.91 CD84.1 CD96.1 CD79.1 239.35,65.47 239.27,65.55 239.27,66.19 CD71.1 239.6,66.25 239.99,65.86 239.99,65.37 v2(240.16,65.2) ; RD34.1 235.59,61.85 235.35,61.61 v2(235.23,61.61) ; RD4.1 254.39,66.58 255.26,65.71 255.26,64.18 v2(254.44,63.36) 253.78,63.36 CD117.1 252.62,63.38 CD108.1 252.61,62.76 v2(252.54,62.7) ; CD72.1 218.42,63.9 218.07,63.56 v2(218.07,62.56) ; CD104.1 CD107.1 247.6,65.16 CD120.1 CD121.1 247.6,62.32 v2(247.67,62.25)
  vias: v2(181.73,77.31) v2(181.76,76.66) v2(181.75,76.04) v2(183.67,66.97) v2(183.83,67.55) v2(184.31,67.93) v2(184.31,67.18) v2(198.43,63.97) v2(199.12,63.97) v2(199.82,63.98) v2(200.55,64) v2(215.25,33.92) v2(216.38,34.12) v2(223.91,34.3) v2(230.04,33.98) v2(239.83,12.64) v2(239.83,12.01) v2(240.12,11.42) v2(240.68,12.63) v2(240.68,12) v2(240.74,11.35) v2(241.4,12.62) v2(241.4,11.99) v2(241.45,11.35) v2(242.13,12.65) v2(242.13,12.01) v2(242.19,11.37) v2(242.82,11.99) v2(242.87,11.35) v2(243.56,11.98) v2(243.61,11.34) v2(244.26,11.97) v2(244.32,11.32) v2(244.96,34.99) v2(244.98,11.97) v2(245.04,11.33) v2(245.69,11.95) v2(245.75,11.3) v2(246.35,11.95) v2(246.4,11.31) v2(267.44,34.28) v2(267.44,33.54) v2(267.44,32.89) v2(268.94,28.99) v2(268.93,28.3) v2(269.71,30.08) v2(269.71,29.32) v2(269.71,28.68) v2(269.71,28.05) v2(269.71,27.41) v2(270.47,30.71) v2(270.47,30.08) v2(270.49,29.35) v2(270.48,28.69) v2(270.48,27.99) v2(270.41,27.37) v2(271.09,29.38) v2(271.1,28.74) v2(271.1,28.11) v2(271.1,27.41) v2(271.11,31.35) v2(271.11,30.71) v2(271.11,30.08) v2(279.37,46.37) v2(279.39,43.42) v2(279.42,45.65) v2(279.41,44.91) v2(279.41,44.18) v2(283.6,72.99) v2(284.06,72.4) v2(284.24,72.98) v2(284.89,72.96) v2(285.45,72.68) v3(179.11,67.05)
+1.2V_MEN_P: length 62.5
  TOP w0.109: 246.74,8.95 v1(249.01,8.95)
  BOTTOM w0.508: 233.29,9.57 233.29,10.44 232.52,11.21 230.54,11.21 227.85,13.89 210.31,13.89 209.68,14.52 202.18,14.52 v2(201.52,13.85)
  BOTTOM w1.016: 207.57,12.23 227.49,12.23 229.65,10.07 232.25,10.07
  vias: v2(206.12,11.93) v2(206.71,11.95) v2(232.66,8.72) v2(232.66,8.09) v2(233.34,8.72) v2(233.34,8.09)
+1.2V_RUN: length 29.1
  TOP w0.508: LV13.2 147.13,34.79 v2(147.28,34.63)
  IN2 w0.762: v2(80.57,50.88) 80.01,51.44 78.16,51.44 77.38,52.22 73.83,52.22 71.87,50.26 69.61,50.26 67.93,48.58 67.93,48.53 v2(67.85,48.44)
  BOTTOM w0.762: v2(67.85,48.44) 67.85,42.83 66.66,41.65 66.66,39.18 v2(66.54,39.06) 63.46,39.06 LV6.2
  vias: v2(62.79,30.09) v2(62.79,29.49) v2(73.51,27.8) v2(74.11,27.78) v2(138.28,47.93) v2(138.75,47.56) v2(139.52,36.02) v2(140.1,36.2) v2(150.32,35.86) v2(161.64,47.92) v2(162.07,48.39) v2(177.75,68.55) v2(178.15,69) v2(178.6,69.42) v2(179.06,69.87) v3(147.13,35.54)
+1.2V_RUN_PWR: length 1.2
  BOTTOM w0.109: 181.75,68.9 v1(183,68.9)
+1.05V_PRIM: length 130.3
  TOP w0.203: 185.72,29.13 185.72,29.13 v2(185.37,29.49) ; 185.72,29.13 v2(186.11,29.51) 185.76,29.85 UH1.AB28 ; 185.72,29.13 UH1.AB30 ; v2(185.35,30.29) 185.72,29.91 UH1.AB28 ; v2(185.35,30.29) 185.39,30.29 UH1.AB27 186.05,30.3 v2(186.11,30.3) 186.11,30.23 UH1.AB28 ; v2(185.35,30.29) 185.35,30.25 UH1.AD28 ; v2(185.35,30.29) 185.28,30.29 UH1.AD27 ; UH1.AB28 v2(185.37,29.49) ; v2(183.78,29.5) 184.18,29.1 ; 184.18,29.1 UH1.AF30 ; 184.18,29.1 184.18,29.16 v2(184.52,29.51) ; v2(183.81,30.99) UH1.AF27 184.23,30.63 184.54,30.94 v2(184.54,30.96) 184.61,30.96 UH1.AD27 ; v2(185.34,32.56) UH1.AD23 184.87,32.17 v2(184.51,32.54) 184.18,32.2 UH1.AF23 v2(183.79,32.56) ; v2(185.34,32.56) UH1.AB23 v2(186.11,31.79) UH1.AA23 v2(186.11,32.56) ; v2(185.34,32.56) UH1.AB22 v2(186.11,32.56) ; v2(184.52,29.51) 184.86,29.85 UH1.AD28 ; v2(184.52,29.51) UH1.AD30 v2(185.37,29.49) ; v2(186.11,32.56) UH1.AA22 ; UH1.AD27 185.31,30.99 v2(185.36,30.99) ; UH1.AD28 185.06,29.85 185.37,29.55 v2(185.37,29.49)
  TOP w0.254: v2(185.34,33.34) UH1.AD20
  TOP w0.305: UH1.AB20 v2(185.34,34.11)
  TOP w0.508: v2(207.26,91.21) 207.26,87.97 217.3,77.94 257.27,77.94 263.85,84.51 263.85,92.7 264.94,93.79 264.94,95.99 268.82,99.87 268.82,101.55 269.36,102.09 269.36,103.77 RC216.1
  IN2 w0.081: v2(90.72,10.24) 87.93,13.03 v2(87.93,13.03)
  BOTTOM w0.508: v2(192.85,91.05) v3(193.84,91.05) 194.89,91.05 196.6,89.35 198.36,89.35 200.9,86.81 204.6,86.81 207.26,89.47 v2(207.26,91.21)
  vias: v2(5.3,20.26) v2(7.16,19.23) v2(7.77,19.23) v2(7.97,18.64) v2(37.62,8.22) v2(38.2,8.22) v2(38.79,8.22) v2(39.37,8.22) v2(159.94,14.3) v2(160.52,14.3) v2(161.11,14.3) v2(161.69,14.3) v2(162.28,14.32) v2(162.26,13.7) v2(162.36,13.12) v2(162.74,12.59) v2(162.86,14.32) v2(162.9,13.72) v2(162.95,13.13) v2(163.34,12.59) v2(163.5,13.73) v2(163.54,13.15) v2(190.58,60.55) v2(191.49,60.56) v2(192.13,60.58) v2(192.84,90.43) v2(192.84,89.83) v2(195.45,17.87) v2(195.43,17.23) v2(196.1,17.23) v2(196.12,17.87) v2(196.85,17.83) v2(196.83,17.19)
+1.05V_PRIMP: length 4
  TOP w0.109: 163.54,9.43 v3(164.86,9.43)
  TOP w0.254: 159.42,12.4 158.85,12.4 157.47,13.77 PR809.1
+1.05V_VDD: length 1.6
  BOTTOM w0.203: UR1.16 18.53,14.22 18.23,13.91 18.23,13.76 17.87,13.4 17.82,13.4
  vias: v2(6.45,26.45) v2(6.44,25.86) v2(7,26.22) v2(8.74,23.22) v2(9.35,23.21) v2(9.76,22.79) v2(14.41,12.18) v2(14.41,11.36) v2(15.2,12.18) v2(15.2,11.36) v2(19.71,7.26) v2(19.72,6.66) v2(22.24,21.27) v2(22.24,20.67) v2(22.4,21.87) v2(22.42,7.73) v2(22.44,7.12) v2(24.97,7.92) v2(24.97,7.33) v2(33.93,17.75) v2(33.93,17.12) v2(34.52,17.74) v2(34.52,17.1) v3(14.61,12.97)
+1.8V_ALW_PCHRES: length 14.5
  IN4 w0.508: v2(166.27,35.39) 166.27,35.01 166.5,34.77 167.07,34.77 167.55,35.26 167.55,37.22 168.65,38.32 169.31,38.32 v2(169.65,38.66)
  BOTTOM w0.381: v2(173.28,26.86) 173.28,26.59 172.96,26.28 RH294.2
  BOTTOM w0.508: RH250.2 177.32,31.34 v2(177.38,31.39) 177.86,31.87 178.78,31.87 RH296.1 ; v2(166.27,35.39) 166.27,35.11 v3(166.56,34.82) 166.78,34.6 RH295.1 ; v2(169.65,38.66) 169.8,38.51 RH247.2
+1.8V_ALW_VTR3: length 10.7
  TOP w0.254: UE1.N5 133.13,19.21 133.01,19.09 v2(133.01,19) 133.01,17.49 CE21.1
  TOP w0.381: v2(126.19,19.23) 126.38,19.42 RE549.1
  IN2 w0.254: v2(133.01,19) 131.09,19 130.85,19.23 130.3,19.23 130,18.93 126.49,18.93 v2(126.19,19.23)
  vias: v2(128.13,14.57) v2(128.77,14.58) v3(129.61,14.72)
+1.8V_PHVLDO: length 1
  TOP w0.254: UH1.AF19 184.5,34.17 v2(184.5,34.1) 184.18,33.78 UH1.AF20
  vias: v3(178.06,34.52)
+1.8V_PRIM: length 110
  TOP w0.254: UZ61.5 194.53,90.64 194.08,90.2 194.08,88.34 CZ544.1 194.55,88.09 195,87.64 v2(195,87.42) 195.53,86.89 RZ543.2
  IN1 w0.508: v2(174.74,46.21) 174.73,46.22 173.92,46.22 172.44,44.73 172.44,43.15 170.2,40.91 170.2,39.51 170.54,39.18 170.81,39.18 171.34,38.66 v2(171.35,38.66)
  IN2 w1.016: 233.54,26.24 250.03,26.24 ; 268.39,26.17 258.13,26.17
  BOTTOM w0.254: UZ45.1 331.33,26.3 v2(331.12,26.08) ; UZ45.2 331.14,26.8 v2(331.04,26.7)
  BOTTOM w0.356: RH614.1 172.32,48.14 173.4,48.14 173.64,47.9 RH604.1 ; RH607.1 176.65,45.44 176.25,45.84 ; 172.6,46.13 RH605.2
  BOTTOM w0.381: RH605.2 171.99,46.74 RH613.1 172.11,47.05 172.7,47.63 173.55,47.63 RH604.1 ; RH614.1 172.13,48.59 172.44,48.91 173.14,48.91 173.67,49.45 173.67,50.26 174.36,50.94 174.89,50.94 176.72,52.77 176.72,53.52 177.31,54.11 177.31,61.61 179.76,64.06 182.94,64.06 185.78,66.9 185.78,72.84 v3(187.14,74.2) 187.73,74.79 187.73,77.57 194.83,84.67 196.98,84.67 197.4,85.09 197.4,86.8 196.83,87.37 195.07,87.37 195.04,87.41 195.01,87.41 v2(195,87.42)
  BOTTOM w0.508: 174.74,46.18 174.69,46.13 172.6,46.13 ; 174.74,46.18 v2(174.74,46.21) ; 174.74,46.18 175.91,46.18 176.25,45.84
  vias: v2(128.1,6.91) v2(132.22,12.42) v2(132.84,12.42) v2(136.17,18.91) v2(138.17,4.13) v2(138.16,3.46) v2(170.86,25.25) v2(214.9,21.26) v2(215.5,21.25) v2(287.25,21.45) v2(287.25,20.83)
+1.8V_PRIM_PCH: length 180.6
  TOP w0.254: UH1.AG20 183.42,33.72 v2(183.77,34.07) 183.4,34.44 UH1.AG19 ; UH1.AN15 v2(180.08,36.32) UH1.AR15 ; UH1.BB11 v2(176.15,38.76)
  TOP w0.508: v2(260.33,28) 259.3,26.97 256.52,26.97 255.5,25.95 252.6,25.95 v2(251.64,26.91) ; v2(336.42,6.06) 336.23,5.88 336.23,3.04 336.5,2.78 RZ378.1
  IN3 w0.254: v2(260.33,28) 260.33,19.82 264.53,15.61 268.39,15.61 269.69,14.32 276.1,14.32 281.64,8.78 286.9,8.78 287.05,8.63 295.77,8.63 296.57,9.43 299.24,9.43 300.25,8.41 306.07,8.41 308.17,6.31 312.35,6.31 312.93,6.88 313.74,6.88 314.33,6.29 v2(314.35,6.29)
  IN3 w0.508: v2(251.64,26.91) 251.64,26.21 245.53,20.11 219.83,20.11 219.83,20.11 209.45,20.11 204.55,25 199.99,25 197.71,27.28 197.71,31.93 195.63,34.01 195.48,34.01
  IN4 w0.508: v2(334.6,8.27) 334.63,8.31 334.63,9.23 333.93,9.94 325.35,9.94 321.82,6.41 318.07,6.41 317.96,6.29 v2(314.35,6.29)
  BOTTOM w0.508: RZ376.1 336.84,7.01 336.32,7.01 ; v2(334.6,8.27) 334.6,8.2 335.04,7.75 335.57,7.75 336.32,7.01 ; v2(336.42,6.06) 336.32,6.17 336.32,7.01
  vias: v3(179.24,36.26)
+1.8V_PRIMP: length 17.8
  TOP w0.254: PR904.1 127.36,8.19 PC904.1 127.37,8.57 127.74,8.93 128.64,8.93 128.83,8.75 131.03,8.75 131.45,9.16 133.04,9.16 133.3,8.91 133.3,8.44 133.45,8.28 134.05,8.28 134.39,8.63 134.77,8.63 134.98,8.42 134.98,8.21 135.3,7.89 138.62,7.89 139.31,7.2 139.31,6.33 v3(139.13,6.15) 138.58,5.6 137.77,5.6
+1.8V_RUN: length 2.6
  TOP w0.381: CA66.1 347.11,14.84 RA201.1 348.34,14.71 v2(348.34,14.13) CA65.1
  vias: v3(341.16,23.72)
+1.8V_RUN_AUDIO: length 7.1
  TOP w0.203: CA57.1 346.28,18.76 346.03,19 346.03,19.64 345.96,19.71 UA1.20
  TOP w0.381: CA57.1 346.28,18.02 CA58.1 346.97,17.68 347.46,17.19 v2(347.46,16.75) 347.46,16.57 347.79,16.24 RA201.2
  BOTTOM w0.109: v3(347.14,17.51) 347.46,17.19 v2(347.46,16.75)
  BOTTOM w0.381: CA69.1 347.2,16.5 v2(347.46,16.75)
+1.8V_RUN_PWR: length 1
  BOTTOM w0.109: v1(332.89,25.02) 333.14,24.78 333.82,24.78
+1.24V_DPHY: length 4.3
  TOP w0.254: UH1.AJ23 182.62,32.17 v2(182.24,32.55) 182.63,32.93 UH1.AJ22
  BOTTOM w0.109: v1(181.8,29.81) 181.53,30.09 RH237.1
  BOTTOM w0.381: v2(182.24,32.55) 182.16,32.55 181.67,32.06 181.67,30.98 RH237.1
+1.24V_DPHY_MAR: length 8.7
  TOP w0.203: 172.6,42.26 173.49,41.36 UH1.BG5
  TOP w0.3: 172.6,42.26 172.6,43.74 171.97,44.37 170.94,44.37 170.78,44.2 T75.1 169.56,44.2 169.42,44.34 CH30.1 168.46,44.81 168.46,45.52 CH559.1
+1.24V_LDOSRAM: length 3.6
  TOP w0.254: UH1.AK23 181.73,32.17 181.35,32.56 v2(181.27,32.56) 181.66,32.95 UH1.AK22
  BOTTOM w0.254: v2(181.27,32.56) 181.27,32.34 T287.1 180.44,31.51 180.44,31 RH237.2
+2.5V_MEM: length 1
  BOTTOM w0.109: v2(288.9,56.58) v3(289.94,56.58)
  vias: v2(207.52,54.46) v2(207.77,35.86) v2(207.85,53.95) v2(208.16,36.3) v2(208.18,35.44) v2(208.61,35.85) v2(287.43,56.58) v2(287.43,55.87) v2(288.16,56.59) v2(288.17,55.9) v2(288.9,55.88)
+2.5V_MEMP: length 14.3
  TOP w0.109: 286.03,54.04 289.51,54.04 v3(289.65,54.18)
  TOP w0.254: PR404.1 PC402.1 281.14,46.48 279.8,47.82 279.8,50.56 282.08,52.84 283.28,52.84
+2.8V_FHV0: length 0.5
  TOP w0.203: UH1.AF31 184.18,28.38 v2(184.48,28.68)
  vias: v3(184.94,26.06)
+2.8V_FHV1: length 0.5
  TOP w0.203: UH1.AG31 v2(183.79,28.69)
  vias: v3(184.3,24.12)
+3.3V_1.8V_AZIO: length 2.3
  BOTTOM w0.109: 171.77,34.3 v2(171.77,34.3) ; 171.77,34.3 171.77,34.3 171.79,34.32 171.79,34.65 v1(171.59,34.85) ; 171.77,34.3 171.77,34.28
  BOTTOM w0.381: v2(168.79,37.59) LC1.1 168.1,38.06 168.22,38.18 CC329.1
+3.3V_1.8V_AZIO_R: length 16.4
  TOP w0.254: UH1.BB14 v2(176.15,37.57)
  BOTTOM w0.254: v1(165.91,38.61) 165.91,38.64 166.23,38.97 166.87,38.97 167.17,39.27 CC327.1 168.33,40.41 169.6,40.41 170.08,39.94 170.08,39.6 170.54,39.14 171.65,39.14 172.02,38.76 172.46,38.76 172.86,39.17 173.42,39.17 173.97,38.62 175.3,38.62 176.15,37.76 v2(176.15,37.57)
  BOTTOM w0.356: 167.35,37.15 167.35,36.88 CC310.1
  BOTTOM w0.381: 167.35,37.15 LC1.2 166.44,37.59 165.91,38.12 v1(165.91,38.61)
+3.3V_1.8V_GPPA: length 15.4
  TOP w0.254: UH1.AN32 v2(180.56,27.59)
  IN2 w0.508: v2(172.15,25.24) 172.15,24.75 171.8,24.39 168.89,24.39 168.49,24.78 166.74,24.78 v2(166.56,24.6)
  BOTTOM w0.381: RH95.2 161.81,23.61 RH340.2 162.54,23.61 162.6,23.55 163.67,23.55 164.46,24.34 164.83,24.34 165.09,24.6 v2(166.56,24.6) v1(167.24,25.28) 167.5,25.54 RH327.2
+3.3V_1.8V_GPPD: length 3.5
  TOP w0.254: UH1.AN24 v2(180.65,32.52)
  BOTTOM w0.109: v1(181.02,33.27) 181.02,32.95 180.65,32.58 v2(180.65,32.52)
  BOTTOM w0.25: v2(180.65,32.52) 179.96,31.83 RH296.2
  BOTTOM w0.254: RH293.2 179.73,30.95 RH296.2
+3.3V_1.8V_SPI: length 21.4
  TOP w0.254: UH1.AN44 180.31,22.1 v2(180.17,22.24)
  IN4 w0.381: v2(175.14,31.48) 174.31,31.48 173.87,31.03 173.87,29.91 174.8,28.98 176.54,28.98 177.09,29.53 178.27,29.53 178.52,29.28 178.52,29.16 178.52,29.15 178.52,28.7 178.52,28.7 178.52,28.54 178.32,28.34 178.32,27.45 178.67,27.09 179.14,27.09 179.46,26.78 179.46,26.34 179.73,26.07 179.73,25.34 179.56,25.17 179.56,24.73 180.27,24.02 180.27,23.34 180,23.07 180,22.42 v2(180.17,22.24)
  BOTTOM w0.109: v1(180.53,24.27) 180.17,23.91 v2(180.17,22.24)
  BOTTOM w0.381: RH246.2 180.41,22 v2(180.17,22.24) ; v2(175.14,31.48) 175.28,31.34 RH250.1
+3.3V_ALW: length 994
  TOP w0.254: v2(47.93,30.99) 47.78,30.99 47.47,30.69 RT529.1 ; 44.68,28.06 43.79,28.06 43,27.27 43,27.15 v2(42.99,27.13) ; 44.68,28.06 44.95,28.06 45.11,28.22 45.95,28.22 46.12,28.06 46.87,28.06 47.08,28.27 v2(47.08,28.55) ; 44.68,28.06 44.69,28.07 44.69,29.61 45.05,29.96 RT510.2 RT514.2 ; v2(187.76,86.49) 187.59,86.33 RV817.1 ; v2(121.23,18.74) 121.3,18.67 121.3,17.63 121.55,17.38 RZ369.1 ; v2(184.62,86.63) 184.29,86.3 CV810.1 183.84,86.2 UV63.5 ; v2(135.66,12.3) 135.59,12.37 135.59,13.57 135.82,13.8 RZ1482.1 ; UE5.5 163.08,21.87 162.48,22.48 161.91,22.48 161.53,22.85 CE52.1 ; JUSH1.12 181.6,4.12 181.53,4.19 v2(181.53,4.67) ; v2(57.6,37.64) 57.58,37.66 57.58,37.98 57.23,38.33 56.05,38.33 55.87,38.16 55.87,38.09 55.24,37.46 v2(55.24,35.66) 54.39,35.66 54.04,35.31 v2(54.04,34.75) ; PR41.1 PR40.2 47.63,18.67 v2(47.5,18.55) ; v2(14.37,6.31) 14.36,6.29 JAPS1.3 ; UZ35.5 195.25,93.13 v2(195.11,92.99) ; CT237.1 39.91,50.01 39.91,49.92 v2(39.91,49.47) UT32.5 ; JUSH1.11 181.1,4.43 v2(180.95,4.58) ; JLED1.6 315.31,9.74 315.5,9.55 316.31,9.55 316.89,10.14 v2(316.89,11.17) ; RE35.2 RE748.2 139.84,16.26 139.57,15.99 v2(139.23,15.99) 139.23,16.21 138.61,16.83 RE25.1 ; v2(290.93,13.4) 290.93,13.25 291.16,13.02 JKBTP1.6 ; v2(16.18,6.27) 16.36,6.1 JAPS1.7 ; v2(355.42,29.96) 354.92,30.46 349.62,30.46 348.91,31.17 347.82,31.17 v2(347.58,31.41) ; PR205.1 199.36,9.45 199.18,9.28 197.04,9.28 196.05,10.26 ; UT34.5 121.87,14.56 CT389.1 121.91,14.88 121.76,15.03 121.06,15.03 120.26,15.83 118.79,15.83 118.48,16.13 RE68.2 ; v2(280.97,79.63) 280.7,79.35 280.7,78.76 280.41,78.46 278.32,78.46 277.95,78.84 277.95,79.87 278.27,80.19 CZ200.1 278.63,80.19 279.03,80.59 279.8,80.59 280.14,80.93 UZ34.5 ; RE8.2 142.2,21.07 141.79,21.07 141.5,20.78 v2(140.78,20.78) ; v2(340.01,3.53) 340.04,3.57 RZ377.1 ; RT515.2 56.92,25.99 56.11,26.8 v2(56.03,26.8) 55.81,26.8 55.48,27.13 55.48,28.17 RT511.2 ; v2(182.23,4.54) 182.23,4.05 182.1,3.93 JUSH1.13
  TOP w0.305: JIO1.76 46.55,2.71 v2(46.32,2.94) 46.05,2.67 JIO1.78
  TOP w0.381: RE68.2 117.85,16.55 v2(117.84,16.54) CZ57.1 CZ58.1 ; 123.52,4.56 123.66,4.56 124.51,5.41 PR900.1 ; v2(130.69,16.33) 130.84,16.49 RE561.2 ; UE3.5 156.68,17.82 CE53.1 156.65,17.32 v2(156.73,17.25) ; v2(163.44,24.1) 163.26,23.92 162.53,23.92 CE52.1 ; UE4.5 157.23,22.38 CE61.1 157.14,23.14 v2(156.88,23.4) ; v2(314.11,44.12) 313.99,44.01 CZ93.1 314.26,43.48 314.29,43.46 UZ10.5
  TOP w0.457: RE732.2 141,15.41 v2(141.69,15.41) ; RE69.1 155.54,26.84 155.36,26.66 v2(155.36,26.08)
  TOP w0.508: RE63.2 145.3,26.97 v2(145.45,26.82) ; v2(142.95,29.44) 143.04,29.53 RE365.2 ; PR107.1 116.74,8.99 v2(116.74,8.61) ; PR800.2 152.96,9.97 v2(152.61,10.33) ; RE83.2 143.18,25.49 143.68,25.98 143.86,25.98 143.88,26.01 v2(143.88,26.02) 143.91,25.99 144.03,25.99 144.25,26.21 144.58,26.21 RE79.1 ; RE37.2 RE43.2 129.69,16.33 v2(130.69,16.33) ; RE732.2 140.92,15.34 RE733.2 ; PR62.1 261.47,10.35 v2(260.9,9.77) ; RE735.2 141.7,13.07 v2(141.68,13.06) 141.33,13.06 141.13,13.26 RE734.2 ; QH7.3 124.68,9.65 124.31,9.27 124.31,8.43 122.9,7.03 122.26,7.03 121.96,7.34 v2(121.96,7.79) 122.43,8.27 RH432.1 121.6,8.6 RH431.2
  TOP w1.016: 109.58,24.74 110.36,24.74 112.74,27.12 112.74,29.12
  IN1 w0.254: v2(290.93,13.4) 290.93,12.96 291.26,12.63 293.87,12.63 295.57,14.33 298.56,14.33 300.17,12.72 309.49,12.72 310.2,13.43 310.96,13.43 311.63,12.76 311.95,12.76 312.84,11.87 316.2,11.87 v2(316.89,11.17) ; v2(128.43,22.52) 127.05,21.13 127.05,21.02 127.02,20.99 v2(126.32,20.99) ; v2(35.14,46.61) 38.52,46.61 39.91,48 v2(39.91,49.47)
  IN1 w0.381: v2(184.62,86.63) 184.76,86.49 v2(187.76,86.49) ; v2(185.84,91.72) 186.9,92.78 193.28,92.78 193.5,92.99 v2(195.11,92.99)
  IN1 w0.508: v2(63.68,3.87) 64.05,3.5 64.93,3.5 65.8,4.37 67.31,4.37 69.75,6.82 70.9,7.4 73.24,7.4 75.66,4.98 78.01,4.98 79.96,3.03 82.46,3.03 83.31,3.88 86.53,3.88 88.25,5.6 v2(93.4,5.6)
  IN2 w0.254: v2(125.96,32.12) 125.96,31.68 126.28,31.36 129.38,31.36 130.05,30.69 v2(130.06,30.69) ; v2(316.89,11.17) 316.89,11.95 317.39,12.45 317.39,13.52 318.09,14.22 318.09,16.64 320.76,19.32 322.55,19.32 323.33,18.53 328.56,18.53 329.24,19.21 329.24,19.77 330.57,21.11 330.57,21.75 330.83,22.01 331.26,22.01 331.95,22.69 332.52,22.69 v2(333.15,23.33) ; v2(163.44,24.1) 163.42,24.07 162.16,24.07 161.3,23.21 159.93,23.21 159.43,23.71 158.65,23.71 158.15,23.2 157.08,23.2 v2(156.88,23.4)
  IN2 w0.508: v2(211.44,93.01) 205.2,86.77 200.3,86.77 198.97,88.1 198.97,90.25 196.71,92.51 196.13,92.51 195.65,92.99 v2(195.11,92.99) ; v2(288.36,75.56) 286.69,77.23 280.54,77.23 278.96,78.82 278.96,79.7 279.43,80.17 280.09,80.17 280.63,79.63 v2(280.97,79.63) ; v2(63.99,4.47) 63.94,4.47 62.48,5.94 59.55,5.94 59.08,6.41 53.95,6.41 53.09,7.26 v2(53.09,7.54) 50.21,4.65 v2(50.21,2.81) 49.41,2.01 46.79,2.01 46.32,2.48 v2(46.32,2.94) 46.32,3.62 43.7,6.24 42.47,6.24 41.13,7.58 36.41,7.58 36.01,7.18 30.57,7.18 29.45,8.3 27.09,8.3 26.41,7.62 26.41,7.03 22.1,2.71 17.8,2.71 16.18,4.34 v2(16.18,6.27) 14.4,6.27 v2(14.37,6.31) 13.42,7.26 v2(10.61,7.26) 10.6,7.27 v2(9.02,7.27) 8.23,7.27 7.18,8.32 7.18,9.07 v2(6.54,9.71) 6.54,10.2 7.38,11.04 7.38,13.09 6.65,13.82 5.1,13.82 v2(4.28,14.63) 7.83,14.63 8.85,15.66 v2(8.85,15.98) 8.85,17.41 v2(9.69,18.25)
  IN3 w0.254: v2(122.09,26.01) 121.93,26.17 117.7,26.17 117.18,26.69 113.68,26.69 111.96,24.97 110.33,24.97 109.45,24.09 v2(109.45,23.8) ; v2(333.15,23.33) 333.15,23.15 333.59,22.71 334.86,22.71 336.26,24.11 339.1,24.11 340.7,22.51 340.7,12.82 337.28,9.39 336.99,9.39 336.2,8.6 336.2,7.34 v2(340.01,3.53) ; v2(59.6,30.85) 59.84,30.85 60.84,31.85 60.84,32.69 59.19,34.34 58.31,34.34 57.89,33.91 55.37,33.91 54.54,34.75 v2(54.04,34.75) ; v2(117.84,16.54) 120.36,16.54 121.23,17.41 v2(121.23,18.74) ; v2(47.5,18.55) 47.5,18.91 42.48,23.93 42.48,24.4 42.85,24.77 42.85,25.59 42.54,25.9 42.54,26.69 v2(42.99,27.13)
  IN3 w0.381: v2(184.62,86.63) 185.17,87.18 185.17,88.49 185.84,89.16 v2(185.84,91.72)
  IN3 w0.508: v2(4.28,14.63) 4.28,19.18 4.5,19.4 4.5,26.04 5.88,27.42 7.23,27.42 8.07,26.59 10.49,26.59 10.84,26.24 12.28,26.24 13.16,27.12 15.37,27.12 17.05,28.8 17.05,30.12 15.74,31.42 15.74,32.16 13.3,34.6 13.3,37.65 18.23,42.58 18.23,43.95 19.78,45.5 24.53,45.5 24.69,45.66 25.3,45.66 27.37,43.6 31.06,43.6 34.07,46.61 v2(35.14,46.61) ; v2(258.22,23.96) 258.22,17.57 262.16,13.63 262.16,10.39 261.54,9.77 v2(260.9,9.77) 256.84,13.83 231.78,13.83 229.24,11.28 216.35,11.28 v2(215.85,10.77) ; 276.45,87.5 276.45,85.05 276.85,84.64 276.85,83.28 273.51,79.94 269.31,79.94 264.56,75.19 222.28,75.19 211.44,86.04 v2(211.44,93.01)
  IN4 w0.254: v2(320.18,43.21) 319.62,42.65 317.34,42.65 316.78,43.21 315.02,43.21 v2(314.11,44.12) ; v2(56.03,26.8) 56.11,26.8 56.86,26.05 58.08,26.05 58.38,26.36 58.38,26.84 57.13,28.1 57,28.1 ; v2(47.08,28.55) 47.08,29.1 47.47,29.49 47.47,30.54 v2(47.93,30.99) 49.56,29.36 51.54,29.36 52.8,28.1 57,28.1 ; 57,28.1 57.49,28.59 57.49,29.45 57.97,29.92 58.65,29.92 59.57,30.85 v2(59.6,30.85) ; v2(126.32,20.99) 126.67,20.64 126.67,18.95 126.27,18.55 126.27,18.43 126.26,18.43 126.26,18.03 126.27,18.02 126.27,17.43 127.65,16.05 128.77,16.05
  IN4 w0.508: v2(67.28,8.38) 66.84,8.38 66.05,7.6 66.05,6.78 63.99,4.72 v2(63.99,4.47) ; v2(53.09,7.54) 53.09,12.89 53.22,13.01 53.22,15.51 52.04,16.68 47.97,16.68 47.61,17.04 47.61,18.43 v2(47.5,18.55) ; v2(314.11,44.12) 314.11,43.89 313.72,43.5 312.82,43.5 312.09,44.23 306.02,44.23 304.48,42.69 290.35,42.69 289.73,42.07 289.12,42.07 287.69,43.5 283.4,43.5 279.18,39.28 279.18,26.81 277.81,25.45 270.95,25.45 270.14,24.63 258.89,24.63 v2(258.22,23.96)
  BOTTOM w0.254: QT3.1 42.28,26.43 v2(42.99,27.13) ; RC241.1 v2(278.53,88.5) ; RT518.2 54.98,35.93 v2(55.24,35.66) ; v2(50.21,2.81) 50.21,2.25 50.7,1.76 RE740.1 RE739.1 51.13,2.65 RE71.1 50.3,3.54 49.76,4.08 RE72.1 ; RE11.2 127.94,33.12 126.32,33.12 125.96,32.76 125.96,32.13 ; v2(59.6,30.85) 59.84,31.1 RT512.2 ; RE302.2 130.86,29.92 RE303.2 ; v2(142.95,29.44) 142.96,29.45 RE91.2 ; v2(141.04,32.98) 140,31.95 139.34,31.95 138.84,31.44 RE21.2 ; v2(135.66,12.3) 135.61,12.35 135.61,12.92 RZ9.1 ; RT528.1 57.23,37.27 v2(57.6,37.64) 57.6,38.48 57.69,38.56 RT516.2 ; v2(53.09,7.54) 52.97,7.42 RE75.1 ; CZ91.1 290.93,12.82 v2(290.93,13.4) ; UE12.24 v2(8.85,15.98) ; RE505.2 122.83,33.73 v2(122.86,33.69) ; 125.96,32.13 v2(125.96,32.12) ; 125.96,32.13 125.16,32.92 125.16,33.8 125.59,34.22 RE362.2 ; v2(320.18,43.21) 320.26,43.14 320.26,39.69 319.83,39.27 319.83,38.58 320.69,37.72 322.09,37.72 322.47,38.1 332.93,38.1 334.4,36.63 346.48,36.63 347.76,35.35 347.76,34.08 349.64,32.2 350.21,32.2 351.51,30.9 352.48,30.9 352.67,30.71 354.67,30.71 v2(355.42,29.96) ; v2(333.15,23.33) 333.15,24.05 331.77,25.44 330.33,25.44 330.05,25.72 330.05,29.23 336.6,35.78 343.03,35.78 344.78,34.03 344.78,33.15 345.72,32.21 346.78,32.21 v2(347.58,31.41) ; v2(340.01,3.53) 340.01,2.14 339.5,1.63 337.33,1.63 RZ381.1 ; CE340.1 7.2,10 7.95,10.75 UE12.14
  BOTTOM w0.356: v2(9.69,18.25) 9.87,18.08 CE341.1 9.82,17.58 RE565.1
  BOTTOM w0.381: RE731.2 136.64,37.52 135.95,36.83 v2(135.95,35.92) ; 155.61,18.59 155.61,20.86 155.34,21.13 155.34,22.72 155.92,23.3 156.77,23.3 v2(156.88,23.4) 156.88,24.13 155.36,25.65 v2(155.36,26.08) ; 155.61,18.59 156.73,17.48 v2(156.73,17.25) ; 155.61,18.59 155.58,18.56 v2(154.12,18.56) ; PR60.1 PR59.2 52,19.41 51.69,19.11 49.89,19.11 48.98,18.19 47.85,18.19 v2(47.5,18.55) ; RE730.2 138.31,37.52 138.71,37.12 138.71,34.76 138.01,34.06 138.01,32.24 RE21.2 ; RE700.2 128.39,22.47 v2(128.43,22.52) 129.01,22.52 RE12.2 ; RE343.1 v2(122.09,26.01)
  BOTTOM w0.508: PR110.1 67.4,9.01 67.28,8.88 v2(67.28,8.38) ; v2(126.32,20.99) 126.32,20.41 126.56,20.17 RE701.2 ; RE526.1 142.28,26.24 RE10.2 142.83,25.5 143.35,26.02 v2(143.88,26.02) ; v2(6.54,9.71) CE340.1 ; v2(130.06,30.69) 130.33,30.43 RE303.2 ; v2(314.11,44.12) 314.11,46.58 301.4,59.29 300.31,59.29 v3(297.56,62.04) 290.98,68.62 v3(290.98,70.32) 290.98,72.94 v3(289.67,74.26) v2(288.36,75.56) ; v2(4.28,14.63) RE564.1 ; v2(9.02,7.27) 8.74,7.55 RE563.2 ; RE300.1 v2(140.78,20.78) ; v2(141.68,13.06) 139.89,13.06 139.79,12.95 RZ8.1 ; RE566.1 v2(10.61,7.26)
  vias: v2(88.7,24.85) v2(88.88,29.02) v2(89.19,28.5) v2(89.22,25.16) v2(89.22,24.45) v2(89.49,29.02) v2(89.73,24.85) v2(89.8,28.5) v2(90.41,28.5) v2(97.08,8.4) v2(97.06,7.78) v2(97.73,8.4) v2(97.7,7.79) v2(98.35,8.4) v2(98.33,7.79) v2(98.68,9.03) v2(98.77,9.65) v2(98.8,10.26) v2(98.93,23.13) v2(98.94,22.54) v2(98.96,21.94) v2(98.95,8.38) v2(98.92,7.76) v2(99.08,21.36) v2(99.37,9.65) v2(99.39,9.01) v2(99.47,22.86) v2(99.4,10.26) v2(99.59,21.72) v2(99.56,8.36) v2(99.53,7.75) v2(99.67,22.31) v2(99.99,23.12) v2(100.01,21.18) v2(100.15,21.95) v2(100.25,22.57) v2(100.53,21.47) v2(100.63,23.04) v2(100.72,22.2) v2(107.61,23.83) v2(108.26,23.82) v2(108.87,23.8) v2(119.75,10.01) v2(121.67,3.38) v2(122.28,3.38) v2(129,13.5) v2(129.6,13.53) v2(135.34,35.92) v2(142.31,15.41) v2(145.25,13.1) v2(145.38,21.31) v2(145.82,21.78) v2(145.9,13.09) v2(195.46,11.07) v2(196.2,11.06)
