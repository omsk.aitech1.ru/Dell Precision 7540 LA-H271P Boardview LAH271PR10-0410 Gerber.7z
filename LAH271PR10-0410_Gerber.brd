# Allegro board LAH271PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_CS#2: length 71.3
  TOP w0.076: UC1.AD2 234.66,87.83 234.66,82.7 v2(236.68,80.69)
  IN2 w0.127: v2(236.68,80.69) 236.71,80.66 236.71,73.02 236.54,72.86 236.31,72.86 236.15,73.02 236.15,79.64 236,79.79 235.76,79.79 235.59,79.62 235.59,63.88 235.75,63.72 236.58,63.72 236.73,63.57 236.73,63.32 236.58,63.16 235.73,63.16 235.59,63.02 235.59,61.86 238.49,58.96 238.49,46.83 v2(235.71,44.05)
  BOTTOM w0.168: v2(235.71,44.05) 235.28,43.62 235.28,39.82 235.78,39.32 236.08,39.32 236.43,38.98 JDIMM1.149
DDR_A_CS#3: length 70.3
  TOP w0.076: UC1.AE5 235.81,89.97 236.33,89.45 236.33,88.15 236.41,88.06 236.41,87.27 236.33,87.19 236.33,86.86 236.69,86.5 v2(236.69,86.41)
  IN4 w0.076: 233.54,79.3 234.46,80.22 234.46,80.43 235.52,81.5 235.52,83.56 236.05,84.09 236.05,84.86 236.49,85.3 236.85,85.3 237.14,85.58 237.14,85.96 v2(236.69,86.41)
  IN4 w0.152: 233.54,79.3 232.78,78.55 232.78,77.17 224.12,68.5 224.12,65.48 225.01,64.59 225.01,60.26 226.42,58.84 226.42,57.67 226.01,57.27 226.01,54.24 226.84,53.42 226.84,52.32 229.01,50.14 229.01,47.08 231.18,44.91 231.18,38.24 231.34,38.09 232.15,38.09 232.3,37.94 232.3,37.68 232.15,37.53 231.34,37.53 231.18,37.38 231.18,37.2 v2(233.03,35.36)
  BOTTOM w0.168: v2(233.03,35.36) v1(233.69,35.36) 234.43,36.09 JDIMM1.157
DDR_A_D0: length 76.9
  TOP w0.076: UC1.BR6 258.56,90.72 259.41,90.72 259.57,90.88 260.01,90.88 v2(260.51,90.38)
  TOP w0.152: v2(274.74,42.99) 274.82,42.91 274.82,39.67 273.68,38.53 JDIMM2.8
  IN4 w0.14: v2(260.51,90.38) 261.63,90.38 262.2,89.81 265.36,89.81 277.58,77.59 277.58,74.43 277.78,74.23 278.41,74.23 278.53,74.11 278.53,73.85 278.37,73.68 277.78,73.68 277.64,73.54 277.64,73.28 277.76,73.15 278.37,73.15 278.51,73.01 278.51,72.74 278.37,72.6 277.79,72.6 277.64,72.45 277.64,72.19 278.66,71.17 278.66,64.97 280.02,63.61 280.02,49.04 275.3,44.32 275.3,43.55 v2(274.74,42.99)
  BOTTOM w0.152: v2(274.74,42.99) 274.91,42.82 274.91,39.54 273.93,38.55 JDIMM1.7
DDR_A_D1: length 76.6
  TOP w0.076: UC1.BT6 259.2,91.22 260.42,91.22 261.24,90.39 261.24,90.23 261.84,89.64 v2(261.84,89.07)
  TOP w0.152: v2(275.34,40.63) 275.31,40.59 275.24,40.59 275.13,40.7 275.13,44.65 274.93,44.86 JDIMM2.3
  IN4 w0.14: v2(261.84,89.07) 264.94,89.07 276.78,77.23 276.78,66.86 276.92,66.72 277.57,66.72 277.71,66.58 277.71,66.31 277.57,66.18 276.92,66.18 276.78,66.04 276.78,65.43 279.28,62.93 279.28,49.55 274.28,44.55 274.28,42.84 275.23,41.89 275.23,40.74 v2(275.34,40.63)
  BOTTOM w0.152: v2(275.34,40.63) 275.32,40.65 275.32,44.45 274.68,45.09 JDIMM1.4
DDR_A_D2: length 71.4
  TOP w0.076: UC1.BP3 258.09,89.29 258.64,89.29 258.72,89.21 259.48,89.21 259.6,89.08 259.93,89.08 260.23,88.79 v2(260.23,88.25)
  TOP w0.152: v2(270.6,44.59) 270.43,44.76 JDIMM2.21
  IN4 w0.076: v2(260.23,88.25) 260.22,88.24 260.22,87.68 261.87,86.02 262.19,86.02
  IN4 w0.14: v2(270.6,44.59) 270.6,44.76 272.79,46.95 272.79,49.89 273.31,50.41 273.31,50.77 273.17,50.91 272.56,50.91 272.42,51.05 272.42,51.32 272.56,51.46 273.17,51.46 273.31,51.6 273.31,51.86 273.17,52 272.56,52 272.42,52.14 272.42,52.41 272.56,52.55 273.17,52.55 273.21,52.59 273.21,58.62 274.12,59.54 274.12,60.21 273.98,60.35 273.79,60.35 273.65,60.49 273.65,60.75 273.79,60.89 273.98,60.89 274.12,61.03 274.12,69.12 273.98,69.26 273.5,69.26 273.37,69.4 273.37,69.67 273.5,69.81 273.98,69.81 274.12,69.94 274.12,70.21 273.98,70.35 273.53,70.35 273.39,70.49 273.39,70.76 273.53,70.9 273.98,70.9 274.12,71.04 274.12,75.89 273.99,76.02 273.73,76.02 273.58,75.87 273.58,72.59 273.42,72.44 273.15,72.44 273.03,72.56 273.03,77.07 264.28,85.82 262.4,85.82 262.19,86.02
  BOTTOM w0.152: v2(270.6,44.59) 270.74,44.73 270.74,45 270.68,45.07 JDIMM1.20
DDR_A_D3: length 75.4
  TOP w0.076: v2(260.68,87.8) 260.63,87.85 260.05,87.85 259.4,88.5 258.99,88.5 UC1.BR3
  TOP w0.152: v2(272.23,43) 272.09,43 271.15,42.05 271.15,39.65 270.68,39.18 JDIMM2.20
  IN4 w0.076: v2(260.68,87.8) 260.69,87.8 260.69,87.79 261.41,87.79 261.97,87.24 263.26,87.24
  IN4 w0.14: 263.26,87.24 264.54,87.24 275.25,76.52 275.25,62.68 275.8,62.14 275.8,59.46 275.95,59.3 276.22,59.3 276.34,59.43 276.34,61.36 276.48,61.5 276.75,61.5 276.89,61.36 276.89,58.85 277.57,58.16 277.57,49.99 272.15,44.57 272.15,43.08 v2(272.23,43)
  BOTTOM w0.152: v2(272.23,43) 271.18,41.95 271.18,40.12 270.43,39.36 JDIMM1.21
DDR_A_D4: length 73.2
  TOP w0.076: UC1.BN5 257.53,90.54 257.53,91 257.91,91.38 258.79,91.38
  TOP w0.152: JDIMM2.4 274.68,38.67 v2(275.34,39.33) ; v2(262.65,88.66) 262.65,89.28 260.42,91.51 258.91,91.51 258.79,91.38
  IN4 w0.14: v2(262.65,88.66) 262.69,88.62 264.86,88.62 276.41,77.08 276.41,63.67 276.93,63.16 277.12,63.16 277.73,63.77 277.93,63.77 278.12,63.58 278.12,63.38 277.51,62.77 277.51,62.58 278.7,61.38 278.7,49.49 273.91,44.7 273.91,42.69 274.76,41.84 274.76,39.92 v2(275.34,39.33)
  BOTTOM w0.152: v2(275.34,39.33) 275.16,39.33 274.93,39.1 JDIMM1.3
DDR_A_D5: length 73.4
  TOP w0.076: v2(260.95,89.93) 260.95,90.44 260.35,91.05 259.46,91.05 259.3,90.89 258.93,90.89 258.74,91.07 258.37,91.07 258.18,90.88 UC1.BP6
  TOP w0.152: JDIMM2.7 273.93,44.68 274.4,44.2 v2(274.72,44.2)
  IN4 w0.14: v2(260.95,89.93) 261.65,89.93 262.14,89.44 265.2,89.44 277.2,77.45 277.2,67.64 277.34,67.5 277.6,67.5 277.74,67.64 277.74,70.76 277.88,70.9 278.14,70.9 278.29,70.75 278.29,64.82 279.65,63.46 279.65,49.4 274.72,44.47 v2(274.72,44.2)
  BOTTOM w0.152: JDIMM1.8 273.68,45.08 274.55,44.2 v2(274.72,44.2)
DDR_A_D6: length 76.4
  TOP w0.076: v2(262.05,86.48) 261.72,86.48 261.01,85.76 260,85.76 259.63,86.13 258.88,86.13 257.75,87.26 257.74,87.26 257.54,87.45 257.54,88.14 UC1.BP2
  TOP w0.152: JDIMM2.17 271.43,44.56 272.78,43.2 272.78,40.84 272.24,40.3 v2(272.24,40.3)
  IN4 w0.14: v2(272.24,40.3) 272.11,40.3 271.4,41 271.4,44.92 273.79,47.31 273.79,50.76 273.93,50.9 274.49,50.9 274.64,51.05 274.64,51.32 274.52,51.45 273.93,51.45 273.79,51.59 273.79,51.85 273.93,51.99 274.52,51.99 274.64,52.12 274.64,52.39 274.5,52.53 273.94,52.53 273.79,52.68 273.79,52.89 274.39,53.49 274.39,59.28 274.49,59.38 274.49,76.13 264.14,86.48 v2(262.05,86.48)
  BOTTOM w0.152: v2(272.24,40.3) 272.4,40.3 272.78,40.68 272.78,43.81 271.68,44.92 JDIMM1.16
DDR_A_D7: length 74.6
  TOP w0.076: v2(261.63,86.96) 261.56,86.89 261.01,86.89 260.4,87.5 260.4,87.5 260.38,87.52 259.97,87.52 259.83,87.38 259.41,87.38 258.82,87.96 258.82,88.06 258.82,88.41 258.8,88.44 258.61,88.64 258.5,88.64 UC1.BN3
  TOP w0.152: v2(272.39,41.65) 272.21,41.65 271.73,41.17 271.73,38.88 271.68,38.82 JDIMM2.16
  IN4 w0.076: v2(261.63,86.96) 261.69,86.89 263.09,86.89 263.11,86.87 263.26,86.87
  IN4 w0.14: v2(272.39,41.65) 271.78,42.26 271.78,44.74 274.16,47.13 274.16,48.64 276.5,50.98 276.5,53 276.36,53.14 276.09,53.14 275.95,53 275.95,51.09 275.82,50.95 275.55,50.95 275.4,51.1 275.4,54.59 274.88,55.11 274.88,56.37 275.38,56.86 275.38,58.82 274.86,59.34 274.86,76.34 264.33,86.87 263.26,86.87
  BOTTOM w0.152: JDIMM1.17 271.43,40.69 v2(272.39,41.65)
DDR_A_D8: length 69.6
  TOP w0.076: UC1.BL4 255.85,89.54 v2(255.53,89.21)
  TOP w0.152: v2(270.63,42.75) 270.5,42.75 268.43,44.83 JDIMM2.29
  IN4 w0.076: v2(255.53,89.21) 256.26,88.48 256.8,88.48 257.46,87.82 258.53,87.82 261.35,85.01 261.82,85.01 262.07,84.76 263.52,84.76
  IN4 w0.14: 263.52,84.76 271,77.28 271,67.09 271.15,66.94 271.43,66.94 271.55,67.06 271.55,68.42 271.69,68.56 271.95,68.56 272.09,68.42 272.09,66.23 272.49,65.84 272.49,59.74 271.46,58.71 271.46,53.88 271.11,53.53 271.11,50.35 270.66,49.91 270.66,46.63 269.51,45.48 269.51,43.98 270.19,43.3 270.19,43.2 v2(270.63,42.75)
  BOTTOM w0.152: v2(270.63,42.75) 270.35,42.75 268.68,44.43 JDIMM1.28
DDR_A_D9: length 68.8
  TOP w0.076: UC1.BL5 255.85,90.19 v2(255.53,89.86)
  TOP w0.152: v2(270.62,43.39) 269.43,44.58 JDIMM2.25
  IN4 w0.076: v2(255.53,89.86) 256.14,89.25 256.35,89.2 259.01,87.75 261.41,85.35 261.99,85.35 262.19,85.15 262.24,85.15
  IN4 w0.14: v2(270.62,43.39) 270.02,43.99 270.02,45.31 271.6,46.88 271.6,53.38 272.4,54.18 272.4,59.1 272.87,59.57 272.87,66.02 272.53,66.36 272.53,71.78 272.39,71.92 272.13,71.92 271.99,71.78 271.99,69.52 271.85,69.39 271.58,69.39 271.44,69.52 271.44,77.47 263.76,85.15 262.24,85.15
  BOTTOM w0.152: v2(270.62,43.39) 270.45,43.39 269.68,44.16 JDIMM1.24
DDR_A_D10: length 67.9
  TOP w0.076: v2(257.99,86.11) 257.38,86.11 255.97,87.51 UC1.BL2
  TOP w0.152: v2(266.96,42.36) 266.75,42.36 266.43,42.68 JDIMM2.37
  IN4 w0.076: 262.51,81.72 261.82,82.41 260.79,82.41 257.99,85.21 v2(257.99,86.11)
  IN4 w0.14: 262.51,81.72 267.63,76.59 267.63,70.38 267.77,70.24 268.16,70.24 268.3,70.1 268.3,69.83 268.16,69.69 267.77,69.69 267.63,69.55 267.63,69.28 267.77,69.14 268.16,69.14 268.3,69 268.3,68.74 268.16,68.6 267.77,68.6 267.63,68.46 267.63,68.19 267.77,68.05 268.16,68.05 268.3,67.91 268.3,67.65 268.16,67.51 267.77,67.51 267.63,67.37 267.63,67.1 267.77,66.96 268.16,66.96 268.3,66.82 268.3,59.97 266.63,58.3 266.63,53.29 267.57,52.35 267.57,52 267.43,51.86 266.7,51.86 266.56,51.72 266.56,51.45 266.7,51.31 267.43,51.31 267.57,51.17 267.57,50.91 267.43,50.77 266.7,50.77 266.56,50.63 266.56,50.36 266.7,50.22 267.43,50.22 267.57,50.08 267.57,47.28 266.56,46.27 266.56,42.76 v2(266.96,42.36)
  BOTTOM w0.152: v2(266.96,42.36) 266.41,42.9 266.41,44.73 266.18,44.96 JDIMM1.38
DDR_A_D11: length 68.3
  TOP w0.076: UC1.BM1 256.5,87.59 v2(257.09,87.01)
  TOP w0.152: JDIMM2.41 265.43,44.82 266.11,44.14 266.11,43.19 266,43.07 266,42.06 v2(266.98,41.07)
  IN4 w0.076: v2(257.09,87.01) 257.09,86.31 257.58,85.82 257.58,85.3 260.78,82.1 261.6,82.1 262.25,81.46
  IN4 w0.14: 262.25,81.46 267.25,76.45 267.25,66.5 267.41,66.34 267.79,66.34 267.93,66.2 267.93,65.93 267.79,65.79 267.41,65.79 267.27,65.65 267.27,65.39 267.41,65.25 267.79,65.25 267.93,65.11 267.93,64.84 267.79,64.7 267.41,64.7 267.27,64.56 267.27,64.3 267.41,64.16 267.79,64.16 267.93,64.02 267.93,63.75 267.79,63.61 267.41,63.61 267.27,63.47 267.27,63.2 267.41,63.06 267.79,63.06 267.93,62.92 267.93,61.34 267.79,61.2 267.4,61.2 267.26,61.06 267.26,60.79 267.4,60.66 267.79,60.66 267.93,60.52 267.93,60.13 266.23,58.43 266.23,54.21 266.18,54.16 266.18,41.87 v2(266.98,41.07)
  BOTTOM w0.152: v2(266.98,41.07) 266.17,41.88 266.17,43.91 265.18,44.91 JDIMM1.42
DDR_A_D12: length 70.6
  TOP w0.076: v2(254.74,89.21) UC1.BK4
  TOP w0.152: v2(270.62,41.58) 270.36,41.58 269.97,41.19 269.97,40.33 268.68,39.03 JDIMM2.28
  IN4 w0.076: v2(254.74,89.21) 254.99,89.21 256.29,87.91 256.29,87.88 256.56,87.62 258.36,87.62 261.3,84.68 261.72,84.68 261.93,84.47 263.14,84.47 263.33,84.28
  IN4 w0.14: v2(270.62,41.58) 270.15,42.05 270.15,42.72 269.81,43.06 269.81,43.16 269.14,43.83 269.14,45.65 270.3,46.8 270.3,50.06 270.74,50.5 270.74,53.68 271.09,54.03 271.09,58.86 272.12,59.9 272.12,64.58 271.98,64.72 271.43,64.72 271.29,64.86 271.29,65.12 271.43,65.26 271.98,65.26 272.12,65.4 272.12,65.67 271.94,65.85 271.59,65.85 270.59,66.85 270.59,77.02 263.33,84.28
  BOTTOM w0.152: JDIMM1.29 268.43,39.47 270.54,41.58 v2(270.62,41.58)
DDR_A_D13: length 69.3
  TOP w0.076: v2(254.74,89.86) UC1.BK5
  TOP w0.152: v2(270.62,40.25) 270.46,40.25 269.68,39.46 JDIMM2.24
  IN4 w0.076: 263.31,83.73 262.85,84.19 261.79,84.19 261.57,84.41 261.19,84.41 260.29,85.31 260.1,85.31 257.99,87.41 255.3,87.41 254.37,88.34 254.37,89.49 v2(254.74,89.86)
  IN4 w0.14: 263.31,83.73 270.2,76.84 270.2,66.65 270.9,65.95 270.9,64.69 271.69,63.91 271.69,61.19 271.58,61.08 271.11,61.08 270.97,60.95 270.97,60.68 271.11,60.54 271.61,60.54 271.75,60.4 271.75,60.13 269.93,58.3 269.93,46.96 268.77,45.8 268.77,43.67 269.44,43.01 269.44,42.91 269.78,42.57 269.78,41.09 v2(270.62,40.25)
  BOTTOM w0.152: JDIMM1.25 269.43,39.06 v2(270.62,40.25)
DDR_A_D14: length 70.7
  TOP w0.076: v2(258.44,85.66) 257.8,85.66 257.6,85.85 257.31,85.85 UC1.BK1
  TOP w0.152: v2(267,43.62) 267.38,43.24 267.38,40.78 265.18,38.57 JDIMM2.42
  IN4 w0.076: v2(258.44,85.66) 258.44,85.04 260.76,82.71 262.04,82.71 262.77,81.98
  IN4 w0.14: v2(267,43.62) 267,46.19 267.93,47.13 267.93,52.51 267.75,52.69 267.75,52.89 267.92,53.05 267.92,53.25 267.73,53.44 267.53,53.44 267.36,53.27 267.17,53.27 267,53.44 267,58.15 268.67,59.81 268.67,70.82 268.53,70.96 268.18,70.96 268.04,71.1 268.04,71.36 268.18,71.5 268.53,71.5 268.67,71.64 268.67,71.91 268.53,72.05 268.18,72.05 268.04,72.19 268.04,72.45 268.18,72.59 268.53,72.59 268.67,72.73 268.67,73 268.53,73.14 268.18,73.14 268.04,73.28 268.04,73.55 268.18,73.69 268.53,73.69 268.67,73.83 268.67,74.09 268.53,74.23 268.18,74.23 268.04,74.37 268.04,74.64 268.18,74.78 268.53,74.78 268.67,74.92 268.67,75.19 268.53,75.32 268.18,75.32 268.04,75.46 268.04,76.71 262.77,81.98
  BOTTOM w0.152: v2(267,43.62) 267.19,43.62 267.38,43.44 267.38,40.48 265.43,38.53 JDIMM1.41
DDR_A_D15: length 68.9
  TOP w0.076: UC1.BK2 254.85,87.95 254.85,86.99 258.44,83.41 v2(260.68,83.41)
  TOP w0.152: JDIMM2.38 266.18,38.45 268.03,40.3 v2(268.65,40.3)
  IN4 w0.076: 263.03,82.28 262.25,83.05 261.04,83.05 v2(260.68,83.41)
  IN4 w0.14: 263.03,82.28 263.09,82.22 269.07,76.23 269.07,65.74 269.21,65.6 269.61,65.6 269.75,65.46 269.75,65.19 269.61,65.06 269.21,65.06 269.07,64.92 269.07,64.65 269.21,64.51 269.61,64.51 269.75,64.37 269.75,64.1 269.61,63.96 269.21,63.96 269.07,63.82 269.07,63.56 269.21,63.42 269.61,63.42 269.75,63.28 269.75,61.26 269.61,61.12 269.4,61.12 269.26,60.98 269.26,60.72 269.4,60.58 269.61,60.58 269.75,60.44 269.75,60.23 267.95,58.42 267.95,53.91 268.3,53.55 268.3,46.94 267.52,46.16 267.52,41.43 v2(268.65,40.3)
  BOTTOM w0.152: v2(268.65,40.3) 267.83,40.3 266.43,38.9 JDIMM1.37
DDR_A_D16: length 66.9
  TOP w0.076: v2(255,85.96) 254.19,85.96 253.5,86.65 253.5,86.99 253.92,87.41 253.92,87.85 253.7,88.07 253.7,89.45 253.61,89.54 UC1.BG4
  TOP w0.152: JDIMM2.45 264.43,44.96 264.73,44.66 264.96,44.66 265.79,43.82 265.79,43.25 v2(265.39,42.85)
  IN4 w0.076: v2(255,85.96) 255.87,85.96 256.47,85.36 256.88,85.36 261.16,81.07 261.16,80.77 261.3,80.62
  IN4 w0.14: v2(265.39,42.85) 264.96,43.28 264.95,43.29 264.95,45.35 264.47,45.84 264.47,52.21 264.97,52.7 264.97,58.89 266.11,60.04 266.11,72.36 265.97,72.5 265.7,72.5 265.56,72.36 265.56,70.59 265.43,70.47 265.17,70.47 265.02,70.62 265.02,76.91 261.3,80.62
  BOTTOM w0.152: v2(265.39,42.85) 265.79,43.24 265.79,43.7 265.03,44.46 264.94,44.46 264.18,45.23 JDIMM1.46
DDR_A_D17: length 66.7
  TOP w0.076: v2(254.55,86.41) 254.01,86.41 253.74,86.68 253.74,87 254.11,87.38 254.11,88.01 254,88.12 254,89.59 UC1.BG5
  TOP w0.152: v2(265.39,43.53) 265.12,43.53 263.43,45.23 JDIMM2.49
  IN4 w0.076: v2(254.55,86.41) 256.16,86.41 261.66,80.9
  IN4 w0.14: 261.66,80.9 265.38,77.18 265.38,73 265.52,72.87 265.78,72.87 265.93,73.02 265.93,75.41 266.05,75.53 266.35,75.53 266.48,75.4 266.48,59.88 265.34,58.75 265.34,52.56 265.39,52.51 v2(265.39,43.53)
  BOTTOM w0.152: JDIMM1.50 263.18,45.16 264.8,43.53 v2(265.39,43.53)
DDR_A_D18: length 70.4
  TOP w0.076: UC1.BF4 252.55,89.54 v2(252.22,89.21)
  TOP w0.152: JDIMM2.62 260.18,39.77 260.72,40.32 260.72,41.8 261.35,42.43 261.35,43.21 261.76,43.61 v2(261.95,43.61)
  IN4 w0.076: 259.27,79.46 259.12,79.61 259.12,80.66 258.36,81.42 257.98,81.42 256.52,82.88 256.52,83.22 253.41,86.33 253.41,88.03 v2(252.22,89.21)
  IN4 w0.14: 259.27,79.46 262.69,76.04 262.69,68.97 262.83,68.83 263.28,68.83 263.42,68.69 263.42,68.43 263.28,68.29 262.83,68.29 262.69,68.15 262.69,67.88 262.83,67.74 263.28,67.74 263.42,67.6 263.42,67.34 263.28,67.2 262.83,67.2 262.69,67.06 262.69,66.79 262.83,66.65 263.28,66.65 263.42,66.51 263.42,66.24 263.28,66.1 262.83,66.1 262.69,65.96 262.69,65.7 262.83,65.56 263.28,65.56 263.42,65.42 263.42,64.16 262.65,63.39 262.65,61.32 262.79,61.18 263.18,61.18 263.32,61.04 263.32,60.77 263.19,60.64 262.79,60.64 262.65,60.5 262.65,59.86 261.19,58.41 261.19,45.82 261.95,45.06 v2(261.95,43.61)
  BOTTOM w0.152: JDIMM1.63 259.93,39.52 260.72,40.32 260.72,41.8 261.39,42.47 261.39,43.05 v2(261.95,43.61)
DDR_A_D19: length 71.5
  TOP w0.076: v2(252.22,89.86) 252.55,90.19 UC1.BF5
  TOP w0.152: JDIMM2.59 260.93,45.23 261.38,44.77 261.69,44.77 263.23,43.23 263.23,42.87 263.07,42.72 262.81,42.72 262.63,42.55 262.63,42.36 262.82,42.17 263.06,42.17 263.23,42.01 263.23,41.04 v2(263.65,40.62)
  IN4 w0.076: v2(252.22,89.86) 253.68,88.41 253.68,86.52 256.85,83.35 256.85,82.87 258.04,81.69 258.62,81.69 259.47,80.83 259.47,79.79 259.63,79.64
  IN4 w0.14: v2(263.65,40.62) 262.44,41.82 262.44,45.09 261.56,45.97 261.56,58.25 263.78,60.48 263.78,68.93 263.06,69.66 263.06,76.21 259.63,79.64
  BOTTOM w0.152: v2(263.65,40.62) 264.06,41.03 264.06,43.59 262.79,44.86 261.54,44.86 261.18,45.23 JDIMM1.58
DDR_A_D20: length 66.2
  TOP w0.076: UC1.BG2 253.41,87.99 253.74,87.65 253.74,87.47 253.29,87.03 253.29,86.6 254.89,85 v4(255.17,85) 255.84,85 v2(255.9,85.06)
  TOP w0.152: JDIMM2.50 263.18,39.26 v2(265.39,41.48)
  IN4 w0.076: 260.88,80.67 260.88,81 256.82,85.06 v2(255.9,85.06)
  IN4 w0.14: 260.88,80.67 260.88,80.53 264.57,76.83 264.57,70.31 265.28,69.6 265.28,67.55 265.46,67.37 265.6,67.37 265.74,67.23 265.74,66.96 265.6,66.82 265.46,66.82 265.32,66.68 265.32,66.41 265.46,66.27 265.6,66.27 265.74,66.14 265.74,65.87 265.6,65.73 265.46,65.73 265.32,65.59 265.32,65.32 265.46,65.18 265.6,65.18 265.74,65.04 265.74,64.78 265.6,64.64 265.46,64.64 265.32,64.5 265.32,64.23 265.46,64.09 265.6,64.09 265.74,63.95 265.74,63.68 265.6,63.54 265.46,63.54 265.32,63.4 265.32,63.14 265.46,63 265.6,63 265.74,62.86 265.74,60.19 264.6,59.05 264.6,52.86 264.09,52.35 264.09,45.7 264.52,45.27 264.52,43.18 264.91,42.79 264.91,41.96 v2(265.39,41.48)
  BOTTOM w0.152: v2(265.39,41.48) 265.24,41.48 263.43,39.66 JDIMM1.49
DDR_A_D21: length 63.6
  TOP w0.076: v2(256.35,84.61) 256.31,84.57 255.07,84.57 253.09,86.55 253.09,87.09 253.41,87.4 UC1.BG1
  TOP w0.152: JDIMM2.46 264.18,38.86 v2(265.39,40.08)
  IN4 w0.076: 260.63,80.25 260.51,80.38 260.51,81.05 256.95,84.61 v2(256.35,84.61)
  IN4 w0.14: v2(265.39,40.08) 264.54,40.93 264.54,42.64 264.43,42.75 264.13,43.06 264.13,45.14 263.69,45.57 263.69,51.07 263.55,51.21 263.02,51.21 262.88,51.35 262.88,51.62 263.02,51.76 263.55,51.76 263.69,51.9 263.69,52.47 264.23,53.01 264.23,57.81 264.09,57.94 263.55,57.94 263.41,58.08 263.41,58.35 263.55,58.49 264.09,58.49 264.23,58.63 264.23,59.2 265.37,60.34 265.37,62.55 264.91,63.01 264.91,69.45 264.2,70.16 264.2,76.68 260.63,80.25
  BOTTOM w0.152: v2(265.39,40.08) 265.22,40.08 264.43,39.29 JDIMM1.45
DDR_A_D22: length 65.4
  TOP w0.076: UC1.BF1 252.55,87.59 v2(252.22,87.26)
  TOP w0.152: JDIMM2.58 261.18,40.43 261.74,40.99 v2(261.95,40.99)
  IN4 w0.076: v2(252.22,87.26) 252.71,86.78 252.71,86.06 254.87,83.91 254.87,83.9 258.5,80.26 258.5,79.58
  IN4 w0.14: 258.5,79.58 258.5,79.03 261.06,76.47 261.06,72.26 261.25,72.07 261.77,72.07 261.91,71.93 261.91,71.66 261.77,71.52 261.25,71.52 261.11,71.38 261.11,71.12 261.25,70.98 261.77,70.98 261.91,70.84 261.91,70.57 261.77,70.43 261.25,70.43 261.11,70.29 261.11,70.02 261.25,69.88 261.77,69.88 261.91,69.74 261.91,69.48 261.77,69.34 261.25,69.34 261.11,69.2 261.11,68.93 261.25,68.79 261.77,68.79 261.91,68.65 261.91,60.19 260.43,58.7 260.43,51.32 260.29,51.18 259.76,51.18 259.62,51.04 259.62,50.77 259.76,50.63 260.29,50.63 260.43,50.49 260.43,50.3 259.86,49.74 259.86,46.11 261.07,44.9 261.07,41.87 v2(261.95,40.99)
  BOTTOM w0.152: JDIMM1.59 260.93,39.97 v2(261.95,40.99)
DDR_A_D23: length 67.5
  TOP w0.076: v2(252.22,87.91) 252.55,88.24 UC1.BF2
  TOP w0.152: v2(261.94,42.34) 262.35,42.75 262.35,43.77 261.77,44.35 260.76,44.35 259.93,45.19 JDIMM2.63
  IN4 w0.076: v2(252.22,87.91) 253.04,87.1 253.04,86.25 256.19,83.1 256.19,82.88 258.84,80.23 258.84,79.35 258.94,79.25
  IN4 w0.14: v2(261.94,42.34) 261.49,42.78 261.49,45 260.27,46.22 260.27,49.54 260.8,50.06 260.8,58.56 262.28,60.04 262.28,64.28 262.42,64.42 262.84,64.42 262.98,64.56 262.98,64.82 262.84,64.96 262.42,64.96 262.28,65.1 262.28,72.46 262.14,72.6 261.6,72.6 261.46,72.74 261.46,73.01 261.6,73.15 262.14,73.15 262.28,73.29 262.28,73.55 262.14,73.69 261.6,73.69 261.46,73.83 261.46,74.1 261.6,74.24 262.14,74.24 262.28,74.38 262.28,74.64 262.14,74.78 261.6,74.78 261.46,74.92 261.46,75.19 261.6,75.33 262.14,75.33 262.28,75.47 262.28,75.91 258.94,79.25
  BOTTOM w0.152: JDIMM1.62 260.18,44.79 260.6,44.36 261.76,44.36 262.35,43.77 262.35,42.75 v2(261.94,42.34)
DDR_A_D24: length 65.4
  TOP w0.076: v2(253.57,84.64) 253.01,84.64 252.32,85.34 251.87,85.34 251.11,86.09 251.11,87.18 251.17,87.25 251.17,87.75 250.89,88.03 UC1.BD2
  TOP w0.152: v2(260.3,41.76) 260.72,42.18 260.72,43.18 258.93,44.98 JDIMM2.67
  IN4 w0.076: 257.36,79.58 257.36,80.28 254.61,83.02 254.26,83.02 253.73,83.55 253.73,83.88 253.57,84.04 v2(253.57,84.64)
  IN4 w0.14: 257.36,79.58 257.36,78.55 259.79,76.11 259.79,65.22 259.93,65.08 260.63,65.08 260.77,64.94 260.77,64.67 260.63,64.53 259.93,64.53 259.79,64.39 259.79,64.13 260.23,63.69 260.23,60.12 259.09,58.98 259.09,58.26 258.95,58.12 258.67,58.12 258.52,57.98 258.52,57.71 258.66,57.58 258.95,57.58 259.09,57.44 259.09,52.28 258.35,51.54 258.35,46.01 259.87,44.48 259.87,42.18 v2(260.3,41.76)
  BOTTOM w0.152: JDIMM1.66 259.18,44.85 260.86,43.16 260.86,42.32 v2(260.3,41.76)
DDR_A_D25: length 63.3
  TOP w0.076: UC1.BD1 250.89,85.7 v1(250.97,85.62) 251.54,85.06 252.02,85.06 252.89,84.19 v2(254.02,84.19)
  TOP w0.152: v2(260.3,43.04) 260.11,43.04 257.93,45.23 JDIMM2.71
  IN4 w0.076: 257.73,79.58 257.73,80.36 254.78,83.31 254.34,83.31 254.02,83.62 v2(254.02,84.19)
  IN4 w0.14: 257.73,79.58 257.73,79.25 257.73,79.25 257.73,78.7 260.28,76.15 260.28,68.14 260.42,68 261,68 261.14,67.86 261.14,67.59 261,67.45 260.42,67.45 260.28,67.31 260.28,67.05 260.42,66.91 261,66.91 261.14,66.77 261.14,66.5 261,66.36 260.42,66.36 260.28,66.22 260.28,65.95 260.42,65.81 261,65.81 261.14,65.67 261.14,63.4 261,63.26 260.79,63.26 260.65,63.12 260.65,62.85 260.79,62.71 261,62.71 261.14,62.57 261.14,60.51 259.49,58.86 259.49,52.16 258.72,51.4 258.72,46.15 260.3,44.58 v2(260.3,43.04)
  BOTTOM w0.152: JDIMM1.70 258.18,44.78 259.92,43.04 v2(260.3,43.04)
DDR_A_D26: length 66.4
  TOP w0.076: UC1.BC4 250.04,89.54 v2(249.71,89.21)
  TOP w0.152: v2(257.01,41.86) 256.85,41.86 255.93,42.78 JDIMM2.79
  IN4 w0.076: v2(249.71,89.21) 250.88,88.04 250.88,84.15 254.98,80.05 254.98,79.58
  IN4 w0.14: 254.98,79.58 254.98,77.77 256.73,76.02 256.73,71.58 256.87,71.44 257.38,71.44 257.52,71.3 257.52,71.03 257.38,70.89 256.87,70.89 256.73,70.75 256.73,70.49 256.87,70.35 257.38,70.35 257.52,70.21 257.52,69.94 257.38,69.8 256.87,69.8 256.73,69.66 256.73,69.39 256.87,69.25 257.38,69.25 257.52,69.12 257.52,68.85 257.38,68.71 256.88,68.71 256.74,68.57 256.74,68.31 256.89,68.16 257.38,68.16 257.52,68.02 257.52,60.89 255.58,58.95 255.58,53.68 255.24,53.34 255.24,49.22 254.81,48.78 254.81,45.26 256.53,43.54 256.53,42.34 v2(257.01,41.86)
  BOTTOM w0.152: JDIMM1.80 255.68,43.19 v2(257.01,41.86)
DDR_A_D27: length 68.6
  TOP w0.076: v2(249.71,89.86) 250.04,90.19 UC1.BC5
  TOP w0.152: v2(257.06,43.05) 257.42,42.69 257.42,40.46 255.68,38.72 JDIMM2.80
  IN4 w0.076: 255.41,79.58 255.41,79.91 251.26,84.06 251.26,88.31 v2(249.71,89.86)
  IN4 w0.14: 255.41,79.58 255.41,77.86 257.88,75.38 257.88,75.1 257.74,74.96 257.3,74.96 257.16,74.82 257.16,74.55 257.3,74.41 257.74,74.41 257.88,74.27 257.88,74 257.74,73.86 257.3,73.86 257.16,73.72 257.16,73.46 257.3,73.32 257.74,73.32 257.88,73.18 257.88,72.91 257.74,72.77 257.24,72.77 257.12,72.65 257.12,72.38 257.28,72.23 257.74,72.23 257.88,72.09 257.88,60.73 255.95,58.8 255.95,53.53 255.61,53.19 255.61,49.02 255.2,48.6 255.2,45.39 256.98,43.61 256.98,43.13 v2(257.06,43.05)
  BOTTOM w0.152: v2(257.06,43.05) 257.18,43.05 257.47,42.76 257.47,40.51 255.93,38.97 JDIMM1.79
DDR_A_D28: length 68.3
  TOP w0.076: v2(252.22,85.99) 251.85,86.37 251.85,86.57 251.5,86.92 251.5,88.22 251.41,88.32 251.41,89.67 UC1.BD5
  TOP w0.152: v2(258.41,43.21) 258.44,43.21 258.95,42.7 258.95,39.29 258.18,38.52 JDIMM2.70
  IN4 w0.076: v2(252.22,85.99) 252.22,84.88 253.27,83.83 253.27,83.37 256.62,80.02 256.62,79.58
  IN4 w0.14: v2(258.41,43.21) 258.38,43.23 258.38,44.11 257.61,44.88 257.61,45.9 257.47,46.04 257.03,46.04 256.89,46.18 256.89,46.45 257.03,46.59 257.47,46.59 257.61,46.73 257.61,50.19 257.53,50.26 257.04,50.26 256.9,50.4 256.9,50.67 257.04,50.81 257.48,50.81 257.61,50.94 257.61,51.21 257.46,51.35 257.05,51.35 256.91,51.49 256.91,51.76 257.06,51.9 257.46,51.9 257.61,52.05 257.61,52.32 257.48,52.45 257.01,52.45 256.89,52.57 256.89,52.83 257.04,52.99 257.53,52.99 257.67,53.13 257.67,58.61 259.49,60.43 259.49,63.3 259.03,63.77 259.03,75.83 256.62,78.25 256.62,79.58
  BOTTOM w0.152: JDIMM1.71 257.93,39.98 257.75,40.15 257.75,42.95 258.01,43.21 v2(258.41,43.21)
DDR_A_D29: length 64.6
  TOP w0.076: v2(252.67,85.54) 252.11,85.54 251.34,86.32 251.34,87.88 251.18,88.03 251.18,89.25 UC1.BD4
  TOP w0.152: JDIMM2.66 259.14,37.74 259.14,38.79 259.7,39.36 259.7,40.03 260.15,40.49 v2(260.29,40.49)
  IN4 w0.076: 256.99,79.58 256.99,80.16 254.4,82.75 254.22,82.75 253.46,83.51 253.46,83.91 253.17,84.2 253.17,84.42 252.67,84.91 v2(252.67,85.54)
  IN4 w0.14: v2(260.29,40.49) 259.5,41.27 259.5,41.82 259.36,41.96 259.16,41.96 259.02,42.1 259.02,42.37 259.16,42.51 259.36,42.51 259.5,42.65 259.5,42.92 259.36,43.06 259.16,43.06 259.02,43.2 259.02,43.46 259.16,43.6 259.36,43.6 259.5,43.74 259.5,44.33 258.94,44.89 258.74,44.89 258.54,44.69 258.34,44.69 258.15,44.88 258.15,45.08 258.35,45.28 258.35,45.48 257.98,45.85 257.98,52.37 258.18,52.57 258.52,52.57 258.66,52.71 258.66,52.98 258.53,53.12 258.18,53.12 258.04,53.25 258.04,58.45 259.86,60.28 259.86,63.46 259.4,63.92 259.4,75.99 256.99,78.4 256.99,79.58
  BOTTOM w0.152: v2(260.29,40.49) 258.93,39.12 JDIMM1.67
DDR_A_D30: length 63.9
  TOP w0.076: UC1.BC1 250.04,87.59 v2(249.71,87.26)
  TOP w0.152: v2(256.91,40.51) 256.81,40.51 254.68,38.37 JDIMM2.84
  IN4 w0.076: 254.59,79.58 254.59,80.18 250.5,84.27 250.5,86.47 v2(249.71,87.26)
  IN4 w0.14: v2(256.91,40.51) 256.08,41.34 256.08,43.47 254.44,45.11 254.44,48.94 254.87,49.38 254.87,53.49 255.22,53.83 255.22,59.11 257.03,60.92 257.03,62.69 256.65,63.07 256.65,63.44 256.85,63.64 257.01,63.64 257.15,63.78 257.15,64.04 257.01,64.18 256.64,64.18 256.5,64.32 256.5,64.59 256.64,64.73 257.01,64.73 257.15,64.87 257.15,65.13 257.01,65.27 256.64,65.27 256.5,65.41 256.5,65.68 256.64,65.82 257.01,65.82 257.15,65.96 257.15,66.23 257.01,66.37 256.54,66.37 256.42,66.49 256.42,66.78 256.55,66.91 257.01,66.91 257.15,67.05 257.15,67.32 257.01,67.46 256.64,67.46 256.33,67.77 256.33,75.88 254.59,77.62 254.59,79.58
  BOTTOM w0.152: JDIMM1.83 254.93,38.81 256.63,40.51 v2(256.91,40.51)
DDR_A_D31: length 62
  TOP w0.076: UC1.BC2 250.04,88.24 v2(249.71,87.91)
  TOP w0.152: JDIMM2.83 254.93,44.1 v2(254.84,44.02)
  IN4 w0.076: 254.15,79.62 254.15,80.33 250.12,84.36 250.12,86.08 249.32,86.88 249.32,87.52 v2(249.71,87.91)
  IN4 w0.14: 254.15,79.62 254.15,77.54 255.96,75.73 255.96,65.24 256.11,65.09 256.11,62.75 256.66,62.19 256.66,61.07 254.27,58.68 254.27,53.61 254.37,53.51 254.37,49.41 254.03,49.07 254.03,47.43 253.57,46.97 253.57,39.97 253.71,39.83 254.07,39.83 254.21,39.97 254.21,43.38 v2(254.84,44.02)
  BOTTOM w0.152: v2(254.84,44.02) 254.68,44.19 JDIMM1.84
DDR_A_D32: length 73.7
  TOP w0.076: v2(233.73,84.05) 233.18,84.6 233.18,87.47 UC1.AB1
  TOP w0.152: v2(227.57,40.26) 227.94,40.62 227.94,40.96 228.7,41.72 228.7,42.91 230.43,44.63 JDIMM2.173
  IN4 w0.076: 232.9,81.62 233.73,82.46 v2(233.73,84.05)
  IN4 w0.14: v2(227.57,40.26) 228.33,41.01 228.33,41.74 228.61,42.02 228.61,43.41 225.38,46.64 225.38,49.76 221.97,53.17 221.97,58.11 220.92,59.16 220.92,64.28 220.21,64.98 219.71,64.98 219.09,65.6 219.09,69.87 220.9,71.67 223.27,71.67 230,78.4 230,79.31 232.31,81.62 232.9,81.62
  BOTTOM w0.152: v2(227.57,40.26) 227.76,40.26 228.29,40.79 228.29,41.37 229.4,42.48 229.4,43.09 230.18,43.86 JDIMM1.174
DDR_A_D33: length 70.9
  TOP w0.076: UC1.AB2 233.57,87.96 233.57,87.42 233.38,87.23 233.38,85.3 v2(234.18,84.5)
  TOP w0.152: v2(229.26,40.34) 230.34,39.26 230.72,39.26 231.18,38.8 JDIMM2.170
  IN4 w0.076: v2(234.18,84.5) 234.09,84.41 234.09,82.41 232.99,81.32
  IN4 w0.14: v2(229.26,40.34) 229.26,39.03 229.14,38.91 228.85,38.91 228.72,39.03 228.72,41.7 228.98,41.96 228.98,43.65 225.74,46.88 225.74,49.91 222.34,53.32 222.34,58.26 221.28,59.32 221.28,64.43 220.15,65.56 220.15,67.45 219.46,68.14 219.46,69.69 221.08,71.3 223.42,71.3 230.37,78.25 230.37,79.31 232.37,81.32 232.99,81.32
  BOTTOM w0.152: JDIMM1.169 231.43,38.37 231,38.79 230.81,38.79 v2(229.26,40.34)
DDR_A_D34: length 72.6
  TOP w0.076: UC1.AA4 232.44,89.54 v2(232.11,89.21)
  TOP w0.152: JDIMM2.187 226.93,44.43 226.49,43.99 226.49,42.19 226.23,41.94 v2(226.09,41.94)
  IN4 w0.076: 228.74,79.71 231.22,82.19 231.22,82.3 232.55,83.62 232.55,83.86 233.39,84.7 233.39,87.93 v2(232.11,89.21)
  IN4 w0.14: v2(226.09,41.94) 226.32,41.94 226.52,42.13 226.52,43.35 222.45,47.42 222.45,50.42 219.97,52.9 219.97,57.85 218.51,59.31 218.51,63.85 217.58,64.79 217.58,70.5 221.41,74.34 222.45,74.34 222.6,74.19 222.6,73.92 222.47,73.79 221.63,73.79 221.49,73.65 221.49,73.39 221.64,73.24 222.67,73.24 228.59,79.17 228.59,79.56 228.74,79.71
  BOTTOM w0.152: v2(226.09,41.94) 226.09,42.09 226.45,42.46 226.45,43.67 227.18,44.4 JDIMM1.186
DDR_A_D35: length 74.9
  TOP w0.076: UC1.AA5 232.43,90.19 v2(232.11,89.86)
  TOP w0.152: JDIMM2.183 227.93,44.58 226.86,43.51 226.86,41.22 226.25,40.61 v2(226.05,40.61)
  IN4 w0.076: 228.96,79.54 228.96,79.62 231.55,82.21 231.55,82.35 232.82,83.61 232.82,83.8 233.69,84.68 233.69,88.28 v2(232.11,89.86)
  IN4 w0.14: v2(226.05,40.61) 226.29,40.61 226.89,41.21 226.89,43.5 223.46,46.93 223.46,49.94 220.34,53.05 220.34,58.14 218.88,59.6 218.88,64.09 217.94,65.02 217.94,70.35 220.44,72.85 222.79,72.85 228.96,79.02 228.96,79.54
  BOTTOM w0.152: v2(226.05,40.61) 226.48,41.03 226.48,41.9 226.84,42.26 226.84,43.16 228.18,44.49 JDIMM1.182
DDR_A_D36: length 74
  TOP w0.076: UC1.AB5 233.9,89.58 233.9,87.27 233.78,87.15 233.78,86.8 v2(234.18,86.41)
  TOP w0.152: v2(230.21,41.61) 229.71,42.12 229.71,43.4 231.43,45.12 JDIMM2.169
  IN4 w0.076: 233.17,80.63 234.61,82.06 234.61,84.06 234.79,84.24 234.79,85.8 v2(234.18,86.41)
  IN4 w0.14: v2(230.21,41.61) 229.95,41.61 229.72,41.84 229.72,43.98 226.5,47.2 226.5,50.23 223.7,53.03 223.7,57.95 222.48,59.16 222.48,59.61 222.62,59.75 223.08,59.75 223.22,59.89 223.22,60.16 223.08,60.3 222.62,60.3 222.48,60.44 222.48,64.27 221.24,65.51 221.24,68.07 221.46,68.29 221.46,68.49 220.98,68.97 220.98,69.17 221.17,69.36 221.36,69.36 221.85,68.87 222.05,68.87 222.24,69.06 222.24,69.26 221.75,69.75 221.75,69.94 221.94,70.13 222.14,70.13 222.62,69.65 222.82,69.65 231.09,77.91 231.09,79.25 232.47,80.63 233.17,80.63
  BOTTOM w0.152: JDIMM1.170 231.18,44.5 229.67,43 229.67,41.98 230.03,41.62 230.2,41.62 v2(230.21,41.61)
DDR_A_D37: length 72.9
  TOP w0.076: v2(234.18,85.77) 233.79,86.16 233.79,86.5 233.61,86.68 233.61,87.21 233.73,87.34 233.73,88.25 233.58,88.41 233.58,89.25 UC1.AB4
  TOP w0.152: v2(229.22,41.65) 228.72,41.14 228.72,39.9 230.18,38.44 JDIMM2.174
  IN4 w0.076: 233.08,80.97 234.34,82.24 234.34,84.14 234.54,84.33 234.54,85.42 v2(234.18,85.77)
  IN4 w0.14: v2(229.22,41.65) 229.35,41.78 229.35,43.83 226.13,47.04 226.13,50.07 223.32,52.88 223.32,57.8 221.65,59.47 221.65,60.14 221.79,60.28 221.92,60.28 222.06,60.42 222.06,60.69 221.92,60.83 221.79,60.83 221.65,60.97 221.65,61.24 221.79,61.38 221.92,61.38 222.06,61.52 222.06,61.78 221.92,61.92 221.79,61.92 221.65,62.06 221.65,62.33 221.79,62.47 221.86,62.47 222,62.61 222,62.88 221.86,63.01 221.79,63.01 221.65,63.15 221.65,63.42 221.79,63.56 221.92,63.56 222.06,63.7 222.06,63.97 221.92,64.11 221.79,64.11 221.65,64.25 221.65,64.58 220.53,65.71 220.53,68.12 220.39,68.26 220.04,68.26 219.9,68.4 219.9,68.67 220.05,68.81 220.39,68.81 220.53,68.95 220.53,69.61 220.37,69.77 220.37,69.98 220.56,70.17 220.74,70.17 220.98,69.93 221.17,69.93 221.36,70.12 221.36,70.32 221.21,70.47 221.21,70.69 221.42,70.9 223.54,70.9 230.72,78.08 230.72,79.27 232.42,80.97 233.08,80.97
  BOTTOM w0.152: JDIMM1.173 230.43,38.4 228.83,40 228.83,41.26 v2(229.22,41.65)
DDR_A_D38: length 74.1
  TOP w0.076: v2(232.11,87.93) 232.44,88.24 UC1.AA2
  TOP w0.152: JDIMM2.182 228.18,38.73 226.78,40.13 225.91,40.13 225.63,40.4 225.63,42.86 v2(226.03,43.26)
  IN4 w0.076: 228.22,79.49 228.22,79.57 232.26,83.61 232.26,83.9 232.96,84.59 232.96,87.07 232.96,87.08 v2(232.11,87.93)
  IN4 w0.14: 228.22,79.49 228.22,79.32 223.63,74.73 221.27,74.73 217.21,70.66 217.21,64.28 217.46,64.03 217.46,61.02 217.6,60.89 217.97,60.89 218.11,60.75 218.11,60.48 217.97,60.34 217.61,60.34 217.47,60.2 217.47,59.81 219.04,58.25 219.04,55.37 219.17,55.23 219.44,55.23 219.58,55.09 219.58,54.83 219.44,54.68 219.17,54.68 219.04,54.54 219.04,54.28 219.17,54.14 219.43,54.14 219.57,54 219.57,53.75 219.41,53.59 219.17,53.59 219.04,53.45 219.04,53.32 222.09,50.27 222.09,47.26 226.03,43.32 v2(226.03,43.26)
  BOTTOM w0.152: JDIMM1.183 227.93,38.57 226.43,40.06 225.99,40.06 225.42,40.63 225.42,42.9 225.78,43.26 v2(226.03,43.26)
DDR_A_D39: length 68.2
  TOP w0.076: v2(232.11,87.29) 232.44,87.59 UC1.AA1
  TOP w0.152: JDIMM2.186 227.18,38.87 226.44,39.61 v2(226.18,39.61)
  IN4 w0.076: 227.69,79.31 231.98,83.6 231.98,83.93 232.72,84.67 232.72,85.73 232.49,85.96 232.49,86.91 v2(232.11,87.29)
  IN4 w0.14: 227.69,79.31 223.6,75.22 221.23,75.22 216.84,70.83 216.84,64 217.05,63.79 217.05,59.69 218.67,58.08 218.67,53.16 221.72,50.11 221.72,47.11 225.62,43.21 225.62,40.41 225.37,40.15 224.3,40.15 224.15,40 224.15,39.78 224.32,39.61 v2(226.18,39.61)
  BOTTOM w0.152: v2(226.18,39.61) 226.25,39.68 226.45,39.68 226.93,39.21 JDIMM1.187
DDR_A_D40: length 78.4
  TOP w0.076: UC1.V5 231.39,89.58 231.39,86.75 v2(232.11,86.02)
  TOP w0.152: v2(224.58,41.55) 224.74,41.55 225.02,41.83 225.02,44.04 225.93,44.94 JDIMM2.191
  IN4 w0.076: v2(232.11,86.02) 232.49,85.64 232.49,84.81 231.7,84.02 231.7,83.66 228.92,80.87 228.41,80.87 224.92,77.39 224.13,77.39
  IN4 w0.14: 224.13,77.39 222.26,77.39 221.7,76.84 221.7,76.64 221.85,76.49 222.13,76.49 222.61,76.97 222.82,76.97 223,76.78 223,76.59 222.44,76.03 220.87,76.03 220.54,75.7 220.35,75.7 220.28,75.76 220.08,75.76 219.89,75.57 219.89,75.37 219.96,75.31 219.96,75.11 219.77,74.92 219.57,74.92 219.51,74.99 219.31,74.99 219.12,74.8 219.12,74.6 219.19,74.54 219.19,74.34 216.03,71.18 216.03,62.78 216.28,62.54 216.28,59.76 216.14,59.62 215.78,59.62 215.64,59.48 215.64,59.22 215.78,59.08 216.14,59.08 216.28,58.94 216.28,58.81 216.55,58.54 216.74,58.54 216.8,58.59 216.99,58.59 217.18,58.4 217.18,58.21 217.13,58.15 217.13,57.96 217.45,57.64 217.45,54.34 217.59,54.2 217.75,54.2 217.89,54.06 217.89,53.79 217.75,53.65 217.59,53.65 217.45,53.51 217.45,53.29 220.45,50.29 220.45,49.81 220.59,49.67 220.78,49.67 220.93,49.52 220.93,49.27 220.79,49.13 220.59,49.13 220.45,48.99 220.45,47.29 224.84,42.89 224.84,41.81 v2(224.58,41.55)
  BOTTOM w0.152: v2(224.58,41.55) 225.1,42.07 225.1,43.46 226.18,44.53 JDIMM1.190
DDR_A_D41: length 77.2
  TOP w0.076: UC1.V2 231.05,87.96 231.05,87.42 230.99,87.36 230.99,84.7 v2(231.21,84.49)
  TOP w0.152: v2(222.69,42.61) 223.9,41.4 223.9,40.7 225.18,39.43 JDIMM2.194
  IN4 w0.076: 224.09,78.05 224.84,78.05 228.22,81.42 228.95,81.42 230.95,83.42 230.95,83.69 231.21,83.95 v2(231.21,84.49)
  IN4 w0.14: v2(222.69,42.61) 223.12,43.05 223.12,43.57 219.71,46.98 219.71,49.16 219.57,49.3 219.09,49.3 218.95,49.44 218.95,49.69 219.1,49.84 219.47,49.84 219.57,49.94 219.57,50.13 216.08,53.62 216.08,57.4 214.89,58.58 214.89,66.13 215.25,66.49 215.25,70.99 215.11,71.13 215.05,71.13 214.91,71.27 214.91,71.54 215.05,71.68 215.23,71.68 215.4,71.85 215.4,72.08 215.26,72.22 215.05,72.22 214.91,72.36 214.91,73.29 216.27,74.65 216.47,74.65 216.65,74.46 216.65,74.22 215.67,73.24 215.67,73.04 215.83,72.88 216.04,72.88 221.21,78.05 224.09,78.05
  BOTTOM w0.152: JDIMM1.195 224.93,39.19 223.34,40.78 223.34,42.17 222.89,42.61 v2(222.69,42.61)
DDR_A_D42: length 74.1
  TOP w0.076: v2(229.59,87.31) 229.92,87.59 UC1.U1
  TOP w0.152: v2(219.95,42.7) 221.93,44.68 JDIMM2.207
  IN4 w0.076: v2(229.59,87.31) 229.99,86.91 229.99,85.47 225.74,81.22 225.5,81.22 224.52,80.24 223.63,80.24
  IN4 w0.14: 223.63,80.24 219.5,80.24 218.49,79.23 216.54,79.23 213.09,75.79 213.09,75.32 212.89,75.12 212.69,75.12 212.66,75.16 212.46,75.16 212.27,74.97 212.27,74.5 211.21,73.44 211.21,73.04 211.35,72.9 211.53,72.9 211.67,72.76 211.67,72.49 211.53,72.35 211.35,72.35 211.21,72.21 211.21,71.94 211.35,71.81 211.53,71.81 211.67,71.67 211.67,71.4 211.53,71.26 211.35,71.26 211.21,71.12 211.21,70.85 211.35,70.71 211.53,70.71 211.67,70.57 211.67,70.31 211.53,70.17 211.35,70.17 211.21,70.03 211.21,69.76 211.35,69.62 211.53,69.62 211.67,69.48 211.67,69.21 211.53,69.07 211.35,69.07 211.21,68.93 211.21,68.67 211.35,68.53 211.53,68.53 211.67,68.39 211.67,68.12 211.53,67.98 211.35,67.98 211.21,67.84 211.21,67.58 211.35,67.44 211.53,67.44 211.67,67.3 211.67,67.03 211.53,66.89 211.35,66.89 211.21,66.75 211.21,66.48 211.35,66.34 211.53,66.34 211.67,66.2 211.67,65.94 211.53,65.8 211.35,65.8 211.21,65.66 211.21,65.39 211.35,65.25 211.53,65.25 211.67,65.11 211.67,64.2 210.91,63.44 210.91,61.17 211.73,60.36 211.73,53.83 215.8,49.76 215.8,47.1 217.5,45.4 219.95,42.95 v2(219.95,42.7)
  BOTTOM w0.152: v2(219.95,42.7) 220.14,42.7 220.43,43 220.43,43.56 221.68,44.8 JDIMM1.208
DDR_A_D43: length 75.4
  TOP w0.076: v2(229.59,87.94) 229.92,88.24 UC1.U2
  TOP w0.152: JDIMM2.204 222.68,38.48 222.23,38.92 222.23,40.3 221.09,41.44 v2(220.91,41.44)
  IN4 w0.076: 223.66,79.9 224.54,79.9 225.57,80.93 225.69,80.93 230.24,85.48 230.24,87.3 v2(229.59,87.94)
  IN4 w0.14: 223.66,79.9 219.71,79.9 218.67,78.86 217.22,78.86 216.1,77.75 215.91,77.75 215.85,77.8 215.65,77.8 215.46,77.62 215.46,77.42 215.52,77.36 215.52,77.16 215.33,76.97 215.13,76.97 215.08,77.03 214.88,77.03 214.69,76.84 214.69,76.65 214.75,76.59 214.75,76.39 214.56,76.2 214.36,76.2 214.3,76.26 214.11,76.26 213.92,76.07 213.92,75.56 212.09,73.74 212.09,73.51 212.23,73.37 212.47,73.37 212.61,73.23 212.61,72.96 212.47,72.82 212.23,72.82 212.09,72.68 212.09,72.42 212.23,72.28 212.47,72.28 212.61,72.14 212.61,71.87 212.47,71.73 212.23,71.73 212.09,71.59 212.09,71.32 212.23,71.18 212.47,71.18 212.61,71.04 212.61,70.78 212.47,70.64 212.23,70.64 212.09,70.5 212.09,70.23 212.23,70.09 212.47,70.09 212.61,69.95 212.61,69.68 212.47,69.55 212.23,69.55 212.09,69.41 212.09,53.99 216.17,49.91 216.17,47.25 220.48,42.94 220.48,41.88 v2(220.91,41.44)
  BOTTOM w0.152: v2(220.91,41.44) 221.35,41.01 221.35,40.54 222.93,38.96 JDIMM1.203
DDR_A_D44: length 77.6
  TOP w0.076: v2(230.76,84.04) 230.78,84.05 UC1.V1
  TOP w0.152: JDIMM2.190 226.18,38.39 225.79,38.77 225.79,39.15 224.16,40.79 224.16,41.8 v2(222.69,43.27)
  IN4 w0.076: 224.12,78.39 224.78,78.39 228,81.61 228.89,81.61 230.76,83.48 v2(230.76,84.04)
  IN4 w0.14: v2(222.69,43.27) 222.68,43.28 222.68,43.49 218.57,47.6 218.57,50.61 215.71,53.46 215.71,57.24 214.52,58.43 214.52,69.21 214.66,69.35 214.71,69.35 214.85,69.49 214.85,69.75 214.71,69.89 214.66,69.89 214.52,70.03 214.52,73.44 218.02,76.93 218.22,76.93 218.41,76.74 218.41,76.55 216.88,75.02 216.88,74.83 217.07,74.64 217.27,74.64 221.02,78.39 224.12,78.39
  BOTTOM w0.152: JDIMM1.191 225.93,38.53 225.43,39.03 225.43,39.45 223.73,41.15 223.73,42.44 222.86,43.3 222.72,43.3 v2(222.69,43.27)
DDR_A_D45: length 75.8
  TOP w0.076: v2(232.11,85.39) 231.59,85.39 231.4,85.57 231.4,86.3 231.22,86.48 231.22,88.13 231.07,88.28 231.07,89.24 UC1.V4
  TOP w0.152: JDIMM2.195 224.93,44.87 224.72,44.66 224.72,42.97 224.52,42.77 v2(224.3,42.77)
  IN4 w0.076: v2(232.11,85.39) 232.29,85.21 232.29,84.95 231.45,84.11 231.45,83.84 231.15,83.54 231.15,83.38 228.88,81.11 228.28,81.11 224.9,77.72 224.08,77.72
  IN4 w0.14: v2(224.3,42.77) 223.96,42.44 223.96,41.04 223.84,40.92 223.6,40.92 223.49,41.03 223.49,43.72 220.08,47.13 220.08,50.14 216.44,53.77 216.44,57.68 215.26,58.86 215.26,59.91 215.45,60.1 215.76,60.1 215.9,60.24 215.9,60.51 215.76,60.65 215.45,60.65 215.31,60.79 215.31,64.08 215.28,64.11 215.28,64.37 215.42,64.51 215.48,64.51 215.62,64.65 215.62,64.92 215.48,65.06 215.42,65.06 215.28,65.2 215.28,65.47 215.42,65.61 215.48,65.61 215.62,65.75 215.62,71.3 216.09,71.77 216.09,71.96 215.94,72.11 215.94,72.31 216.11,72.48 216.34,72.48 216.48,72.35 216.67,72.35 216.86,72.54 216.86,72.74 216.77,72.83 216.77,73.03 216.96,73.22 217.16,73.22 217.25,73.12 217.45,73.12 217.63,73.31 217.63,73.51 217.54,73.6 217.54,73.8 217.73,73.99 217.93,73.99 218.02,73.9 218.22,73.9 218.41,74.08 218.41,74.28 218.31,74.37 218.31,74.57 220.44,76.7 220.64,76.7 220.94,76.39 221.17,76.39 221.31,76.53 221.31,76.8 221.02,77.08 221.02,77.28 221.46,77.72 224.08,77.72
  BOTTOM w0.152: v2(224.3,42.77) 224.3,43.73 225.18,44.6 JDIMM1.194
DDR_A_D46: length 75.4
  TOP w0.076: UC1.U5 229.92,90.19 v2(229.59,89.86)
  TOP w0.152: JDIMM2.208 221.68,39.68 221.13,40.23 v2(220.92,40.23)
  IN4 w0.076: 223.73,79.26 224.59,79.26 230.74,85.42 230.74,88.71 v2(229.59,89.86)
  IN4 w0.14: 223.73,79.26 220.19,79.26 219.05,78.13 217.57,78.13 213.39,73.95 213.39,60.52 213.34,60.47 213.34,53.78 216.91,50.21 216.91,50.03 217.05,49.89 217.28,49.89 217.42,49.75 217.42,49.49 217.28,49.35 217.05,49.35 216.91,49.21 216.91,47.55 221.43,43.03 221.43,38.51 221.31,38.38 221.02,38.38 220.92,38.49 v2(220.92,40.23)
  BOTTOM w0.152: JDIMM1.207 221.93,39.22 v2(220.92,40.23)
DDR_A_D47: length 75.8
  TOP w0.076: v2(229.59,89.21) 229.92,89.54 UC1.U4
  TOP w0.152: v2(220.9,42.63) 222.93,44.65 JDIMM2.203
  IN4 w0.076: 223.69,79.57 224.56,79.57 230.48,85.49 230.48,88.32 v2(229.59,89.21)
  IN4 w0.14: 223.69,79.57 219.91,79.57 218.83,78.5 217.4,78.5 213.02,74.12 213.02,68.92 212.88,68.78 212.61,68.78 212.47,68.64 212.47,68.37 212.61,68.23 212.88,68.23 213.02,68.09 213.02,67.83 212.88,67.69 212.61,67.69 212.47,67.55 212.47,67.28 212.61,67.14 212.88,67.14 213.02,67 213.02,66.73 212.88,66.59 212.61,66.59 212.47,66.45 212.47,66.19 212.61,66.05 212.88,66.05 213.02,65.91 213.02,65.64 212.88,65.5 212.61,65.5 212.47,65.36 212.47,65.09 212.61,64.95 212.88,64.95 213.02,64.82 213.02,64.55 212.88,64.41 212.61,64.41 212.47,64.27 212.47,64 212.61,63.86 212.88,63.86 213.02,63.72 213.02,63.46 212.88,63.32 212.61,63.32 212.47,63.18 212.47,62.91 212.61,62.77 212.88,62.77 213.02,62.63 213.02,61.14 212.97,61.09 212.97,60.84 212.83,60.7 212.64,60.7 212.5,60.56 212.5,60.29 212.64,60.15 212.83,60.15 212.97,60.01 212.97,59.75 212.83,59.61 212.64,59.61 212.5,59.47 212.5,59.2 212.64,59.06 212.83,59.06 212.97,58.92 212.97,53.63 216.54,50.06 216.54,47.4 220.9,43.04 v2(220.9,42.63)
  BOTTOM w0.152: v2(220.9,42.63) 220.75,42.79 220.75,43.23 222.68,45.16 JDIMM1.204
DDR_A_D48: length 80.2
  TOP w0.076: v2(227.8,84.83) 227.8,85.39 228.24,85.83 228.24,86.46 228.48,86.7 228.48,87.34 228.54,87.4 228.54,87.96 UC1.R2
  TOP w0.152: v2(218.17,40.57) 219.17,41.57 219.17,42.97 220.93,44.72 JDIMM2.211
  IN4 w0.076: v2(227.8,84.83) 227.8,84.03 225.67,81.89 224.86,81.89 224.35,81.38 223.04,81.38
  IN4 w0.14: 223.04,81.38 218.47,81.38 217.83,80.74 215.19,80.74 209.65,75.2 209.65,66.48 209.51,66.34 209.24,66.34 209.1,66.2 209.1,65.94 209.24,65.8 209.51,65.8 209.65,65.66 209.65,64.77 209.18,64.3 209.18,63.04 208.64,62.5 208.64,59.6 208.78,59.46 208.97,59.46 209.12,59.6 209.32,59.6 209.5,59.41 209.5,59.22 209.36,59.07 209.36,58.87 210.04,58.2 210.04,53.39 213.53,49.89 213.53,47.68 218.63,42.58 218.63,41.03 v2(218.17,40.57)
  BOTTOM w0.152: v2(218.17,40.57) 218.34,40.57 218.69,40.92 218.69,43.03 220.68,45.02 JDIMM1.212
DDR_A_D49: length 79.2
  TOP w0.076: UC1.P5 227.4,90.19 v2(227.08,89.86)
  TOP w0.152: v2(218.19,41.84) 218.19,43.08 219.93,44.81 JDIMM2.215
  IN4 w0.076: 223.06,81.7 224.36,81.7 224.74,82.09 225.63,82.09 227.52,83.98 227.52,84.52 227.41,84.63 227.41,85.53 227.93,86.05 227.93,89.01 v2(227.08,89.86)
  IN4 w0.14: 223.06,81.7 218.21,81.7 217.62,81.11 215.04,81.11 209.23,75.31 209.23,70.47 209.09,70.33 208.84,70.33 208.7,70.19 208.7,69.92 208.84,69.78 209.09,69.78 209.23,69.64 209.23,69.34 209.09,69.2 208.78,69.2 208.64,69.06 208.64,68.8 208.78,68.66 209.09,68.66 209.23,68.52 209.23,68.25 209.09,68.11 208.78,68.11 208.64,67.97 208.64,67.71 208.78,67.57 209.09,67.57 209.23,67.43 209.23,67.16 209.09,67.02 208.78,67.02 208.64,66.88 208.64,63.03 208.24,62.62 208.24,59.45 209.06,58.63 209.06,56.73 209.67,56.12 209.67,53.23 213.16,49.74 213.16,47.53 218.19,42.51 v2(218.19,41.84)
  BOTTOM w0.152: v2(218.19,41.84) 218.04,41.99 218.04,43.41 219.68,45.04 JDIMM1.216
DDR_A_D50: length 78.1
  TOP w0.076: v2(228.7,85.73) 228.7,88.23 228.55,88.38 228.55,89.24 UC1.R4
  TOP w0.152: v2(219.85,40.28) 220.05,40.28 220.68,39.66 JDIMM2.212
  IN4 w0.076: v2(228.7,85.73) 228.7,85.73 228.7,84.66 225.74,81.7 225.02,81.7 224.39,81.06 223.09,81.06
  IN4 w0.14: 223.09,81.06 218.68,81.06 217.99,80.37 215.34,80.37 210.01,75.05 210.01,64.61 209.55,64.15 209.55,60.22 210.4,59.36 210.4,53.54 214.54,49.4 214.54,47.19 219,42.73 219,37.97 219.14,37.83 219.45,37.83 219.59,37.97 219.59,40.02 v2(219.85,40.28)
  BOTTOM w0.152: v2(219.85,40.28) 220.39,39.75 220.39,39.01 220.93,38.47 JDIMM1.211
DDR_A_D51: length 78.6
  TOP w0.076: v2(227.08,89.21) 227.4,89.54 UC1.P4
  TOP w0.152: v2(215.53,40.81) 215.15,40.43 215.15,39.39 215.79,38.74 216.3,38.74 216.68,38.37 JDIMM2.228
  IN4 w0.076: v2(227.08,89.21) 227.68,88.61 227.68,86.48 224.21,83.01 223.21,83.01
  IN4 w0.14: v2(215.53,40.81) 215.95,41.23 215.95,42.49 211.1,47.34 211.1,49.55 206.39,54.27 206.39,62.89 207.15,63.65 207.15,72.05 207.29,72.19 207.58,72.19 207.72,72.33 207.72,72.6 207.58,72.74 207.29,72.74 207.15,72.88 207.15,73.14 207.29,73.28 207.58,73.28 207.72,73.42 207.72,73.69 207.58,73.83 207.29,73.83 207.15,73.97 207.15,74.23 207.29,74.37 207.58,74.37 207.72,74.51 207.72,74.78 207.58,74.92 207.29,74.92 207.15,75.06 207.15,75.4 214.39,82.64 216.95,82.64 217.32,83.01 223.21,83.01
  BOTTOM w0.152: v2(215.53,40.81) 215.31,40.81 215.03,40.53 215.03,39.49 215.75,38.77 216.03,38.77 216.43,38.37 JDIMM1.229
DDR_A_D52: length 79.8
  TOP w0.076: v2(229.15,86.18) 229.15,86.64 228.87,86.92 228.87,89.58 UC1.R5
  TOP w0.152: v2(219.86,41.49) 219.3,40.93 219.3,38.88 219.68,38.5 JDIMM2.216
  IN4 w0.076: v2(229.15,86.18) 229.15,84.87 225.8,81.51 225.14,81.51 224.36,80.73 223.12,80.73
  IN4 w0.14: 223.12,80.73 218.88,80.73 218.16,80.01 216.21,80.01 215.84,79.63 215.64,79.63 215.5,79.77 215.3,79.77 215.12,79.58 215.12,79.39 215.26,79.25 215.26,79.05 215.07,78.86 214.87,78.86 214.73,79 214.53,79 214.34,78.81 214.34,78.61 214.48,78.47 214.48,78.28 214.29,78.09 214.1,78.09 213.96,78.23 213.76,78.23 213.57,78.04 213.57,77.84 213.71,77.7 213.71,77.5 213.52,77.31 213.32,77.31 213.18,77.46 212.99,77.46 212.8,77.27 212.8,77.07 212.94,76.93 212.94,76.73 212.75,76.54 212.55,76.54 212.41,76.68 212.21,76.68 212.03,76.49 212.03,76.3 212.17,76.16 212.17,75.96 211.98,75.77 211.78,75.77 211.64,75.91 211.44,75.91 211.25,75.72 211.25,75.52 211.39,75.38 211.39,75.19 211.2,75 211.01,75 210.87,75.14 210.67,75.14 210.48,74.95 210.48,74.75 210.62,74.61 210.62,74.41 210.38,74.18 210.38,64.96 210.52,64.83 210.64,64.83 210.79,64.68 210.79,64.42 210.65,64.28 210.52,64.28 209.92,63.67 209.92,60.37 210.09,60.2 210.29,60.2 210.44,60.35 210.63,60.35 210.82,60.16 210.82,59.97 210.67,59.82 210.67,59.62 210.77,59.52 210.77,53.69 214.91,49.55 214.91,47.35 219.41,42.84 219.41,41.84 219.76,41.49 v2(219.86,41.49)
  BOTTOM w0.152: JDIMM1.215 219.93,38.65 219.43,39.14 219.43,41.06 v2(219.86,41.49)
DDR_A_D53: length 77.2
  TOP w0.076: v2(227.08,87.91) 227.4,88.24 UC1.P2
  TOP w0.152: v2(215.5,42.05) 215.69,42.05 216.79,43.15 216.79,44.09 217.43,44.73 JDIMM2.225
  IN4 w0.076: 223.21,83.36 224.22,83.36 227.25,86.39 227.44,86.99 227.44,87.47 v2(227.08,87.91)
  IN4 w0.14: 223.21,83.36 217.12,83.36 216.78,83.01 214.24,83.01 213.7,82.48 213.5,82.48 213.26,82.71 213.07,82.71 212.88,82.52 212.88,82.33 213.12,82.09 213.12,81.89 212.93,81.7 212.73,81.7 212.49,81.94 212.29,81.94 212.11,81.75 212.11,81.55 212.34,81.32 212.34,81.12 212.15,80.93 211.96,80.93 211.72,81.17 211.52,81.17 211.33,80.98 211.33,80.78 211.57,80.54 211.57,80.35 206.78,75.55 206.78,63.8 206.02,63.04 206.02,54.11 210.73,49.4 210.73,47.19 215.5,42.42 v2(215.5,42.05)
  BOTTOM w0.152: JDIMM1.224 217.68,44.23 v2(215.5,42.05)
DDR_A_D54: length 76.4
  TOP w0.076: UC1.R1 228.26,86.89 227.98,86.61 227.98,86.26 227.17,85.44 v1(227.17,85.03) v2(227.17,84.21)
  TOP w0.152: JDIMM2.224 217.68,38.4 216.63,39.44 215.65,39.44 v2(215.57,39.53)
  IN4 w0.076: v2(227.17,84.21) 225.74,84.21 224.21,82.67 223.37,82.67
  IN4 w0.14: v2(215.57,39.53) 215.75,39.34 215.75,38.56 215.89,38.43 216.15,38.43 216.32,38.6 216.32,42.64 211.47,47.49 211.47,49.71 206.76,54.42 206.76,62.74 207.51,63.5 207.51,70.77 208.09,71.34 208.09,75.82 214.54,82.27 217.11,82.27 217.51,82.67 223.37,82.67
  BOTTOM w0.152: v2(215.57,39.53) 215.66,39.53 216.25,38.94 217.24,38.94 217.43,38.75 JDIMM1.225
DDR_A_D55: length 77
  TOP w0.076: v2(227.08,87.27) 227.4,87.59 UC1.P1
  TOP w0.152: JDIMM2.229 216.43,44.85 214.72,43.14 214.72,42.55 v2(214.8,42.47)
  IN4 w0.076: 223.1,83.71 224.18,83.71 227.08,86.61 v2(227.08,87.27)
  IN4 w0.14: v2(214.8,42.47) 214.8,42.59 210.36,47.03 210.36,49.25 205.65,53.96 205.65,63.2 206.41,63.95 206.41,76.61 206.79,77 206.99,77 207.22,76.77 207.41,76.77 207.6,76.96 207.6,77.16 207.38,77.38 207.38,77.58 207.56,77.77 207.76,77.77 207.99,77.54 208.19,77.54 208.37,77.73 208.37,77.93 208.15,78.16 208.15,78.35 208.34,78.54 208.53,78.54 208.76,78.32 208.96,78.32 209.15,78.5 209.15,78.7 208.92,78.93 208.92,79.13 209.11,79.31 209.31,79.31 209.53,79.09 209.73,79.09 209.92,79.28 209.92,79.47 209.69,79.7 209.69,79.9 209.88,80.09 210.08,80.09 210.31,79.86 210.5,79.86 210.69,80.05 210.69,80.25 210.47,80.47 210.47,80.67 213.21,83.42 216.69,83.42 216.98,83.71 223.1,83.71
  BOTTOM w0.152: JDIMM1.228 216.68,45.23 214.8,43.35 v2(214.8,42.47)
DDR_A_D56: length 82.3
  TOP w0.076: UC1.M4 226.07,89.22 226.07,88.4 226.19,88.28 226.19,87.25 225.98,87.03 225.98,86.76 225.74,86.53 v2(225.74,85.91)
  TOP w0.152: JDIMM2.233 215.43,44.71 213.83,43.11 213.83,41.44 213.02,40.63 v2(212.85,40.63)
  IN4 w0.076: 222.6,84.96 223.34,84.96 224.3,85.91 v2(225.74,85.91)
  IN4 w0.14: v2(212.85,40.63) 213.28,41.06 213.28,41.97 205.54,49.7 205.54,51.93 204.14,53.34 204.14,63.82 204.9,64.58 204.9,77.49 212.37,84.96 222.6,84.96
  BOTTOM w0.152: v2(212.85,40.63) 213.87,41.65 213.87,43.38 215.68,45.19 JDIMM1.232
