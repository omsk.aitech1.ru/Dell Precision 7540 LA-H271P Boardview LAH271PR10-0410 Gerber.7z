# Allegro board LAH271PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EDP_TXN1_C: length 4.7
  BOTTOM w0.102: UV64.5 113.46,35.46 113.56,35.36 113.56,34.98 113.85,34.69 113.85,34.66 114.25,34.26 114.29,34.26 v4(115.11,33.43) 115.5,33.05 115.5,32.51 CV832.2
EDP_TXN2: length 150
  TOP w0.102: v2(216.05,107.39) 216.25,107.6 216.86,107.6 217.21,107.95 218.78,107.95 219.08,108.25 219.08,108.34 UC1.B29
  IN1 w0.102: v2(216.05,107.39) 215.14,107.39 214.77,107.77 213.18,107.77 211.6,106.18 211.6,105.64 199.32,93.35 199.32,93.02 198.76,92.47 198.76,87.94 188.95,78.13 188.95,75.53 185.73,72.3 185.73,71.69 176.84,62.8 176.84,62.48 175.88,61.53 174.43,61.53 166.62,53.72 166.62,53.24 163.18,49.81 163.18,48.57 160.3,45.69 159.37,45.69 157.65,43.97 156.5,43.97 153.81,41.28 150.94,41.28 150.25,41.97 142.06,41.97 141.64,42.39 136.77,42.39 136.29,42.87 129.64,42.87 129.35,42.58 128.95,42.58 126.41,40.04 125.77,40.04 124.7,38.96 121.82,38.96 120.61,37.76 120.61,36.04 119.46,34.89 119.46,33.51 116.13,30.18 114.1,30.18 113.59,30.69 113.59,31.07 v2(113.3,31.36)
  BOTTOM w0.102: CV834.1 113.6,31.97 113.6,31.66 v2(113.3,31.36)
EDP_TXN2_C: length 3.5
  BOTTOM w0.102: UV64.7 112.66,35.48 112.76,35.38 112.76,35.12 112.84,35.04 v4(112.84,34.69) 112.84,34.43 113.6,33.67 113.6,33.25 CV834.2
EDP_TXN3: length 153.3
  TOP w0.102: v2(218.83,107.28) 219.19,107.64 UC1.B28
  IN1 w0.102: v2(218.83,107.28) 218.83,107.11 218.77,107.06 218.5,107.06 218.24,106.8 214.94,106.8 214.39,107.34 213.34,107.34 212.01,106.02 212.01,105.47 199.72,93.18 199.72,92.76 199.28,92.32 199.28,87.88 189.4,78 189.4,74.54 182.54,67.68 182.54,66.56 180.86,64.88 180.16,64.88 176.34,61.06 174.66,61.06 167.31,53.72 167.31,53.34 163.59,49.63 163.59,48.36 160.49,45.25 159.55,45.25 157.81,43.51 156.63,43.51 153.98,40.86 151.53,40.86 151.38,40.71 141.97,40.71 141.39,41.3 139.96,41.3 139.8,41.14 138.17,41.14 137.37,41.94 136.57,41.94 136.06,42.46 129.9,42.46 129.57,42.13 129.08,42.13 126.54,39.59 125.99,39.59 124.95,38.56 122.05,38.56 121.09,37.59 121.09,35.89 119.89,34.69 119.89,33.36 116.3,29.77 113.65,29.77 112.32,31.1 112,31.1 111.8,30.9 111.8,30.59 111.7,30.49 v2(111.32,30.49)
  BOTTOM w0.102: v2(111.32,30.49) 111.75,30.92 111.75,31.24 CV836.1
EDP_TXN3_C: length 4
  BOTTOM w0.102: CV836.2 111.76,32.51 111.76,33.15 111.72,33.19 111.72,33.77 111.76,33.81 111.76,34.83 111.56,35.02 111.56,35.32 111.46,35.42 UV64.10
EDP_TXP0: length 148.4
  TOP w0.076: v2(220.11,108.06) 220.49,108.43 UC1.D29
  IN1 w0.102: v2(118,34.92) 118,35.15 118.13,35.28 118.3,35.28 118.42,35.16 118.42,34.47 118.08,34.13 117.33,34.13 116.78,34.67 116.78,35.28 121.06,39.56 124.41,39.56 125.49,40.63 126.15,40.63 128.71,43.2 129.13,43.2 129.44,43.51 139.15,43.51 139.56,43.1 141.72,43.1 142.15,43.53 150.18,43.53 151.83,41.88 153.57,41.88 156.27,44.58 157.42,44.58 162.45,49.61 162.45,50.04 165.84,53.43 165.84,54.03 176.6,64.79 177.96,64.79 182.41,69.24 182.41,70.1 188.34,76.03 188.34,79.05 198.12,88.83 198.12,92.71 198.63,93.22 198.63,93.51 211.01,105.88 211.01,106.43 213.17,108.6 216.83,108.6 216.91,108.51 220.33,108.51 220.48,108.35 220.48,108.12 220.33,107.97 220.21,107.97 v2(220.11,108.06)
  BOTTOM w0.102: CV829.1 118.48,33.87 118.57,33.96 118.57,34.24 118.36,34.45 118.36,34.64 118.08,34.92 v2(118,34.92)
EDP_TXP0_C: length 7.7
  BOTTOM w0.102: UV64.1 115.06,35.44 114.95,35.34 114.95,35.24 115.05,35.13 115.47,35.13 v4(116.07,34.54) 116.96,33.64 117.02,33.64 117.48,33.19 117.48,33.12 117.68,32.92 117.68,32.4 117.9,32.18 118.54,32.18 118.75,32.39 118.75,33.2 118.75,33.2 118.75,33.29 118.62,33.42 118.36,33.42 CV829.2
EDP_TXP1: length 153.5
  TOP w0.076: UC1.F28 221.46,107.98 v2(221.46,108.06)
  IN1 w0.102: v2(115.97,30.81) 115.82,30.81 115.47,31.15 115.47,36.41 116.12,37.05 117.65,37.05 120.75,40.15 124.03,40.15 125.14,41.27 125.91,41.27 128.75,44.1 137.35,44.1 137.82,44.58 139.23,44.58 139.97,43.83 140.93,43.83 141.84,44.74 150.55,44.74 151.83,43.46 154.12,43.46 155.86,45.2 157.19,45.2 161.83,49.83 161.83,50.28 165.06,53.51 165.06,54.13 176.35,65.42 177.69,65.42 181.63,69.36 181.63,70.36 187.75,76.47 187.75,79.32 197.49,89.06 197.49,93.49 207.65,103.65 207.65,103.92 213.15,109.41 216.93,109.41 217.22,109.13 220,109.13 220.2,108.94 220.76,108.94 221.14,108.56 221.51,108.56 221.88,108.18 221.88,107.84 221.65,107.61 221.34,107.61 221.25,107.69 221.25,107.85 v2(221.46,108.06)
  BOTTOM w0.102: CV831.1 115.69,31.24 115.69,31.08 115.95,30.81 v2(115.97,30.81)
EDP_TXP1_C: length 4.7
  BOTTOM w0.102: UV64.4 113.86,35.46 113.75,35.36 113.75,35.06 v4(114.19,34.62) 114.92,33.89 114.98,33.89 115.5,33.38 115.5,33.32 115.69,33.13 115.69,32.51 CV831.2
EDP_TXP2: length 150
  TOP w0.102: UC1.A29 218.84,108.44 218.89,108.39 218.89,108.33 218.7,108.14 217.13,108.14 216.78,107.79 216.31,107.79 v2(216.05,108.05)
  IN1 w0.102: v2(114.09,31.36) 113.91,31.36 113.78,31.23 113.78,30.76 114.18,30.36 116.05,30.36 119.27,33.59 119.27,34.97 120.43,36.12 120.43,37.83 121.74,39.15 124.62,39.15 125.7,40.22 126.33,40.22 128.87,42.77 129.27,42.77 129.56,43.05 136.37,43.05 136.85,42.58 141.72,42.58 142.14,42.16 150.33,42.16 151.02,41.47 153.73,41.47 156.42,44.16 157.57,44.16 159.29,45.88 160.22,45.88 163,48.65 163,49.88 166.44,53.32 166.44,53.79 174.36,61.72 175.8,61.72 176.65,62.56 176.65,62.88 185.54,71.77 185.54,72.38 188.76,75.61 188.76,78.21 198.58,88.02 198.58,92.55 199.13,93.1 199.13,93.43 211.41,105.71 211.41,106.26 213.11,107.95 214.84,107.95 215.22,107.58 215.57,107.58 v2(216.05,108.05)
  BOTTOM w0.102: CV833.1 113.79,31.97 113.79,31.66 v2(114.09,31.36)
EDP_TXP2_C: length 3.5
  BOTTOM w0.102: UV64.6 113.06,35.48 112.95,35.38 112.95,35.2 113.07,35.08 113.07,34.47 113.79,33.75 113.79,33.25 CV833.2
EDP_TXP3: length 153.2
  TOP w0.102: v2(219.5,107.29) 219.84,107.63 UC1.C28
  IN1 w0.102: v2(219.5,107.29) 218.9,106.87 218.57,106.87 218.32,106.61 214.86,106.61 214.31,107.16 213.42,107.16 212.2,105.94 212.2,105.39 199.91,93.1 199.91,92.69 199.47,92.24 199.47,87.8 189.59,77.92 189.59,74.46 182.73,67.6 182.73,66.48 180.94,64.69 180.24,64.69 176.42,60.87 174.73,60.87 167.5,53.64 167.5,53.27 163.78,49.55 163.78,48.28 160.57,45.07 159.63,45.07 157.89,43.33 156.71,43.33 154.05,40.67 151.61,40.67 151.46,40.52 141.89,40.52 141.31,41.11 140.04,41.11 139.88,40.95 138.09,40.95 137.29,41.75 136.5,41.75 135.98,42.27 129.98,42.27 129.65,41.94 129.16,41.94 126.62,39.4 126.06,39.4 125.03,38.37 122.13,38.37 121.28,37.51 121.28,35.81 120.08,34.61 120.08,33.29 116.38,29.58 113.57,29.58 112.24,30.92 112.08,30.92 111.99,30.83 111.99,30.59 v2(112.16,30.42)
  BOTTOM w0.102: v2(112.16,30.42) 111.94,30.64 111.94,31.23 CV835.1
EDP_TXP3_C: length 4
  BOTTOM w0.102: UV64.9 111.86,35.42 111.75,35.31 111.75,35.1 111.95,34.91 v4(111.95,33.48) 111.95,32.51 CV835.2
EN_2.5V: length 5.2
  TOP w0.109: PC401.1 282.96,50.01 v1(282.37,50.6)
  TOP w0.254: PU400.7 284.35,47.64 284.07,47.92 283.62,47.92 283.37,47.67 PR401.1
  TOP w0.508: PC401.1 282.94,49.42 PR402.1 282.93,48.55 PR401.1
EN_3V_5V: length 64
  TOP w0.109: v2(113.04,9.71) 112.94,9.61 PU100.12
  IN4 w0.102: v2(65.77,10.02) 68.99,10.02 70.88,8.12 74.28,8.12 76.28,6.12 v2(76.28,3.08)
  BOTTOM w0.109: v2(76.28,3.08) 81.47,3.08 83.02,4.63 89.83,4.63 90.63,3.83 91.67,3.83 92.06,4.21 100.69,4.21 101.53,3.37 109.09,3.37 v1(111.62,5.9) 113.04,7.32 v2(113.04,9.71) ; v2(65.77,10.02) 66.32,10.02 66.52,10.22 PR113.2 66.52,11.3 66.29,11.53 PR115.1 65.86,11.58 65.44,11.99 65.44,12.36 PC129.1 65.46,12.4 65.46,12.49 66.1,13.13 PU101.12
EN_3VR_5VR: length 15.3
  TOP w0.109: PU500.12 310.09,40.92 310.31,41.14 310.89,41.14 v2(311.05,41.3) ; v2(310.77,34.01) 311.07,33.71 PC515.1 PR507.1 PR505.2 311.53,31.26 311.39,31.13 PU501.12
  IN3 w0.081: v2(311.05,41.3) 309.01,39.26 309.01,38.43 309.69,37.76 309.69,35.1 v2(310.77,34.01)
  BOTTOM w0.109: v2(310.77,34.01) v1(310.77,34.74)
EN_+1VSP: length 5.5
  TOP w0.254: 156.39,11.17 155.96,10.73 v2(155.83,10.73) ; 156.39,11.17 156.35,11.17 155.87,11.65 155.87,12.11 155.43,12.55 PU800.3 ; 156.39,11.17 PC807.1
  BOTTOM w0.109: v1(153.66,10.9) PR803.2
  BOTTOM w0.254: v2(155.83,10.73) 155.69,10.73 155.53,10.9 PR803.2
EN_INVPWR: length 89.2
  TOP w0.109: UE1.B2 130.33,28.85 129.87,28.85 129.61,29.11 129.61,29.39 129.73,29.5 129.73,29.79 129.55,29.98 v2(129.55,30.03)
  IN1 w0.102: v2(81.28,59.77) 81.73,59.33 81.73,56.8 81.03,56.11 81.03,52.36 81.39,52.01 83.1,52.01 83.36,51.74 83.36,51.36 84.32,50.4 84.32,49.79 84.07,49.54 84.07,46.43 86.29,44.2 92.91,44.2 96.57,47.86 98.55,47.86 98.88,47.53 98.88,46.83 101.48,44.24 101.48,39.35 100.87,38.74 v2(100.87,38.57)
  IN3 w0.081: v2(110.24,29.18) 110.7,28.72 119.15,28.72 119.97,29.53 126.11,29.53 127.68,31.1 128.63,31.1 129.41,30.32 129.41,30.17 v2(129.55,30.03)
  BOTTOM w0.109: v2(100.87,38.57) 100.7,38.4 100.7,36.67 101.23,36.14 101.23,34.9 100.69,34.36 100.69,32.48 100.8,32.36 100.8,31.05 102.57,29.28 v1(102.57,29.12) 102.97,28.72 109.32,28.72 109.77,29.18 v2(110.24,29.18) ; v2(81.28,59.77) 81.88,60.37 QV2.2 ; RE55.1 129.55,31.71 v2(129.55,30.03)
EN_IO: length 5.1
  TOP w0.109: v2(270.58,98.95) v1(270.58,99.6)
  TOP w0.254: v2(270.58,98.95) 270.47,98.95 269.42,97.9 PC312.1 PR307.1 PR304.2
  BOTTOM w0.254: PU300.5 270.61,98.99 v2(270.58,98.95)
EN_SWR: length 5.1
  BOTTOM w0.109: UR1.41 v1(26.34,15.82) 26.61,15.82 27.03,15.4 RR232.1 27.88,15.96 29,15.96 RR231.2
ENABLE_DS#: length 8.6
  TOP w0.102: RE550.1 124.78,18.43 125.12,18.77 v1(125.74,18.77) 126.32,18.77 126.54,19 127.34,19 127.74,19.4 RE549.2
  TOP w0.109: UE1.L2 130.33,20.85 129.88,20.85 129.26,20.23 128.51,20.23 127.73,19.45 127.73,19.44 RE549.2
ENLDO_3V5V: length 65
  TOP w0.109: v2(114.73,9.63) 114.51,9.85 PR109.1 PR108.1 113.6,9.58 113.39,9.37 PU100.11
  IN4 w0.102: v2(76.97,2.28) 76.97,6.08 74.43,8.63 71.11,8.63 68.2,11.53 67.76,11.53 67.56,11.34 v2(66.99,11.34)
  BOTTOM w0.109: v2(66.99,11.34) 66.42,11.91 66.42,12.45 66.65,12.68 PU101.11 ; v2(114.73,9.63) 114.51,9.63 113.78,8.9 113.78,6.68 v1(113.31,6.21) 109.86,2.76 101.34,2.76 100.36,3.74 92.34,3.74 91.96,3.35 90.43,3.35 89.63,4.16 83.22,4.16 81.64,2.58 77.27,2.58 v2(76.97,2.28)
ENLDO_3VR5VR: length 19.7
  TOP w0.109: PU500.11 310.83,40.72 311.19,40.72 311.7,41.23 311.7,41.69 PR512.1 312.38,43.38 PR510.1 311.73,43.39 v2(311.72,43.38) ; PU501.11 311.84,30.93 312.12,31.2 v2(312.26,31.2)
  IN3 w0.081: v2(311.72,43.38) 311.76,43.34 311.76,40.24 310.51,38.99 310.51,35.88 312.26,34.14 v2(312.26,31.2)
  BOTTOM w0.109: v2(312.26,31.2) v1(312.26,31.94)
ENVDD_PCH: length 64.1
  TOP w0.089: UH1.AV44 177.43,22.1 v2(177.33,22.2)
  TOP w0.109: DV42.2 135.79,44.94 136.16,45.31 v2(136.16,45.91)
  IN3 w0.081: v2(177.33,22.2) 177.3,22.23 177.3,23.53 177.08,23.75 176.03,23.75 175.5,23.22 175.17,23.22 172.6,25.79 171.79,25.79 171.15,26.43 171.15,27.61 168.89,29.87 166.22,29.87 165.76,30.33 164.44,30.33 163.01,31.76 163.01,33.08 161.68,34.41 161.68,37.28 162.09,37.69 162.09,38.25 158.83,41.51 158.83,42.03 157.97,42.9 154.69,42.9 152.83,44.75 151.8,44.75 150.81,43.77 141.71,43.77 141.1,44.38 141.1,44.82 140.65,45.27 139.26,45.27 138.59,45.94 136.19,45.94 v2(136.16,45.91)
  BOTTOM w0.109: v1(177.5,23.22) 177.23,22.95 177.23,22.31 v2(177.33,22.2)
ESPI_ALERT#: length 49.4
  TOP w0.089: UH1.AW35 177.5,26.27 v2(177.3,26.08)
  TOP w0.102: v2(134.32,24.02) 134.4,24.02 134.73,23.69 UE1.H7
  IN4 w0.102: v2(134.32,24.02) 134.68,23.66 136.21,23.66 136.64,24.08 140.88,24.08 141.37,24.57 145.21,24.57 147.24,26.6 152.76,26.6 153.72,25.63 156.3,25.63 156.95,24.98 158.39,24.98 159.04,24.34 161.58,24.34 162.55,23.37 v2(162.55,22.95)
  BOTTOM w0.109: RH340.1 162.3,22.7 v2(162.55,22.95) 162.68,23.08 v1(163.52,23.08) 163.72,23.08 164.52,23.88 164.9,23.88 165.21,24.19 166.73,24.19 167.49,24.95 168.7,24.95 168.88,24.78 173.59,24.78 174.36,25.55 176.78,25.55 177.3,26.07 v2(177.3,26.08)
ESPI_CLK: length 20.8
  TOP w0.089: UH1.BB36 176.6,25.78 176.88,25.5 177.12,25.5 177.3,25.68 177.66,25.68 177.93,25.96 178.4,25.96 v2(178.51,26.07)
  BOTTOM w0.109: RH97.1 163.92,21.98 163.92,22.09 163.79,22.22 163.59,22.22 163.46,22.35 163.46,22.53 163.59,22.66 163.79,22.66 163.92,22.78 163.92,22.94 164.61,23.63 165.19,23.63 v1(165.34,23.78) 165.52,23.95 166.83,23.95 167.59,24.72 168.61,24.72 168.8,24.53 173.67,24.53 174.45,25.31 177.78,25.31 178.51,26.04 v2(178.51,26.07)
ESPI_CLK_5105: length 51.1
  TOP w0.102: UE1.G7 135.13,24.05 135.13,22.66 134.92,22.45 v2(134.33,22.45)
  IN4 w0.102: v2(164.47,20.47) 164.25,20.47 163.58,21.14 163.06,21.14 162.73,21.48 162.73,22.22 162.35,22.6 161.97,22.6 160.46,24.11 158.94,24.11 158.3,24.75 156.85,24.75 156.21,25.39 153.64,25.39 153.32,25.71 148.86,25.71 148.42,26.15 147.12,26.15 144.57,23.6 141.1,23.6 140.7,23.21 139.54,23.21 139,23.75 136.57,23.75 136.3,23.48 136.3,23.08 136.04,22.82 134.7,22.82 v2(134.33,22.45)
  BOTTOM w0.109: v2(164.47,20.47) 164.2,20.47 163.93,20.75 RH97.2 163.61,19.75 162.96,19.1 162.96,18.53 162.37,17.94 162.37,17.01 164.63,14.75 164.63,12.4 164.72,12.31 164.72,12.11 164.87,11.96 JESPI.10 ; v2(134.33,22.45) 134.39,22.45 135.19,21.65 RE350.1
ESPI_CS#: length 68.2
  TOP w0.102: UH1.BE38 174.43,24.89 174.04,24.89 174.04,24.89 172.83,24.89 172.56,24.63 169.78,24.63 169.55,24.86 168.9,24.86 168.45,25.32 v1(165.25,25.32) 164.32,25.32 164.08,25.07 164.08,23.83 ; UE1.H6 v2(133.53,23.25)
  TOP w0.109: 164.08,23.83 163.98,23.73 163.98,21.6 164.33,21.25 165.24,21.25 165.81,20.68 166.57,20.68 167.08,20.18 v2(167.08,20.18)
  IN2 w0.081: v2(167.08,20.18) 167.08,20.18 166.19,21.06 165.38,21.06 164.86,21.58 162.47,21.58 v2(162.1,21.96)
  IN4 w0.102: v2(162.1,21.96) 161.97,21.96 160.74,23.18 159.81,23.18 159.24,23.75 158.97,23.75 158.2,24.53 156.76,24.53 156.16,25.12 153.59,25.12 153.23,25.48 148.74,25.48 148.31,25.92 147.21,25.92 144.65,23.36 142.13,23.36 141.06,22.29 139.75,22.29 139.18,22.86 136.58,22.86 136.3,22.58 136.3,22.29 136.07,22.06 134.17,22.06 133.91,22.32 133.91,22.91 133.57,23.25 v2(133.53,23.25)
  BOTTOM w0.109: JESPI.7 165.98,13.46 167.52,15 168.24,15 169.1,15.86 169.1,17.8 168.72,18.18 168.29,18.18 167.69,18.78 167.35,18.78 167.13,18.99 167.13,20.12 v2(167.08,20.18)
ESPI_IO0: length 59.3
  TOP w0.102: UE1.K5 v2(132.73,21.65)
  IN4 w0.102: v2(166.84,16.53) 166.33,16.53 165.05,17.81 164.39,17.81 163.65,18.55 162.92,18.55 162.69,18.31 161.89,18.31 160.96,19.25 160.96,20.9 160.39,21.46 160.06,21.46 159.39,20.79 158.2,20.79 157.85,21.13 155.47,21.13 154.06,22.53 153.55,22.53 152.49,23.59 148.57,23.59 145.17,20.19 145.17,19.71 143.26,17.79 141.35,17.79 139.99,19.15 138.08,19.15 137.23,18.31 135.04,18.31 134.85,18.5 133.75,18.5 133.39,18.85 133.39,19.26 133,19.65 131.8,19.65 131.53,19.91 131.53,21.09 131.71,21.26 132.15,21.26 132.54,21.65 v2(132.73,21.65)
  BOTTOM w0.109: RC366.2 164.9,20.75 164.9,20.2 164.31,19.61 163.82,19.61 163.2,19 163.2,18.43 162.71,17.94 162.71,17.36 163.15,16.91 165.84,16.91 166.21,16.53 v2(166.84,16.53) 166.84,16.31 165.99,15.46 JESPI.3
ESPI_IO0_R: length 14.1
  TOP w0.089: UH1.BB39 v2(175.76,24.93)
  BOTTOM w0.109: v2(175.76,24.93) v1(174.53,24.93) 174.46,24.93 173.8,24.27 168.72,24.27 168.51,24.48 167.69,24.48 166.92,23.71 165.79,23.71 165.44,23.37 164.69,23.37 164.21,22.9 164.21,22.35 RC366.1
ESPI_IO1: length 58.1
  TOP w0.102: UE1.L4 v2(131.93,20.85)
  IN4 w0.102: v2(167.47,16.53) 167.07,16.94 166.25,16.94 165.15,18.04 164.48,18.04 163.14,19.38 161.79,19.38 161.41,19.75 161.41,21.09 160.55,21.95 159.91,21.95 159.2,21.24 158.39,21.24 158.04,21.59 155.66,21.59 154.25,22.99 153.74,22.99 152.68,24.05 148.38,24.05 146.99,22.66 146.11,22.66 144.98,21.53 144.98,20.73 143.51,19.26 140.54,19.26 140.26,19.53 137.88,19.53 137.75,19.4 133.58,19.4 132.8,20.18 132.48,20.18 131.93,20.73 v2(131.93,20.85)
  BOTTOM w0.109: RC367.2 165.15,20.66 165.15,20.12 164.41,19.38 163.91,19.38 163.44,18.9 163.44,18.34 162.94,17.84 162.94,17.49 163.26,17.18 166,17.18 166.24,16.94 167.11,16.94 167.47,16.58 v2(167.47,16.53) 167.47,16.18 166.25,14.96 JESPI.4 164.85,14.96 164.23,15.59 v1(164.23,15.85)
ESPI_IO1_R: length 14.1
  TOP w0.089: v2(177.46,24.89) UH1.AW37
  BOTTOM w0.109: RC367.1 165.36,22.09 166.15,22.89 167.25,22.89 167.79,23.43 168.78,23.43 v1(169.05,23.7) 169.38,24.03 174.28,24.03 174.77,24.52 175.95,24.52 176.33,24.89 177.46,24.89 v2(177.46,24.89)
ESPI_IO2: length 57.3
  TOP w0.102: UE1.G6 v2(133.53,24.85)
  IN4 w0.102: v2(133.53,24.85) 133.53,24.75 132.34,23.56 132.34,22.24 132.52,22.06 132.86,22.06 133.12,21.8 133.12,21.47 132.91,21.27 132.54,21.27 132.34,21.07 132.34,20.71 132.59,20.46 132.79,20.46 133.66,19.59 137.61,19.59 137.81,19.79 138.17,19.79 138.82,20.44 139.68,20.44 140.61,19.51 143.38,19.51 144.75,20.87 144.75,21.62 146.02,22.89 146.89,22.89 148.28,24.28 152.78,24.28 153.83,23.22 154.35,23.22 155.75,21.82 158.14,21.82 158.48,21.47 159.11,21.47 159.81,22.18 160.65,22.18 161.64,21.18 161.64,19.85 161.88,19.61 163.24,19.61 164.58,18.27 165.27,18.27 166,17.54 v2(166.73,17.54)
  BOTTOM w0.109: RC368.2 v1(166.24,19.89) 166.24,19.55 166.37,19.42 166.37,18.73 166.18,18.55 166.18,18.08 v2(166.73,17.54) 167.09,17.18 167.49,17.18 167.88,16.79 167.88,16.26 166.09,14.46 JESPI.5
ESPI_IO2_R: length 14.6
  TOP w0.089: v2(178.04,24.98) 178.19,25.13 UH1.AV37
  BOTTOM w0.109: v2(178.04,24.98) 178.04,24.61 v1(177.89,24.45) 177.22,24.45 177.1,24.58 176.36,24.58 176.05,24.27 174.86,24.27 174.38,23.79 169.63,23.79 169.02,23.19 167.88,23.19 167.35,22.65 166.41,22.65 166.24,22.47 RC368.1
ESPI_IO3: length 64.7
  TOP w0.102: UE1.L5 v2(132.73,20.85)
  IN4 w0.102: v2(132.73,20.85) 132.9,20.85 133.29,21.24 134.78,21.24 134.9,21.12 134.9,20.77 135.02,20.65 135.19,20.65 135.31,20.77 135.31,21.12 135.43,21.24 140.25,21.24 140.37,21.12 140.37,20.58 140.88,20.07 141.54,20.07 141.67,20.2 141.67,20.9 141.91,21.14 142.08,21.14 142.35,20.87 142.52,20.87 142.64,20.98 142.64,21.15 142.26,21.53 142.26,22.2 142.46,22.41 142.69,22.41 142.79,22.31 142.79,21.85 143.81,20.82 144.05,20.82 144.19,20.96 144.19,21.13 143.56,21.75 143.56,21.92 143.68,22.04 143.85,22.04 143.99,21.9 144.16,21.9 144.28,22.02 144.28,22.18 144.14,22.33 144.14,22.5 144.25,22.62 144.42,22.62 144.57,22.47 144.74,22.47 145.66,23.4 146.58,23.4 147.97,24.8 152.94,24.8 153.44,24.3 154.53,24.3 154.87,23.95 154.87,23.34 155.07,23.14 155.24,23.14 155.56,23.46 155.73,23.46 155.85,23.34 155.85,23.18 155.53,22.86 155.53,22.69 155.94,22.27 156.5,22.27 156.62,22.39 156.62,22.88 156.72,22.98 156.92,22.98 157.03,22.88 157.03,22.39 157.14,22.27 157.31,22.27 157.43,22.39 157.43,23.37 157.55,23.48 158.4,23.48 158.55,23.33 158.55,23.13 158.46,23.04 157.95,23.04 157.84,22.93 157.84,22.39 157.96,22.27 158.29,22.27 158.63,22.61 159.3,22.61 159.49,22.8 160.67,22.8 162.78,20.69 163.39,20.69 163.8,20.28 163.8,19.69 164.77,18.72 165.46,18.72 165.76,18.42 v2(166.65,18.42)
  BOTTOM w0.109: RC369.2 167.1,20.94 166.65,20.49 166.65,18.43 v2(166.65,18.42) 167.48,18.42 v1(167.55,18.35) 167.96,17.94 168.55,17.94 168.85,17.65 168.85,16.13 168.07,15.36 167.35,15.36 165.95,13.96 JESPI.6
ESPI_IO3_R: length 11.6
  TOP w0.089: UH1.BA38 v2(176.82,24.16)
  BOTTOM w0.109: v2(176.82,24.16) 176.45,24.16 v1(175.88,23.59) 175.57,23.28 175.12,23.28 174.84,23.56 169.73,23.56 169.09,22.92 167.95,22.92 RC369.1
ESPI_RESET#: length 81.9
  TOP w0.102: UE1.K6 133.63,21.75 v2(133.53,21.65) ; v2(163.04,22.63) 163.49,23.08 v1(163.49,23.27) 163.49,23.57 163.85,23.93 163.85,25.17 164.33,25.65 165.67,25.65 165.78,25.54 168.49,25.54 168.95,25.09 169.65,25.09 169.89,24.85 172.5,24.85 172.73,25.08 173.77,25.08 173.83,25.13 UH1.BF38
  IN4 w0.102: v2(133.53,21.65) 133.53,21.89 133.13,22.29 133.13,23.65 133.91,24.43 140.89,24.43 141.26,24.8 145.1,24.8 147.13,26.83 152.85,26.83 153.56,26.12 154.48,26.12 154.92,26.55 156.07,26.55 157.41,25.21 158.49,25.21 159.13,24.57 161.68,24.57 163.04,23.2 v2(163.04,22.63) 163.04,22.01 164.17,20.88 164.64,20.88 164.95,20.57 164.95,20.13 165.72,19.36 166.28,19.36 167.34,18.3 167.84,18.3 169.27,16.87 170.57,16.87 170.84,17.14 171.43,17.14 172.55,16.03 173.15,16.03 v2(173.7,15.47)
  BOTTOM w0.109: v2(173.7,15.47) 173.7,14.84 173.27,14.41 167.27,14.41 165.82,12.96 JESPI.8 ; v2(163.04,22.63) 163.04,22.04 161.53,20.53 161.53,19.6 CH348.1 161.2,19.53 161.2,21.94 RH95.1 160.96,22.01 RH633.1
EXPANDER_ALERT#: length 4.6
  BOTTOM w0.109: v1(9.76,7.15) 9.21,7.7 9.21,8.53 RE563.1 9.12,9.37 9.12,10.15 9.3,10.33 UE12.11
FB_1.2V: length 5.6
  TOP w0.109: v1(199.49,14.91) 200.31,15.73 PC211.1
  TOP w0.203: PU200.6 201.72,12.33 200.88,13.17 200.88,13.39 200.34,13.92 PR209.1 200.34,14.73 PR206.1 200.46,15.73 PC211.1
FB_1.8V: length 1.3
  TOP w0.109: PR905.1 v1(124.34,7.27)
FB_2.5V: length 5.7
  TOP w0.109: v1(283.28,42.61) 282.75,43.14 PR405.1
  TOP w0.254: PU400.1 283.85,44.73 283.66,44.53 282.94,44.53 PR405.1
  TOP w0.508: PR405.1 282.75,44.72 PR404.2 PC402.2
FB_2PH: length 5.9
  TOP w0.203: PR1137.1 271.9,146.01 PC1116.2 271.03,146.03 PC1117.1 269.03,146.03 PR1136.1 268.33,145.33 PU1100.34
FB_3VR: length 1.8
  TOP w0.254: PC526.1 310.59,31.61 310.94,31.25 PU501.13
FB_4PH: length 8.7
  TOP w0.109: v1(253.94,147.12) 254.21,146.85 PC1115.2
  TOP w0.203: PU1100.5 259.31,145.73 258.73,146.31 258.73,146.9 257.92,147.71 PR1131.1 256.8,147.71 PR1130.1 256.79,146.86 PC1113.2 255.9,146.83 PC1115.2
FB_5V: length 4.4
  BOTTOM w0.109: PC128.1 65.43,13.15 65.14,12.86 63.95,12.86 v1(63.38,12.29)
  BOTTOM w0.254: PC128.1 65.67,13.58 PU101.13
FB_5VR: length 3.1
  TOP w0.254: PC514.1 311.06,42.17 311.06,42.16 311.06,42.03 v1(310.58,41.55) 310.15,41.55 309.64,41.04 PU500.13
FB_+1VSP: length 2.6
  TOP w0.254: PU800.4 156.26,13.05 PR807.1 156.4,12.04 PR808.1
FFS_INT2: length 310
  TOP w0.109: v2(266.11,94.32) 266.11,94.01 264.8,92.7 264.8,84.26 257.74,77.2 217.03,77.2 206.75,87.47 205.28,87.47 204.58,86.77 200.82,86.77 200.17,87.42 198.27,87.42 190.97,80.12 189.08,80.12 187.69,78.73 185.18,78.73 183.69,77.23 183.69,73.26 164.77,54.34 164.77,49.54 164.94,49.36 164.94,48.92 v3(162.34,46.31) 160.98,44.95 160.98,41.38 163.93,38.43 165.61,38.43 166.76,37.27 168.13,37.27 168.57,36.83 RH378.2 168.63,36.83 169.49,37.69 171.51,37.69 172.15,37.05 173.88,37.05 174.06,37.23 174.52,37.23 UH1.BE14
  IN3 w0.081: v2(343.45,32.38) 343.45,34.46 346.7,37.71 346.7,40.43 345.05,42.08 345.05,45.85 345.87,46.68 351.18,46.68 352.16,47.65 352.16,48.42 351.89,48.68 342.5,48.68 341.21,47.4 318.72,47.4 316.85,49.27 312.94,49.27 287.14,75.08 v2(281.31,75.08)
  IN4 w0.102: v2(281.31,75.08) 281.31,75.81 265.45,91.66 265.45,93.49 266.11,94.15 v2(266.11,94.32)
  BOTTOM w0.109: LGA1.11 341.98,28.11 342.07,28.19 342.07,31.92 342.73,32.58 343.24,32.58 v2(343.45,32.38) 343.45,31.14 342.84,30.54 342.84,29.27 343.79,28.31 QN1.2
FFS_INT2_Q: length 42.9
  IN3 w0.081: v2(344.98,28.49) 344.73,28.49 342.8,26.56 342.8,19.91 342.21,19.32 342.21,10.75 340.48,9.01 v2(340.48,7.8)
  IN4 w0.102: v2(340.48,7.8) 342.1,9.42 346.05,9.42 346.54,9.92 348.22,9.92 348.74,9.39 353.78,9.39 355.15,8.02 JNGFF4.32
  BOTTOM w0.109: v1(345.82,28.2) 345.82,28.69 RN1.2 344.98,28.74 v2(344.98,28.49) 344.8,28.31 344.69,28.31 344.44,28.06 QN1.3
FIVR_EN: length 4.1
  BOTTOM w0.109: RC217.1 277.91,91.39 RC218.2 277.66,90.33 RC219.2 277.64,90.21 277.14,89.72 277.14,88.49 v1(277.33,88.29)
FIVR_EN_R: length 28.3
  TOP w0.109: v2(280.15,78.97) 280.15,79.31 RC126.2 ; JXDP1.45 284.2,92.45 284.06,92.31 283.32,92.31 v2(283.17,92.45)
  IN1 w0.102: v2(283.17,92.45) 284.62,91 284.62,89.84 285.4,89.07 285.4,79.21 283.89,77.7 281.61,77.7 280.76,78.56 280.56,78.56 v2(280.15,78.97)
  BOTTOM w0.109: RC217.2 RC132.2 280.03,92.28 280.25,92.05 v1(281.66,92.05) 282.78,92.05 v2(283.17,92.45)
FRS_ON1_R: length 1.7
  BOTTOM w0.109: UT9.3 47.34,30.95 47.82,30.47 RT570.2
FRS_ON2_R: length 7.5
  BOTTOM w0.109: RT574.2 66.83,24.59 66.14,23.91 v1(64.3,23.91) 64.27,23.91 63.54,24.64 61.76,24.64 61.24,24.12 UT11.3
FRS_ON_P1: length 4.6
  BOTTOM w0.109: RT617.1 49.28,30.25 RT570.1 49.98,30.47 v1(50.42,30.92) 50.63,31.13 51.53,31.13 51.62,31.04 UT5.L7
FRS_ON_P2: length 31.6
  TOP w0.109: v2(51.81,31.72) 52.21,31.32 v1(52.21,31.3)
  IN3 w0.081: v2(68.71,25.34) 68.71,25.37 68.09,25.99 67.21,25.99 66.63,26.57 65.34,26.57 64.47,25.71 58.97,25.71 58.44,26.24 58.44,26.97 58.02,27.39 58.02,27.54 57.66,27.9 57.66,29.52 58.61,30.47 58.61,31.36 58.83,31.57 58.83,32.34 58.62,32.55 56.87,32.55 56.78,32.46 52.55,32.46 v2(51.81,31.72)
  BOTTOM w0.109: RT574.1 68.23,24.59 68.71,25.07 v2(68.71,25.34) 68.71,25.39 68.25,25.85 67.16,25.85 66.74,25.43 66.74,25.14 66.14,24.54 RT618.1 ; v2(51.81,31.72) 52,31.54 UT5.L8
GC6_THM_ON: length 232.7
  TOP w0.109: RH6.1 178.38,14.07 174.11,9.8 166.38,9.8 165.22,10.96 v2(165.22,11.35) ; v1(86.16,13.05) 85.97,12.86 v2(85.33,12.86)
  IN2 w0.081: v2(12.15,11.87) 12.15,11.11 16.63,6.63 16.63,4.48 17.62,3.5 22.27,3.5 25.98,7.21 25.98,7.78 27.87,9.67 45.08,9.67 45.52,10.11 45.52,15.07 46.59,16.14 50.08,16.14 50.51,16.57 53.07,16.57 54.82,18.32 57.63,18.32 58.2,18.88 59.96,18.88 60.46,18.38 60.46,18.37 61.62,17.22 61.62,16.17 64.91,12.88 75.55,12.88 v2(79.47,8.96)
  IN3 w0.081: v2(85.33,12.86) 85.06,13.13 80.58,13.13 79.47,12.02 v2(79.47,8.96)
  IN4 w0.102: v2(130.93,14.59) 132.32,15.99 138.05,15.99 139.06,14.98 144.54,14.98 147.49,17.92 152.64,17.92 154.51,16.06 155.87,16.06 156.63,15.3 158.27,15.3 160.47,13.1 161.22,13.1 162.43,11.89 163,11.89 163.34,11.55 165.02,11.55 v2(165.22,11.35)
  BOTTOM w0.109: v2(130.93,14.59) 130.71,14.37 130.71,12.88 125.8,7.97 125.8,6.5 124.48,5.18 123.21,5.18 122.87,5.52 122.87,8.11 124.34,9.58 125.77,9.58 128.54,12.36 128.54,13.05 128.35,13.24 128.35,13.65 127.57,14.43 127.57,15.15 127.13,15.59 126.4,15.59 126.07,15.25 126.07,13.81 125.03,12.76 124.81,12.45 124.81,11.72 124.11,11.01 123.66,11.01 122.75,10.1 120.66,10.1 118.46,12.3 118.46,12.88 117.84,13.5 117.84,14.83 117.45,15.22 116.8,15.22 116.54,14.95 116.54,14.24 116.22,13.93 109.47,13.93 108.98,13.44 92.89,13.44 91.96,12.51 85.69,12.51 v2(85.33,12.86) ; UE12.7 12.04,11.76 v2(12.15,11.87)
GPIO0: length 7.4
  BOTTOM w0.109: RR201.2 30.07,12.87 29.73,13.21 29.73,13.81 v1(30.05,14.13) 30.05,14.36 29.48,14.92 26.98,14.92 26.49,15.42 UR1.42
GPIO_0: length 4.2
  BOTTOM w0.109: RT505.1 36.83,45.93 36.47,45.56 35.45,45.56 35.07,45.18 34.99,45.18 34.2,44.39 UT1.W1
GPIO_1: length 5.3
  BOTTOM w0.089: 34.43,43.89 34.43,43.45 UT1.W2
  BOTTOM w0.109: RT506.1 37.63,46.19 37.02,45.59 36.92,45.59 36.66,45.33 35.49,45.33 35.14,44.97 35.09,44.97 34.43,44.32 34.43,43.89
GPIO_3: length 5.3
  BOTTOM w0.109: RT507.1 38.23,45.86 37.64,45.86 37.05,45.27 v1(37.05,45.24) 36.89,45.09 35.54,45.09 34.66,44.21 UT1.Y1
GPP_B23: length 7.9
  TOP w0.102: v2(168.87,27.05) 168.87,27.33 169.1,27.56 v1(169.74,27.56) 170.08,27.56 170.19,27.67 171.68,27.67 171.79,27.78 173.74,27.78 173.96,27.57 174.28,27.57 174.31,27.54 174.98,27.54 UH1.BD33
  BOTTOM w0.109: v2(168.87,27.05) 168.87,27.37 RH329.1
GPP_C5: length 8.4
  TOP w0.102: 170.57,32.06 170.7,31.93 UH1.BF24
  TOP w0.109: 170.57,32.06 169.93,32.7 168.53,32.7 v1(168.41,32.58) 168.07,32.58 167.95,32.45 v2(167.95,32.22)
  BOTTOM w0.109: v2(167.95,32.22) 167.34,32.22 167.13,32.43 RH78.2
GPP_D12: length 15.2
  TOP w0.089: UH1.AN18 v2(180.56,35.2)
  IN2 w0.081: v2(180.56,35.2) 180.52,35.24 180.52,38.57 180.88,38.94 181.06,38.94 181.29,39.17 181.29,40.61 180.68,41.23 180.68,46.95 v2(180.99,47.26)
  BOTTOM w0.109: v2(180.99,47.26) 180.16,46.44 RH349.1
GPP_F22: length 3.6
  TOP w0.109: v2(178.95,17.88) 178.95,19.32 178.85,19.41 UH1.AT49
  BOTTOM w0.109: RC444.1 178.62,17.55 v2(178.95,17.88) 179.08,17.88 179.49,17.47 v1(179.73,17.47)
GPP_H12: length 5.2
  TOP w0.109: RH615.2 188.23,17.21 188.21,17.23 v1(188.21,17.79) 187.85,18.15 187.37,18.15 186.19,19.32 186.19,19.64 186.42,19.87 186.42,20.43 UH1.AB47
GPP_H15: length 4.7
  TOP w0.109: RH601.2 187.35,17.21 187.33,17.23 187.33,17.32 v1(186.91,17.73) 186.65,17.99 186.65,18.58 185.84,19.39 185.84,20.65 UH1.AC47
GPP_J1: length 10.8
  TOP w0.076: RH616.2 173.81,45.85 174.89,45.85 175.15,46.11 176.05,46.11 176.51,45.64 176.51,45.35 177.25,44.61 177.25,43.07 177.41,42.91 177.41,42.33 UH1.AY3
  TOP w0.109: RH616.2 173.27,46.5 173.27,47.36 173.4,47.49 174.36,47.49 v1(174.96,48.09)
GPPJ_RCOMP: length 6
  TOP w0.254: RH609.2 170.89,44.8 172.11,44.8 172.62,44.29 172.63,44.29 172.79,44.13 173.15,44.13 173.65,43.63 174.11,43.63 174.49,43.25 UH1.BE1 ; UH1.BE2 174.49,43.04 UH1.BE1 ; UH1.BE1 UH1.BD1
GPS_DISABLE#: length 219.1
  TOP w0.102: UE1.H5 v2(132.73,23.25)
  IN2 w0.081: v2(124.42,6.64) 124.84,6.22 125.49,6.22 125.83,6.56 126.33,6.56 127.87,5.02 129.41,5.02 130.09,4.34 130.09,2.21 130.57,1.73 136.01,1.73 137.42,3.15 137.42,4.41 137.69,4.68 138.79,4.68 139.49,5.38 140.66,5.38 141.1,5.82 143.46,5.82 144.65,7.01 145.81,7.01 148.39,9.6 155.39,9.6 156.45,10.66 157.74,10.66 161.34,7.06 165.41,7.06 166.06,7.7 170.19,7.7 172.51,5.37 176.34,5.37 179.04,2.67 188.58,2.67 189.41,3.5 190.75,3.5 191.55,4.3 197.04,4.3 197.48,4.75 205.14,4.75 206.43,3.46 211.03,3.46 211.82,4.25 211.82,5.35 213.08,6.61 213.74,6.61 214.09,6.96 214.09,8.94 212.44,10.59 212.44,10.98 213.5,12.04 219.88,12.04 220.51,12.67 231.13,12.67 231.47,13.01 237.11,13.01 239.6,10.52 250.88,10.52 253.44,13.08 263.52,13.08 264.08,13.64 264.67,13.64 265,13.32 265,12.56 267.22,10.33 267.22,7.61 269.72,5.1 271.75,5.1 274.13,2.72 282.19,2.72 283.63,4.16 v2(283.63,5.45)
  BOTTOM w0.102: v2(132.73,23.25) 132.33,22.85 131.76,22.85 131.51,22.59 ; 131.51,22.59 131.51,22.65 131.32,22.84 130.25,22.84 RE12.1 ; 131.51,22.59 131.51,22.27 131.28,22.05 130.94,22.05 130.75,21.86 130.75,21.54 130.44,21.23 130.44,20.13 129.83,19.52 v1(129.83,18.79) 129.83,18.33 130.09,18.08 130.09,17.69 129.67,17.27 129.67,15.28 130.24,14.71 130.24,13.08 126.05,8.89 124.9,8.89 124.42,8.42 v2(124.42,6.64)
  BOTTOM w0.109: DZ6.1 283.63,6.35 v2(283.63,5.45)
GPU_DP1_AUXN: length 161.7
  TOP w0.109: CV946.1 74.37,33.47 74.91,33.47 v4(75.16,33.73) 75.49,34.05 75.49,38.03 75.74,38.29 75.74,38.63 76.89,39.78 76.89,40.49 78.58,42.17 78.58,44.42 79.2,45.04 79.2,45.41 v2(79.35,45.56) ; JDGFF1.F5 174.67,81.81 174.84,81.64 174.84,81.29 v2(174.68,81.13)
  IN4 w0.102: v2(79.35,45.56) 79.18,45.73 79.18,45.93 79.34,46.09 80.54,46.09 82.31,44.32 84.15,44.32 85.21,43.26 89.4,43.26 94.98,48.84 109.37,48.84 109.7,48.51 115.03,48.51 116.51,47.03 116.51,45.5 117.92,44.1 118.35,44.1 119.19,43.26 123.09,43.26 126.21,46.37 128.6,46.37 129.83,47.6 133.38,47.6 133.5,47.73 134.63,47.73 135.11,47.25 136.83,47.25 136.88,47.2 138.2,47.2 138.48,46.92 139.1,46.92 139.79,47.6 145.21,47.6 148.09,44.73 150.56,44.73 152.13,43.17 155.62,43.17 156.51,44.06 156.85,44.06 174.07,61.28 175.6,61.28 183.73,69.41 183.73,74.45 182.42,75.76 182.42,77.75 182.04,78.13 181.63,78.13 177.75,82 175.32,82 174.81,81.5 174.81,81.26 v2(174.68,81.13)
GPU_DP1_AUXN_C: length 1.9
  TOP w0.109: UV66.61 72.33,33.51 72.43,33.6 73.28,33.6 CV946.2
GPU_DP1_AUXP: length 161.8
  TOP w0.109: v2(175.26,81.13) 175.1,81.29 175.1,81.62 175.27,81.79 JDGFF1.F4 ; v2(78.48,45.69) 78.87,45.69 78.94,45.62 78.94,45.15 78.32,44.53 78.32,42.28 76.63,40.59 76.63,39.89 75.48,38.74 75.48,38.39 75.22,38.14 75.22,34.16 74.8,33.73 74.3,33.73 74.18,33.86 CV945.1
  IN4 w0.102: v2(175.26,81.13) 175.19,81.13 175.02,81.29 175.02,81.41 175.4,81.79 177.66,81.79 181.54,77.92 181.95,77.92 182.2,77.66 182.2,75.67 183.51,74.36 183.51,69.5 175.51,61.49 173.98,61.49 156.76,44.28 156.42,44.28 155.53,43.38 152.22,43.38 150.65,44.95 148.18,44.95 145.3,47.82 139.7,47.82 139.01,47.14 138.57,47.14 138.29,47.41 136.97,47.41 136.92,47.46 135.2,47.46 134.72,47.95 133.41,47.95 133.29,47.82 129.74,47.82 128.51,46.59 126.12,46.59 123,43.48 119.28,43.48 118.44,44.31 118.01,44.31 116.73,45.59 116.73,47.11 115.11,48.73 109.79,48.73 109.46,49.06 94.89,49.06 89.31,43.48 85.3,43.48 84.24,44.53 82.4,44.53 80.63,46.31 79.25,46.31 78.96,46.02 78.96,45.7 78.84,45.58 78.59,45.58 v2(78.48,45.69)
GPU_DP1_AUXP_C: length 1.8
  TOP w0.109: CV945.2 73.3,33.86 72.38,33.86 72.33,33.91 UV66.62
GPU_DP1_HPD: length 186.3
  TOP w0.109: UV66.16 v2(65.26,37.07) ; v2(189.94,99.37) 189.94,99.58 190.78,100.42 DV32.2 190.14,101.45 189.18,101.45 188.93,101.2 UV62.2
  IN3 w0.081: v2(189.94,99.37) 191.19,98.12 191.19,90.56 190.72,90.09 190.72,84.78 189.04,83.11 189.04,81.97 184.31,77.25 184.31,72.04 162.97,50.7 162.97,47.8 160.49,45.33 156.68,45.33 154.11,47.89 139.61,47.89 138.96,48.54 137.46,48.54 137.24,48.76 130.65,48.76 127.69,45.81 124.43,45.81 122.7,44.08 119.47,44.08 113.81,49.74 95.9,49.74 89.14,42.98 85.12,42.98 83.74,44.35 81.41,44.35 79.25,46.52 77.25,46.52 76.16,47.6 v2(74.55,47.6)
  BOTTOM w0.109: RV898.1 65.27,37.06 v2(65.26,37.07) 65.74,37.07 67.45,38.78 67.45,41.25 v1(68.81,42.61) 69.2,43 69.2,45.22 71.39,47.41 74.35,47.41 v2(74.55,47.6)
GPU_DP1_HPD_GATE: length 35.9
  TOP w0.109: UV62.4 189.58,103.05 189.16,103.47 186.53,103.47 186.37,103.3 185.21,103.3 v1(183.94,102.03) 182.88,100.97 177.87,100.97 v2(177.81,101.03) ; JDGFF1.C9 v2(172.27,87.09)
  IN2 w0.081: v2(172.27,87.09) 171.58,87.09 171.18,87.49 171.18,89.42 170.89,89.71 170.89,90.83 171.76,91.7 171.76,93.91 172.49,94.64 176.84,94.64 178.17,95.97 178.17,96.52 176.87,97.82 176.87,100.09 v2(177.81,101.03)
GPU_DP1_N0: length 172.8
  TOP w0.109: v2(172.87,81.33) 173.04,81.5 173.04,81.69 172.87,81.86 JDGFF1.F8 ; CV861.2 70.18,38.7 70.18,39.49 70.64,39.95 70.64,41.47 v4(70.87,41.7) 71.66,42.49 71.66,43.45 72.25,44.04 74.19,44.04 74.64,44.48 75.01,44.48 75.86,45.33 75.86,45.71 75.54,46.03 74.8,46.03 74.61,45.84 74.61,45.12 74.7,45.03 74.91,45.03 75.02,45.14 v2(75.02,45.26)
  IN4 w0.102: v2(172.87,81.33) 172.9,81.36 172.9,81.86 173.23,82.2 174.48,82.2 175.01,82.74 178.12,82.74 181.85,79.01 182.33,79.01 183.65,77.69 183.65,75.6 184.47,74.78 184.47,69.03 183.11,67.67 183.11,65.2 178.39,60.48 174.91,60.48 173.97,59.54 173.36,59.54 163.32,49.51 163.32,48.62 157.98,43.27 156.82,43.27 155.58,42.03 152.72,42.03 152.34,42.41 151.44,42.41 150.58,43.27 147.96,43.27 147.29,43.94 147.29,44.49 144.92,46.87 140.16,46.87 139.48,46.18 138.19,46.18 137.91,46.46 129.99,46.46 129.18,45.65 126.51,45.65 123.39,42.53 118.89,42.53 118.05,43.37 117.62,43.37 115.79,45.2 115.79,46.72 114.73,47.79 109.37,47.79 109.12,48.04 108.54,48.04 107.85,47.35 105.44,47.35 104.77,48.02 95.2,48.02 89.72,42.54 84.91,42.54 83.89,43.55 81.98,43.55 80.7,44.83 77.48,44.83 76.34,45.98 74.95,45.98 74.83,45.86 74.83,45.45 v2(75.02,45.26)
GPU_DP1_N0_C: length 2
  TOP w0.109: UV66.5 69.66,36.66 69.73,36.73 69.73,37.11 70.19,37.58 70.19,37.72 CV861.1
GPU_DP1_N1: length 179.1
  TOP w0.109: v2(175.85,91.88) 176.02,91.7 176.02,91.25 176.36,90.92 176.36,90.47 176.64,90.19 176.64,90 176.47,89.83 JDGFF1.A2 ; CV863.2 68.51,38.57 68.51,38.72 68.12,39.11 68.12,41.42 68.9,42.2 68.9,44.24 69.21,44.56 v2(69.79,44.56)
  IN4 w0.102: v2(175.85,91.88) 176.46,91.26 176.87,91.26 177.31,91.7 178.02,91.7 178.61,91.1 178.61,89.07 179.01,88.67 179.01,88.04 178.49,87.52 178.49,84.14 179.59,83.04 180.42,82.21 180.92,82.21 184.16,78.97 184.16,75.83 184.99,75 184.99,65.69 176.93,57.63 172.93,57.63 170.84,55.54 170.08,55.54 163.91,49.37 163.91,48.48 158.17,42.74 157.02,42.74 155.79,41.52 152.52,41.52 152.35,41.69 151.18,41.69 150.9,41.97 147.07,41.97 146.36,42.68 146.36,43.23 145.98,43.61 140.66,43.61 138.62,45.65 137.94,45.65 137.77,45.81 136.92,45.81 136.22,45.11 126.7,45.11 123.61,42.02 117.89,42.02 117.39,42.53 117.39,42.88 114.95,45.32 114.95,46.84 114.53,47.27 109.53,47.27 109.27,47.01 108.57,47.01 107.61,46.05 105.95,46.05 105.4,46.6 104.35,46.6 103.73,45.97 98.92,45.97 98.4,45.45 93.44,45.45 91.63,43.65 91.63,43.04 90.54,41.95 90.12,41.95 90.04,42.03 84.69,42.03 84.21,42.52 82.23,42.52 81.12,43.64 78.69,43.64 78.62,43.71 77.39,43.71 76.78,44.32 73.27,44.32 73.13,44.18 70.18,44.18 v2(69.79,44.56)
GPU_DP1_N1_C: length 1.8
  TOP w0.109: CV863.1 68.64,37.67 68.64,37.46 68.59,37.41 68.59,36.97 68.53,36.91 68.53,36.69 68.46,36.62 UV66.8
GPU_DP1_N2: length 159.6
  TOP w0.109: v2(175.86,80.53) 176.04,80.35 176.04,80.1 175.87,79.93 JDGFF1.G3 ; CV865.2 66.86,40.55 66.86,41.29 68.11,42.54 68.11,46.58 68.43,46.89 69,46.89 v2(69.07,46.95)
  IN4 w0.102: v2(69.07,46.95) 69.56,46.45 72.31,46.45 72.93,47.07 75.64,47.07 76.73,48.17 79,48.17 80.1,47.07 82.75,47.07 85.62,44.2 89,44.2 94.63,49.84 115.03,49.84 117.45,47.41 117.45,46.36 119.61,44.2 122.7,44.2 126.76,48.26 129.15,48.26 129.44,48.54 132.81,48.54 133.1,48.84 141.31,48.84 145.35,48.84 147.19,46.99 147.73,46.99 148.2,46.52 148.2,46.05 148.55,45.7 151.02,45.7 151.81,44.9 153.15,44.9 153.72,44.34 155.2,44.34 155.9,45.04 156.5,45.04 174.92,63.45 176.31,63.45 182.2,69.34 182.2,70.76 182.55,71.11 182.55,74.28 181.06,75.78 181.06,77.31 178.66,79.7 176.48,79.7 176.23,79.95 176.23,80.16 v2(175.86,80.53)
GPU_DP1_N2_C: length 4
  TOP w0.109: CV865.1 66.99,39.44 66.99,38.69 67.57,38.1 67.57,37.44 67.44,37.31 67.44,37.08 67.33,36.96 67.33,36.71 67.26,36.64 UV66.11
GPU_DP1_N3: length 161.5
  TOP w0.109: JDGFF1.G6 174.07,79.92 174.24,80.09 174.24,80.31 v2(174.07,80.48) ; v2(69.25,48.86) 69.1,48.71 68.84,48.71 68.58,48.45 68.58,48.23 67.33,46.99 67.33,42.89 66.13,41.69 65.65,41.69 65.08,41.12 65.08,40.62 CV867.2
  IN4 w0.102: v2(69.25,48.86) 69.75,48.36 70.05,48.36 70.47,47.94 72.01,47.94 73.68,49.6 80.7,49.6 81.3,49 82.53,49 83.7,47.82 83.7,47.26 86.04,44.93 88.59,44.93 94.28,50.62 115.27,50.62 118.18,47.72 118.18,46.66 119.92,44.92 122.38,44.92 127.12,49.67 141.76,49.67 141.86,49.56 145.66,49.56 147.48,47.74 148.65,47.74 149.4,46.99 154.23,46.99 155.32,45.9 156.34,45.9 175.99,65.55 177.38,65.55 181.4,69.57 181.4,74.4 179.74,76.06 179.74,77.54 178.43,78.85 175.29,78.85 174.44,79.71 174.44,80.11 v2(174.07,80.48)
GPU_DP1_N3_C: length 4.3
  TOP w0.109: CV867.1 65.16,39.47 65.16,39.01 65.4,38.76 66.24,37.93 66.24,37.13 66.53,36.84 66.53,36.71 66.46,36.64 UV66.13
GPU_DP1_P0: length 172.8
  TOP w0.109: v2(173.45,81.33) 173.3,81.48 173.3,81.69 173.47,81.85 JDGFF1.F7 ; v2(74.15,45.22) 74.35,45.42 74.35,45.95 74.69,46.29 75.64,46.29 76.12,45.82 76.12,45.22 75.12,44.22 74.75,44.22 74.3,43.77 72.36,43.77 71.92,43.34 71.92,42.38 70.91,41.36 70.91,39.85 v4(70.69,39.63) 70.44,39.38 70.44,38.75 CV860.2
  IN4 w0.102: v2(173.45,81.33) 173.11,81.67 173.11,81.77 173.32,81.98 174.57,81.98 175.1,82.52 178.03,82.52 181.76,78.8 182.24,78.8 183.43,77.6 183.43,75.51 184.25,74.69 184.25,69.12 182.89,67.76 182.89,65.29 178.3,60.7 174.82,60.7 173.88,59.76 173.27,59.76 163.11,49.6 163.11,48.71 157.89,43.49 156.73,43.49 155.49,42.25 152.81,42.25 152.43,42.63 151.53,42.63 150.67,43.49 148.05,43.49 147.51,44.03 147.51,44.58 145,47.08 140.07,47.08 139.39,46.4 138.28,46.4 138,46.68 129.9,46.68 129.09,45.86 126.42,45.86 123.3,42.75 118.98,42.75 118.14,43.59 117.71,43.59 116,45.29 116,46.81 114.82,48 109.46,48 109.21,48.25 108.45,48.25 107.76,47.57 105.53,47.57 104.86,48.24 95.11,48.24 89.63,42.76 85,42.76 83.98,43.77 82.07,43.77 80.79,45.05 77.57,45.05 76.43,46.19 74.86,46.19 74.61,45.95 74.61,45.41 74.46,45.26 74.19,45.26 v2(74.15,45.22)
GPU_DP1_P0_C: length 2
  TOP w0.109: UV66.4 70.06,36.67 69.99,36.74 69.99,37.01 70.45,37.47 70.45,37.68 CV860.1
GPU_DP1_P1: length 179.1
  TOP w0.109: v2(176.43,91.88) 176.29,91.73 176.29,91.36 176.62,91.02 176.62,90.58 176.9,90.3 176.9,89.98 177.07,89.81 JDGFF1.A1 ; v2(69.79,43.96) 69.46,44.3 69.32,44.3 69.16,44.13 69.16,42.09 68.38,41.31 68.38,39.22 68.77,38.83 68.77,38.53 68.82,38.49 CV862.2
  IN4 w0.102: v2(176.43,91.88) 176.43,91.6 176.55,91.48 176.78,91.48 177.22,91.91 178.11,91.91 178.83,91.19 178.83,89.16 179.23,88.76 179.23,87.95 178.7,87.43 178.7,84.23 180.51,82.43 181.01,82.43 184.38,79.06 184.38,75.92 185.21,75.09 185.21,65.6 177.02,57.41 173.02,57.41 170.92,55.32 170.17,55.32 164.13,49.28 164.13,48.39 158.26,42.53 157.11,42.53 155.88,41.3 152.43,41.3 152.26,41.47 151.09,41.47 150.81,41.75 146.98,41.75 146.14,42.59 146.14,43.14 145.89,43.39 140.57,43.39 138.53,45.43 137.85,45.43 137.68,45.6 137.01,45.6 136.31,44.9 126.79,44.9 123.7,41.81 117.8,41.81 117.17,42.44 117.17,42.79 114.73,45.23 114.73,46.75 114.44,47.05 109.62,47.05 109.36,46.79 108.66,46.79 107.7,45.83 105.86,45.83 105.31,46.38 104.44,46.38 103.82,45.76 99.01,45.76 98.49,45.24 93.53,45.24 91.85,43.56 91.85,42.95 90.63,41.73 90.03,41.73 89.95,41.82 84.61,41.82 84.12,42.3 82.14,42.3 81.03,43.42 78.6,43.42 78.53,43.49 77.3,43.49 76.69,44.11 73.36,44.11 73.22,43.96 69.8,43.96 v2(69.79,43.96)
GPU_DP1_P1_C: length 1.8
  TOP w0.109: CV862.1 68.9,37.69 68.9,37.36 68.85,37.3 68.85,36.86 68.79,36.8 68.79,36.69 68.86,36.62 UV66.7
GPU_DP1_P2: length 159.6
  TOP w0.109: v2(69.07,46.24) 68.67,46.63 68.54,46.63 68.38,46.47 68.38,42.43 67.13,41.18 67.13,40.44 67.22,40.35 CV864.2 ; v2(176.44,80.53) 176.3,80.39 176.3,80.09 176.47,79.92 JDGFF1.G2
  IN4 w0.102: v2(69.07,46.24) 72.4,46.24 73.02,46.86 75.73,46.86 76.82,47.95 78.92,47.95 80.01,46.86 82.66,46.86 85.53,43.99 89.09,43.99 94.72,49.62 114.94,49.62 117.24,47.33 117.24,46.27 119.52,43.98 122.79,43.98 126.85,48.05 129.24,48.05 129.53,48.33 132.9,48.33 133.19,48.62 141.22,48.62 145.26,48.62 147.1,46.78 147.64,46.78 147.98,46.43 147.98,45.96 148.46,45.48 150.93,45.48 151.72,44.68 153.06,44.68 153.63,44.12 155.29,44.12 155.99,44.82 156.59,44.82 175.01,63.24 176.4,63.24 182.42,69.25 182.42,70.67 182.77,71.02 182.77,74.37 181.27,75.87 181.27,77.4 178.75,79.92 176.57,79.92 176.44,80.04 v2(176.44,80.53)
GPU_DP1_P2_C: length 4
  TOP w0.109: UV66.10 67.66,36.64 67.59,36.71 67.59,36.86 67.71,36.97 67.71,37.2 67.83,37.33 67.83,38.21 v4(67.49,38.55) 67.25,38.79 67.25,39.46 CV864.1
GPU_DP1_P3: length 161.5
  TOP w0.109: CV866.2 65.43,40.37 65.34,40.46 65.34,41.01 65.76,41.43 66.23,41.43 67.59,42.78 67.59,46.88 68.84,48.13 68.84,48.34 68.95,48.45 69.15,48.45 69.25,48.35 v2(69.25,48.14) ; JDGFF1.G5 174.67,79.93 174.5,80.1 174.5,80.33 v2(174.65,80.48)
  IN4 w0.102: v2(174.65,80.48) 174.65,79.8 175.38,79.06 178.52,79.06 179.95,77.63 179.95,76.15 181.61,74.49 181.61,69.48 177.47,65.33 176.07,65.33 156.43,45.69 155.23,45.69 154.14,46.78 149.31,46.78 148.56,47.52 147.39,47.52 145.57,49.34 141.77,49.34 141.67,49.45 127.21,49.45 122.47,44.71 119.83,44.71 117.96,46.57 117.96,47.63 115.18,50.4 94.37,50.4 88.68,44.71 85.95,44.71 83.49,47.17 83.49,47.73 82.44,48.78 81.21,48.78 80.61,49.39 73.77,49.39 72.1,47.72 70.38,47.72 69.96,48.14 v2(69.25,48.14)
GPU_DP1_P3_C: length 4.3
  TOP w0.109: CV866.1 65.42,39.49 65.42,39.12 v4(65.66,38.88) 66.5,38.03 66.5,37.24 66.79,36.95 66.79,36.72 66.86,36.65 UV66.12
GPU_DP2_AUXN: length 76.8
  TOP w0.109: JDGFF1.A5 174.67,89.95 174.85,90.13 174.85,90.51 v2(174.56,90.8) ; CV943.1 154.99,43.16 155.59,43.16 156.81,44.38 156.81,46.63 v2(156.26,47.19)
  IN4 w0.102: v2(156.26,47.19) 156.34,47.1 156.52,47.1 176.59,67.18 177.87,67.18 180.63,69.94 180.63,73.98 179.82,74.8 179.59,74.8 177.76,76.63 171.85,76.63 171.22,77.26 171.22,81.22 172.34,82.34 172.34,85.82 172.97,86.44 177.34,86.44 177.73,86.83 177.73,88.35 176.88,89.2 175.57,89.2 175.21,89.56 174.98,89.79 174.98,90.79 174.84,90.93 174.69,90.93 v2(174.56,90.8)
GPU_DP2_AUXN_C: length 3.3
  TOP w0.109: CV943.2 154,43.21 152.8,43.21 152.28,42.68 151.9,42.68 151.76,42.55 UV67.61
GPU_DP2_AUXP: length 76.8
  TOP w0.109: v2(155.94,46.72) 156.36,46.72 156.55,46.53 v4(156.55,45.52) 156.55,44.49 155.48,43.42 154.9,43.42 154.82,43.5 CV944.1 ; JDGFF1.A4 175.27,89.95 175.11,90.11 175.11,90.52 v2(175.39,90.79)
  IN4 w0.102: v2(155.94,46.72) 156.44,46.72 176.68,66.96 177.96,66.96 180.85,69.85 180.85,74.07 179.91,75.02 179.68,75.02 177.85,76.85 171.94,76.85 171.44,77.35 171.44,81.13 172.56,82.25 172.56,85.73 173.06,86.23 177.43,86.23 177.95,86.75 177.95,88.44 176.97,89.41 175.66,89.41 175.2,89.88 175.2,90.6 v2(175.39,90.79)
GPU_DP2_AUXP_C: length 3.3
  TOP w0.109: UV67.62 152.17,42.95 v4(152.49,43.26) 152.69,43.47 153.83,43.47 CV944.2
GPU_DP2_HPD: length 104.3
  TOP w0.109: DV33.2 190.76,98.59 190.54,98.37 189.64,98.37 189.11,97.84 189.11,96.5 189.54,96.06 189.54,94.28 189.41,94.15 189.41,92.95 189.31,92.85 189.31,90.57 189.55,90.33 189.55,88.96 189.11,88.51 v2(188.91,88.51) 188.91,88.21 188.32,87.61 187.25,87.61 186.88,87.24 v1(185.9,87.24) 185.27,87.88 185.27,89.31 184.64,89.94 182.85,89.94 182.77,90.02 182.55,90.02 182.36,90.22 UV61.2 ; UV67.16 v2(144.7,46.25)
  IN1 w0.102: v2(188.91,88.51) 190.12,88.51 192.31,86.32 v2(192.31,85.2)
  IN3 w0.081: v2(192.31,85.2) 192.31,81.52 188.19,77.4 188.19,74.8 186.2,72.81 186.2,71.84 182.19,67.84 182.19,64.53 179.95,62.28 177.1,62.28 176.11,61.29 174.71,61.29 163.66,50.24 163.66,47.38 160.49,44.2 156.88,44.2 153.98,47.11 149.95,47.11 148.52,45.68 145.27,45.68 v2(144.7,46.25)
  BOTTOM w0.109: v2(144.7,46.25) 144.87,46.08 RV897.1
GPU_DP2_HPD_GATE: length 26.4
  TOP w0.109: UV61.4 181.71,89.68 181.14,90.25 180.68,90.25 180.43,90.5 180.43,91.69 180.14,91.99 179.58,91.99 179.05,91.46 v1(179.05,90.86) 179.05,90.16 v2(178,89.1) ; v2(171.85,77.65) 171.67,77.83 JDGFF1.H10
  IN3 w0.081: v2(178,89.1) 177.48,88.59 177.48,86.1 178.89,84.7 178.89,81.47 175.86,78.44 175.72,78.44 174.85,77.58 171.92,77.58 v2(171.85,77.65)
GPU_DP2_N0: length 62.8
  TOP w0.109: CV884.2 151.77,49.26 151.77,50.23 v2(151.55,50.45) ; JDGFF1.A8 172.87,89.83 173.04,90 173.04,90.34 v2(172.91,90.47)
  IN4 w0.102: v2(151.55,50.45) 151.8,50.2 151.8,50.03 152.08,49.75 154.81,49.75 174.94,69.89 174.94,74.1 173.8,75.24 171.21,75.24 169.96,76.49 169.96,89.62 171.75,91.41 172.75,91.41 173.09,91.07 173.09,90.65 v2(172.91,90.47)
GPU_DP2_N0_C: length 5
  TOP w0.109: CV884.1 151.75,48.07 151.75,47.86 151.31,47.42 150.88,47.42 v4(150.56,47.11) 150.38,46.92 149.6,46.92 149.2,46.53 149.2,45.79 149.1,45.68 UV67.5
GPU_DP2_N1: length 49.1
  TOP w0.109: JDGFF1.H2 176.47,77.36 177.41,76.42 177.41,74.13 177.69,73.84 177.95,73.84 v2(178.08,73.7) ; v2(149.77,50.45) 150,50.21 150,49.28 CV886.2
  IN4 w0.102: v2(149.77,50.45) 149.77,49.63 150.37,49.02 155.11,49.02 175.88,69.8 175.88,72.44 177.43,73.98 177.8,73.98 v2(178.08,73.7)
GPU_DP2_N1_C: length 4.5
  TOP w0.109: CV886.1 149.97,48.08 149.97,47.93 149.78,47.73 149.04,47.73 148,46.69 148,45.85 147.9,45.75 UV67.8
GPU_DP2_N2: length 53.5
  TOP w0.109: v2(178.17,72.51) 177.96,72.72 177.13,72.72 176.59,73.26 176.59,75.97 174.67,77.89 JDGFF1.H5 ; CV888.2 148.23,49.28 148.23,50.2 v2(147.99,50.44)
  IN4 w0.102: v2(178.17,72.51) 178.17,72.73 178.07,72.84 177.51,72.84 176.64,71.97 176.64,69.53 155.39,48.27 149.97,48.27 149.16,49.09 148.46,49.09 147.99,49.56 v2(147.99,50.44)
GPU_DP2_N2_C: length 3.8
  TOP w0.109: UV67.11 146.7,45.67 146.8,45.77 146.8,46.6 v4(147.3,47.1) 148.17,47.98 148.17,48.1 CV888.1
GPU_DP2_N3: length 76.6
  TOP w0.109: v2(174.05,87.96) 174.23,88.14 174.23,88.37 174.07,88.53 JDGFF1.B6 ; CV890.2 146.44,49.27 146.44,50.22 v2(146.21,50.45)
  IN4 w0.102: v2(174.05,87.96) 174.24,88.14 174.24,88.55 173.96,88.83 171.43,88.83 170.94,88.34 170.94,87.57 171.82,86.69 171.82,82.55 170.71,81.44 170.71,76.89 171.55,76.04 174.08,76.04 174.85,75.27 178.4,75.27 179.3,74.38 179.3,72.51 177.4,70.62 177.4,69.26 155.68,47.53 149.6,47.53 148.85,48.28 147.69,48.28 146.46,49.52 146.46,50.2 v2(146.21,50.45)
GPU_DP2_N3_C: length 3.4
  TOP w0.109: UV67.13 145.9,45.68 146,45.79 v4(146,46.47) 146,46.91 146.43,47.35 146.43,48.06 CV890.1
GPU_DP2_P0: length 62.8
  TOP w0.109: v2(152.26,50.45) 152.03,50.22 152.03,49.27 CV883.2 ; JDGFF1.A7 173.47,89.81 173.3,89.98 173.3,90.28 v2(173.49,90.47)
  IN4 w0.102: v2(173.49,90.47) 173.31,90.65 173.31,91.16 172.84,91.62 171.66,91.62 169.75,89.71 169.75,76.4 171.12,75.02 173.71,75.02 174.73,74.01 174.73,69.98 154.72,49.97 152.17,49.97 152.01,50.12 152.01,50.2 v2(152.26,50.45)
GPU_DP2_P0_C: length 5
  TOP w0.109: CV883.1 152.02,48.04 152.02,47.75 v4(151.81,47.55) 151.42,47.16 150.99,47.16 150.49,46.66 149.71,46.66 149.46,46.42 149.46,45.79 149.5,45.75 UV67.4
GPU_DP2_P1: length 49.1
  TOP w0.109: v2(150.48,50.45) 150.26,50.23 150.26,49.26 CV885.2 ; JDGFF1.H1 177.07,78.61 176.73,78.27 176.73,77.47 177.67,76.53 177.67,74.23 177.8,74.1 178.02,74.1 178.17,74.26 v2(178.17,74.47)
  IN4 w0.102: v2(178.17,74.47) 177.9,74.2 177.34,74.2 175.67,72.53 175.67,69.89 155.02,49.23 150.46,49.23 149.98,49.72 149.98,50.07 150.36,50.45 v2(150.48,50.45)
GPU_DP2_P1_C: length 4.5
  TOP w0.109: UV67.7 148.3,45.81 148.26,45.84 148.26,46.58 v4(148.72,47.04) 149.15,47.47 149.89,47.47 150.23,47.82 150.23,48.03 CV885.1
GPU_DP2_P2: length 53.5
  TOP w0.109: v2(148.7,50.44) 148.49,50.23 148.49,49.25 CV887.2 ; v2(178.48,73.17) 178.3,72.98 177.24,72.98 176.85,73.37 176.85,76.08 174.93,78 174.93,78.22 175.27,78.56 JDGFF1.H4
  IN4 w0.102: v2(178.48,73.17) 178.37,73.06 177.42,73.06 176.42,72.06 176.42,69.62 155.3,48.49 150.06,48.49 149.25,49.31 148.55,49.31 148.21,49.65 148.21,50.07 148.58,50.44 v2(148.7,50.44)
GPU_DP2_P2_C: length 3.8
  TOP w0.109: CV887.1 148.43,48.01 148.43,47.87 147.06,46.49 147.06,45.77 147.1,45.74 UV67.10
GPU_DP2_P3: length 76.5
  TOP w0.109: CV889.2 146.7,49.26 146.7,50.23 v2(146.93,50.45) ; JDGFF1.B5 174.67,88.54 174.49,88.37 174.49,88.1 v2(174.64,87.96)
  IN4 w0.102: v2(174.64,87.96) 174.45,88.14 174.45,88.64 174.05,89.05 171.34,89.05 170.72,88.43 170.72,87.48 171.6,86.6 171.6,82.64 170.49,81.53 170.49,76.8 171.46,75.83 173.99,75.83 174.76,75.06 178.31,75.06 179.08,74.29 179.08,72.6 177.19,70.71 177.19,69.35 155.59,47.75 149.69,47.75 148.94,48.5 147.78,48.5 146.67,49.61 146.67,50.19 v2(146.93,50.45)
GPU_DP2_P3_C: length 3.4
  TOP w0.109: UV67.12 146.3,45.75 146.26,45.79 146.26,46.81 146.7,47.24 146.7,48.05 CV889.1
GPU_EDP_AUXN: length 114.7
  TOP w0.109: v2(172.25,87.96) 172.44,88.14 172.44,88.32 172.27,88.49 JDGFF1.B9
  IN1 w0.102: v2(172.25,87.96) 172.62,88.33 172.62,88.43 172.53,88.53 171.48,88.53 169.96,87.01 169.96,77.86 171.53,76.29 173.57,76.29 176.57,73.3 176.57,71.52 155.33,50.28 153.82,50.28 152.86,49.32 139.96,49.32 139.49,49.79 136.97,49.79 136.53,49.36 133.1,49.36 132.98,49.23 126.7,49.23 125.1,47.64 125.1,46.46 122.58,43.95 117.1,43.95 116.48,44.56 107.65,44.56 106.68,43.6 104.65,43.6 103.86,42.81 103.86,41.01 v2(102.94,40.09)
  BOTTOM w0.109: v2(102.94,40.09) 103.14,40.28 103.59,40.28 CV828.1
GPU_EDP_AUXN_C: length 2.7
  BOTTOM w0.109: CV828.2 104.78,40.3 105.27,40.3 105.35,40.22 105.73,39.84 106.22,39.84 106.29,39.77 UV64.29
GPU_EDP_AUXP: length 114.8
  TOP w0.109: v2(172.84,87.96) 172.7,88.1 172.7,88.32 172.87,88.49 JDGFF1.B8
  IN1 w0.102: v2(102.94,40.75) 103.3,40.75 103.65,41.1 103.65,42.9 104.56,43.82 106.59,43.82 107.56,44.78 116.57,44.78 117.19,44.16 122.49,44.16 124.88,46.55 124.88,47.73 126.61,49.45 132.89,49.45 133.01,49.57 136.45,49.57 136.88,50.01 139.58,50.01 140.05,49.54 152.77,49.54 153.74,50.5 155.24,50.5 176.35,71.61 176.35,73.21 173.48,76.08 171.44,76.08 169.75,77.77 169.75,87.1 171.39,88.74 172.62,88.74 172.84,88.52 v2(172.84,87.96)
  BOTTOM w0.109: v2(102.94,40.75) 103.15,40.54 103.56,40.54 CV827.1
