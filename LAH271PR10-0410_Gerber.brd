# Allegro board LAH271PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TBTA_I2C_INT#: length 44.8
  TOP w0.109: v2(54.67,28.98) 54.7,28.95 RT511.1 54.7,27.7 v1(55.07,27.32) ; v2(31.31,42.19) 31.51,42.39 RT16.1
  IN2 w0.081: v2(31.31,42.19) 32.4,43.29 34.36,43.29 35.22,42.43 35.22,40.45 37.18,38.48 37.18,37.93 37.8,37.32 37.8,36.89 37.35,36.44 37.35,35.46 38.09,34.72 40.38,34.72 40.53,34.87 40.53,35.28 40.94,35.68 41.31,35.68 41.64,35.36 41.64,34.73 42.08,34.29 43.86,34.29 44.43,33.73 44.43,33.19 44.93,32.69 45.9,32.69 46.54,33.33 46.54,34.3 46.77,34.53 48.28,34.53 v2(48.38,34.62)
  IN3 w0.081: v2(48.38,34.62) 49.04,34.62 49.54,34.12 49.54,32.66 49.31,32.42 49.31,31.63 48.77,31.09 48.77,29.66 49.19,29.24 50.33,29.24 50.62,29.54 52,29.54 52.99,28.55 54.24,28.55 v2(54.67,28.98)
  BOTTOM w0.109: v2(54.67,28.98) 54.87,28.78 UT5.F2 ; UT1.M4 v2(31.31,42.19)
TBTA_SBU1: length 93.5
  TOP w0.102: JUSBC1.B8 5.95,48.02 6.56,48.02 v2(6.69,48.15)
  IN2 w0.094: v2(16.61,46.53) 16.7,46.44 17.52,46.44 18.72,45.24 18.72,42.3 17.65,41.23 17.65,40.16 16.9,39.41 16.9,38.89 16.45,38.43 15.92,38.43 14.52,37.04 14.07,37.04 9.85,32.81 9.85,31.14 12.33,28.66 12.33,28.3 13.23,27.41 17.27,27.41 20.46,30.6 27.96,30.6 29.52,32.17 37.03,32.17 37.61,31.59 38.3,31.59 38.88,32.17 40.13,32.17 40.98,31.33 47.2,31.33 47.5,31.62 48.18,31.62 49.32,30.48 49.67,30.48 50.5,31.31 52.06,31.31 52.42,31.67 52.42,31.96 53.16,32.7 56.45,32.7 56.97,32.18 56.97,30.54 56.97,30.54 56.97,30.52 57.45,30.04 58.33,30.04 58.7,29.67 58.98,29.67 59.3,29.35 59.3,29.02 59.05,28.78 v2(59.05,28.6)
  BOTTOM w0.102: UT5.A3 57.37,29.19 57.43,29.25 57.53,29.25 57.96,28.82 58.45,28.82 58.55,28.72 58.93,28.72 v2(59.05,28.6) ; v2(16.61,46.53) 15.51,47.63 13.52,47.63 13.38,47.49 DT7.6 DT7.5 v1(10.82,47.49) 10.6,47.49 10.25,47.83 7.48,47.83 7.16,48.15 v2(6.69,48.15)
TBTA_SBU2: length 93.5
  TOP w0.102: v2(14.88,45.04) 14.78,45.14 13.74,45.14 13.4,45.49 DT8.1 DT8.9 11.96,45.49 11.6,45.85 11.31,45.85 11.18,45.72 v1(11.18,45.62) 11.18,45.49 11.09,45.39 10.8,45.39 10.64,45.55 10.64,45.83 10.48,45.99 10.12,45.99 9.96,46.15 8.15,46.15 8.03,46.27 7.55,46.27 7.55,46.28 JUSBC1.A8
  IN2 w0.094: v2(14.88,45.04) 15.03,45.18 15.03,45.41 14.77,45.66 14.77,45.76 14.96,45.95 15.09,45.95 15.3,45.75 15.45,45.75 15.56,45.86 15.56,46.01 15.38,46.2 15.38,46.33 15.6,46.55 15.75,46.55 16.19,46.11 17.58,46.11 18.52,45.16 18.52,42.38 17.45,41.31 17.45,40.25 16.7,39.49 16.7,38.97 16.36,38.63 15.84,38.63 14.44,37.23 13.99,37.23 9.65,32.89 9.65,31.06 12.14,28.58 12.14,28.22 13.15,27.21 17.35,27.21 20.54,30.4 28.04,30.4 29.61,31.97 36.95,31.97 37.53,31.4 38.38,31.4 38.96,31.98 40.05,31.98 40.89,31.13 47.29,31.13 47.55,31.4 48.13,31.4 49.24,30.28 49.75,30.28 50.58,31.12 52.15,31.12 52.62,31.59 52.62,31.88 53.24,32.5 56.37,32.5 56.77,32.1 56.77,30.46 56.78,30.46 56.78,30.44 57.37,29.85 58.25,29.85 58.62,29.48 58.89,29.48 59.1,29.27 59.1,29.1 59.02,29.02 58.83,29.02 v2(58.76,29.09)
  BOTTOM w0.102: UT5.A4 57.46,29.44 57.61,29.44 58.04,29.01 58.68,29.01 v2(58.76,29.09)
TBTA_USB2_RBIAS: length 18.2
  IN2 w0.081: v2(20.67,34.38) 21.43,35.14 25.4,35.14 26.27,34.27 28.62,34.27 29.36,35.01 v2(29.36,35.04)
  IN4 w0.102: v2(16.12,36.77) 16.4,37.04 17.65,37.04 18.23,36.45 18.23,35.48 19.34,34.38 v2(20.67,34.38)
  BOTTOM w0.102: UT1.H19 v2(29.36,35.04)
  BOTTOM w0.109: v2(16.12,36.77) 16.12,37.12 RT41.2 v1(17.39,37.42)
TBTB_CC1: length 75.7
  TOP w0.254: v2(6.69,62.6) 6.54,62.6 6.41,62.73 JUSBC1.1B5
  TOP w0.508: v2(53.31,31.48) 53.07,31.48 51.73,32.82 50.48,32.82 50.1,33.19 50.1,33.77 48.63,35.25 47.43,35.25 v2(47.28,35.4) 46.79,35.4 46.41,35.78 CT351.2
  IN1 w0.508: v2(29.2,53.36) 28.36,54.19 27.38,54.19 26.99,53.8 24.21,53.8 23.28,54.73 18.02,54.73 v2(17.63,54.33)
  IN3 w0.508: v2(29.2,53.36) 29.2,52.34 28.69,51.84 28.69,50.32 29.25,49.76 30.85,49.76 31.16,50.07 32.5,50.07 33.07,49.5 33.92,49.5 34.07,49.35 36,49.35 36.53,48.82 37.37,48.82 37.72,48.46 38.49,48.46 38.97,47.98 38.97,45.71 38.24,44.98 38.24,42.72 40.16,40.79 40.16,38.95 41.77,37.34 42.7,37.34 43.39,38.03 44.05,38.03 44.96,37.13 45.26,37.13 45.7,36.69 45.7,36.23 46.53,35.4 v2(47.28,35.4) ; v2(11.3,55.43) 11.43,55.29 13.78,55.29 14.73,54.33 v2(17.63,54.33)
  BOTTOM w0.254: 11.57,59.67 11.65,59.58 DT11.1 DT11.9 11.65,57.22 11.53,57.1 11.53,55.66 v2(11.3,55.43) ; v2(53.31,31.48) 53.31,31.59 UT5.K9
  BOTTOM w0.457: v2(6.69,62.6) 7.1,62.6
  BOTTOM w0.508: 11.57,59.67 11.57,60.73 9.7,62.6 7.1,62.6
TBTB_CC2: length 82.2
  TOP w0.254: 13.25,60 13.25,59.68 13.65,59.28 DT12.6 DT12.5 13.65,57.26 v2(13.6,57.22) ; JUSBC1.1A5 7.93,63.97 8.27,63.63 8.5,63.63
  TOP w0.508: v2(48.96,36.67) 48.96,36.24 49.09,36.11 CT353.2 49.48,35.62 49.48,35.34 50.42,34.4 51.05,34.4 53.36,32.09 v2(53.45,32.09) ; v2(47.4,41.48) 47.4,40.94 47.72,40.62 50.01,40.62 50.59,40.04 v2(50.59,39.56) ; 13.25,60 13.25,60.71 10.33,63.63 8.5,63.63
  IN1 w0.508: v2(47.4,41.48) 45.97,42.92 42.31,42.92 41.23,44 41.23,49.93 40.59,50.56 39.47,50.56 38.17,51.87 34.97,52.5 34.11,52.59 32.55,52.59 32.13,52.65 30.8,53.98 28.73,54.83 27.12,54.83 26.73,54.44 24.46,54.44 23,55.9 23,57.52 v2(23.43,57.95)
  IN3 w0.508: v2(13.6,57.22) 13.1,57.73 13.1,61.63 15.22,63.76 17.2,63.76 18.49,62.46 19.19,61.73 19.65,61.27 19.65,60.23 22.36,57.51 22.99,57.51 v2(23.43,57.95)
  BOTTOM w0.254: UT5.K10 53.31,32.09 v2(53.45,32.09)
  BOTTOM w0.508: v2(50.59,39.56) 50.59,38.94 50.21,38.56 50.21,37.37 v1(49.74,36.9) 49.71,36.87 49.05,36.87 48.96,36.78 v2(48.96,36.67)
TBTB_DPSRC_AUX_N_C: length 3.3
  BOTTOM w0.102: UT5.E11 55.51,33.18 55.51,33.86 55.12,34.25 55.12,34.91 54.69,35.33 RT518.1 RT386.2
TBTB_DPSRC_AUX_P_C: length 3.9
  BOTTOM w0.102: RT524.1 56.31,35.82 RT385.2 55.91,35.63 55.35,35.07 v4(55.35,34.56) 55.35,34.35 55.7,33.99 55.7,33.2 UT5.D11
TBTB_HPD: length 41.7
  BOTTOM w0.076: UT5.E10 55.61,32.78 56.01,32.78 56.11,32.88 56.11,33.38
  BOTTOM w0.109: RT620.2 35.61,47.91 35.71,48.01 RT33.1 35.71,48.59 36.2,49.08 36.2,49.83 36.09,49.93 36.09,50.53 36.31,50.75 v1(38.86,50.75) 39.44,50.75 40.39,49.8 40.39,45.93 40.44,45.62 40.47,45.45 41.09,44.12 43.16,42.06 48.14,42.06 48.44,41.76 48.44,41.06 48.77,40.73 50.98,40.73 51.41,40.3 55.32,40.3 55.76,40.73 56.82,40.73 56.99,40.57 56.99,39.71 56.76,39.49 56.51,39.49 56.3,39.28 56.3,38.24 56.85,37.69 56.85,36.82 RT528.2 57.23,36 56.86,35.63 56.58,35.63 56.28,35.33 56.28,34.11 56.11,33.94 56.11,33.38
TBTB_HPD_R: length 6
  BOTTOM w0.109: UT1.T1 32.84,43.69 32.84,44.88 32.72,45 32.72,45.64 34.18,47.1 34.55,47.1 34.88,47.43 34.88,47.71 RT620.1 34.98,47.91 RT642.2
TBTB_I2C_INT#: length 63.7
  TOP w0.109: RT17.1 30.9,42.92 30.9,41.93 v2(31.29,41.54) v1(31.92,41.54) ; RT515.1 57.84,25.38 57.57,25.11 53.96,25.11 v2(52.69,26.39)
  IN2 w0.081: v2(31.29,41.54) 30.93,41.91 30.93,42.33 32.11,43.52 34.26,43.52 34.26,43.52 34.45,43.52 35.44,42.52 35.44,40.54 37.43,38.56 37.43,38.03 38.02,37.43 38.02,36.8 37.57,36.35 37.57,35.56 38.19,34.95 39.19,34.95 39.4,35.15 39.4,35.87 39.55,36.02 39.55,36.57 39.71,36.73 40.6,36.73 41.87,35.45 41.87,34.83 42.2,34.5 43.95,34.5 44.63,33.82 44.63,33.28 45,32.91 45.81,32.91 46.31,33.42 46.31,34.39 46.71,34.79 47.74,34.79 47.97,35.02 48.6,35.02 48.88,34.74 48.88,34.22 v2(48.82,34.17)
  IN3 w0.081: v2(52.69,26.39) 52.25,26.82 52.25,27.31 52.11,27.45 51.44,27.45 50.41,28.48 48.88,28.48 44.8,32.56 44.8,33.65 45.12,33.97 46.19,33.97 46.57,33.59 46.57,33.08 46.98,32.67 49.01,32.67 49.34,32.99 49.34,33.95 49.12,34.17 v2(48.82,34.17)
  BOTTOM w0.076: 54.61,27.87 54.61,28.29 UT5.G2
  BOTTOM w0.109: v2(31.29,41.54) 31.28,41.55 31.28,41.57 UT1.M5 ; v2(52.69,26.39) 53,26.7 54.1,26.7 54.61,27.22 54.61,27.87
TBTB_SBU1: length 115.3
  TOP w0.102: JUSBC1.1B8 5.95,64.22 6.56,64.22 v2(6.69,64.35)
  IN2 w0.094: v2(55.37,26.54) 55.02,26.18 54.27,26.18 53.98,26.48 53.63,26.48 52.74,25.59 50.08,25.59 49.14,26.53 43.06,26.53 42.54,26.01 36.47,26.01 35.93,26.55 34.45,26.55 33.82,25.92 32.74,25.92 32.02,25.21 32.02,24.1 30.72,22.8 29.34,22.8 29.11,22.58 28.74,22.58 27.2,21.03 26.4,21.03 23.95,18.58 21.63,18.58 19.71,20.5 18.29,20.5 17.79,21 15.95,21 14.56,22.4 12.25,22.4 10.95,23.7 8.58,23.7 7.98,24.29 7.98,26.32 6.29,28.01 5.52,28.01 3.8,29.74 3.8,32.75 4.46,33.42 4.46,34.73 7.43,37.7 7.43,39.65 3.91,43.17 3.91,51.31 9.49,56.88 13.1,56.88 13.66,56.32 v2(13.81,56.32)
  BOTTOM w0.102: v2(13.81,56.32) 14.01,56.52 14.01,57.4 13.65,57.76 DT11.6 DT11.5 13.65,59.76 13.45,59.96 v1(13.45,60.6) 13.45,60.89 10.5,63.83 7.2,63.83 v2(6.69,64.35) ; v2(55.37,26.54) 55.36,26.54 55.21,26.69 55.21,27.88 UT5.E1
TBTB_SBU2: length 115.3
  TOP w0.102: v2(10.76,55.72) 11.22,56.18 11.22,57.24 11.65,57.68 DT12.1 DT12.9 11.65,60.34 9.63,62.36 8.03,62.36 7.91,62.48 JUSBC1.1A8
  IN2 w0.094: v2(10.76,55.72) 10.45,55.72 10.35,55.82 10.35,56.03 10.46,56.14 11.65,56.14 11.77,56.01 11.77,55.69 11.89,55.58 12.09,55.58 12.19,55.69 12.19,56.02 12.29,56.11 12.52,56.11 12.6,56.04 12.6,55.67 12.69,55.58 12.96,55.58 13.03,55.66 13.03,55.92 13.12,56.01 13.31,56.01 13.4,56.1 13.4,56.29 13.01,56.68 9.57,56.68 4.11,51.23 4.11,43.25 7.63,39.73 7.63,37.62 4.66,34.65 4.66,33.34 3.99,32.67 3.99,29.82 5.6,28.21 6.37,28.21 8.18,26.41 8.18,24.38 8.66,23.9 11.03,23.9 12.33,22.6 14.64,22.6 16.04,21.2 17.87,21.2 18.37,20.69 19.79,20.69 21.71,18.78 23.87,18.78 26.32,21.22 27.12,21.22 28.66,22.77 29.03,22.77 29.26,23 30.64,23 31.83,24.18 31.83,25.29 32.66,26.12 33.74,26.12 34.37,26.74 36.01,26.74 36.55,26.21 42.46,26.21 42.98,26.73 49.22,26.73 50.16,25.79 52.66,25.79 53.55,26.67 54.06,26.67 54.35,26.38 54.58,26.38 v2(54.77,26.57)
  BOTTOM w0.102: UT5.F1 55.02,27.88 55.02,26.82 v2(54.77,26.57)
TBTB_USB2_RBIAS: length 17.1
  IN2 w0.081: v2(19.97,34.99) 20.45,34.99 20.83,35.37 25.49,35.37 26.36,34.5 28.28,34.5 28.71,34.93 v2(28.71,35.04)
  IN4 w0.102: v2(19.97,34.99) 19.8,34.82 19.23,34.82 18.46,35.58 18.46,36.55 16.16,38.85 v2(16.16,39.05)
  BOTTOM w0.102: UT1.F19 v2(28.71,35.04)
  BOTTOM w0.109: RT42.2 16.44,38.77 v2(16.16,39.05)
TDOCK_BATLOW#: length 5.6
  BOTTOM w0.089: 33.51,43.86 33.51,43.44 UT1.U2
  BOTTOM w0.109: RT20.1 35.6,46.04 35.58,46.05 35.49,46.05 35.36,46.18 v1(34.8,46.18) 33.93,46.18 33.27,45.53 33.27,44.1 33.51,43.86
TEST_PWRGD: length 5.3
  TOP w0.109: RT36.1 36.17,38.83 35.69,39.31 35.69,39.82 35.52,39.99 35.08,39.99 34.91,40.16 33.94,40.16 v1(33.78,40.32) 33.49,40.61 33.49,41.12 v2(33.91,41.54)
  BOTTOM w0.109: UT1.W5 v2(33.91,41.54)
THERMTRIP1#: length 89.7
  TOP w0.102: UE1.B12 139.2,28.92 139.76,28.92 139.96,29.11 139.96,29.63 140.72,30.39 140.72,31.04 141.1,31.42 141.64,31.42 142.04,31.02
  TOP w0.109: v2(164.53,49.11) 164.53,54.57 183.41,73.44 183.41,77.43 184.95,78.96 187.06,78.96 187.96,79.86 187.96,83.23 187.56,83.63 187.56,84.3 QV40.1 187.26,85.41 RV817.2 ; 142.04,31.02 143.54,31.02 144.31,30.24 145.3,30.24 147.96,32.91 151.41,32.91 151.65,33.16 151.65,34.38 152.39,35.12 154.9,35.12 v1(156.58,36.8) 158.02,38.24 v2(158.02,41.54)
  BOTTOM w0.109: v2(158.02,41.54) 158.02,44.04 160.04,46.06 160.04,47.27 160.27,47.5 161.91,47.5 163.3,48.9 164.32,48.9 v2(164.53,49.11)
THERMTRIP2#: length 33.5
  TOP w0.102: UE1.H3 v2(131.13,23.25)
  TOP w0.109: CE36.1 RE69.2 155.55,28.88 QE4.1 156.71,27.62 156.25,27.16 156.25,26.4 155.96,26.11 v2(155.96,26.08)
  IN1 w0.102: v2(155.96,26.08) 155.96,26.23 155.68,26.51 155.22,26.51 154.52,25.81 150.49,25.81 149.7,26.6 149.12,26.6 148.36,25.84 147.07,25.84 146.33,25.1 146.16,25.1 144.48,23.43 142.29,23.43 141.33,24.38 139.58,24.38 139.03,23.84 136.68,23.84 136.47,23.63 133.86,23.63 133.69,23.81 131.73,23.81 131.65,23.73 131.17,23.25 v2(131.13,23.25)
TOUCH_SCREEN_DET#: length 147.4
  TOP w0.102: v2(166.61,26.54) 166.96,26.89 167.3,26.89 167.54,27.13 168.39,27.13 169.12,27.86 171.6,27.86 171.71,27.97 173.82,27.97 173.97,27.82 173.98,27.82 174.04,27.76 174.38,27.76 174.41,27.73 175.06,27.73 175.14,27.65 175.28,27.65 175.32,27.6 UH1.BC33
  TOP w0.109: v2(113.86,14.79) 113.86,14.24 v1(113.39,13.77) ; JTS1.5 78.14,36.22 77.72,35.81 RV8.2 78.37,35.11 78.75,35.49 v2(79.93,35.49)
  IN3 w0.081: v2(166.61,26.54) 166.17,26.1 166.17,24.95 165.55,24.33 164.25,24.33 163.32,25.25 162.78,25.25 162.2,24.67 162.2,23.85 160.31,21.96 159.83,21.96 158.3,20.43 158,20.43 157.42,19.85 157.42,19.29 157.98,18.74 157.98,16.47 157.53,16.02 v2(157.53,15.79)
  IN4 w0.102: v2(115.71,11.9) 113.86,13.76 v2(113.86,14.79)
  BOTTOM w0.109: v2(113.86,14.79) 113.23,14.16 109.37,14.16 108.88,13.67 91.19,13.67 89.79,15.08 89.79,20.39 89,21.19 89,22.34 87.82,23.52 87.72,23.52 85.92,25.32 85.92,26.66 85.56,27.02 83.92,27.02 83.54,27.4 83.54,30.24 83.05,30.73 83,30.79 82.95,30.93 82.03,31.86 81.66,31.86 80.9,32.62 80.9,34.05 79.93,35.02 v2(79.93,35.49) ; v2(157.53,15.79) 155.74,15.79 155.29,16.24 148.14,16.24 146.36,14.46 146.36,12.79 143.82,10.25 142.2,10.25 140.28,8.33 140.28,7.76 134.76,2.24 121.69,2.24 118.83,5.1 115.08,5.1 114.02,6.16 114.02,8.8 114.43,9.21 114.9,9.21 115.71,10.02 v2(115.71,11.9)
TOUCH_SCREEN_PD#: length 143.2
  TOP w0.089: UH1.AM45 181.15,21.26 181.19,21.22 181.19,21.1 181.3,20.99 181.3,20.01 181.5,19.81 181.5,19.53
  TOP w0.102: 181.5,19.53 181.5,17.51 181.83,17.19 RH348.2
  TOP w0.109: RH348.2 181.41,16.21 181.41,14.96 180.95,14.5 180.72,14.5 180.27,14.05 180.27,13.57 180.1,13.4 178.99,13.4 174.65,9.07 174.01,9.07 173.34,8.4 173.34,8.35 173.04,8.05 172.54,8.05 172.24,8.36 172.24,9.05 171.96,9.33 166.01,9.33 163.62,11.71 163.62,12.25 164.14,12.77 164.14,13.83 163.06,14.91 158.9,14.91 158.47,15.33 157.32,15.33 156.77,15.88 155.46,15.88 155.27,15.7 155.27,14.15 155.12,14 154.47,14 153.2,15.27 v1(151.64,15.27) 150.2,15.27 149.45,14.53 149.16,14.53 148.92,14.29 148.13,14.29 146.41,12.58 140.34,12.58 139.42,11.66 139.42,11.53 138.68,10.79 137.06,10.79 136.73,11.12 134.62,11.12 134.39,10.89 134.39,10.32 134.27,10.19 133.74,10.19 133.57,10.36 133.57,10.76 132.66,11.66 128.08,11.66 127.77,11.97 126.67,11.97 125.75,12.88 124.07,12.88 123.74,12.56 122.68,12.56 122.45,12.32 120.41,12.32 120.2,12.11 117.62,12.11 116.93,12.79 115.81,12.79 115.35,13.25 115.35,14.12 114.89,14.58 114.89,15.06 112.68,17.28 112.68,18.89 112.07,19.49 110.42,19.49 109.9,20.01 106.87,20.01 105.89,20.99 105.89,21.93 105.53,22.29 105.53,24.22 103.77,25.99 100.14,25.99 v2(99.66,25.5) ; v2(79.3,38.24) 79.14,38.08 JTS1.4
  IN2 w0.081: v2(99.66,25.5) 99.21,25.94 99.21,26.38 98.75,26.84 98.75,27.5 96.57,29.69 96.57,31.1 91.35,36.32 86.84,36.32 86.04,35.52 83.43,35.52 83.16,35.25 81.81,35.25 81.3,35.76 81.3,36.25 v2(79.3,38.24)
TOUCHPAD_INTR#: length 243.8
  TOP w0.102: UH1.BF32 174.05,28.01 173.9,28.17 171.63,28.17 171.54,28.07 171.53,28.07 171.51,28.05 169.04,28.05 168.4,27.41 167.48,27.41 167.16,27.09 166.51,27.09 165.52,26.1 163.99,26.1 163.5,25.61 v1(163.5,24.91) 163.5,24.82 163.24,24.55 v2(163.06,24.55) 162.62,24.55 RH402.2
  TOP w0.109: v2(126.53,24.28) 126.73,24.47 RE318.1 ; JKBTP1.16 286.16,11.45 286.25,11.36 286.25,10.98 286.02,10.75 285.65,10.75 285.57,10.83 281.56,10.83 280.42,11.98 280.42,12.87 279.47,13.82 279.47,14.42 278.6,15.3 277.95,15.3 277.1,16.15 277.1,23.6 274.53,26.16 269.93,26.16 267.03,29.06 260.2,29.06 258.95,27.81 253.84,27.81 v2(253.15,27.12)
  IN3 w0.081: v2(163.06,24.55) 162.78,24.27 162.78,23.84 160.48,21.54 160.05,21.54 158.3,19.79 158.3,16.48 157.93,16.11 157.93,15.52 157.51,15.09 157.51,14.01 159.56,11.95 v2(159.56,11.39) 160.95,11.39 161.93,10.42 165.75,10.42 165.89,10.55 167.96,10.55 168.08,10.67 177.84,10.67 180.01,12.83 182.21,12.83 183.24,11.8 188.26,11.8 189.87,13.41 198.49,13.41 199.79,14.71 209.1,14.71 209.63,14.18 227.65,14.18 232.16,18.7 247.22,18.7 253.15,24.63 v2(253.15,27.12)
  IN4 w0.102: v2(126.53,24.28) 126.14,23.89 124.9,23.89 122.94,21.92 122.94,20.23 122.09,19.38 120.3,19.38 119.96,19.03 119.96,18.42 121.46,16.91 121.46,15.56 126.23,10.79 129.12,10.79 130.12,9.79 134.38,9.79 134.87,9.3 136.55,9.3 136.87,9.61 140.6,9.61 141.78,10.79 145.6,10.79 146.91,12.1 147.54,12.1 148.55,13.11 148.55,13.61 148.15,14.01 148.15,15.35 148.43,15.63 151.64,15.63 153.32,13.95 154.13,13.95 154.72,13.36 155.64,13.36 156.52,12.48 158.2,12.48 158.91,11.77 159.18,11.77 v2(159.56,11.39)
TP_LAN_JTAG_TCK: length 2.7
  BOTTOM w0.109: UL1.35 193.19,125.74 193.7,125.23 v1(193.93,125.23) 194.26,125.23 RL2.2
TP_LAN_JTAG_TDI: length 4.6
  BOTTOM w0.109: T73.1 196.33,127.36 194.32,127.36 193.78,126.82 193.39,126.82 193.27,126.94 UL1.32
TP_LAN_JTAG_TDO: length 4.6
  BOTTOM w0.109: UL1.34 193.27,126.14 193.46,125.95 194.19,125.95 194.61,126.37 196.38,126.37 T74.1
TP_LAN_JTAG_TMS: length 2.4
  BOTTOM w0.109: UL1.33 193.33,126.54 193.36,126.51 v1(193.99,126.51) 194.27,126.51 194.63,126.87 RL1.2
TP_SKL_E30: length 5.4
  TOP w0.076: UC1.E30 220.8,108.9 216.24,108.9 T281.1
TP_SKL_F30: length 16
  TOP w0.076: v2(222.19,110.4) 222.1,110.31 222.1,109.54 UC1.F30
  BOTTOM w0.102: v2(222.19,110.4) 221.66,109.87 219.5,109.87 218.1,111.27 215.1,111.27
  BOTTOM w0.109: T285.1 214.83,111.55 215.1,111.27
TPM_GPIO0: length 1.7
  TOP w0.109: UZ12.29 119.59,26.49 120.52,27.42 RZ112.2
TPM_GPIO4: length 1.6
  TOP w0.109: T284.1 119.3,20.05 119.79,20.54 119.98,20.54 120.1,20.66 UZ12.13
TPM_LPM#: length 1.7
  TOP w0.109: UZ12.3 116.78,24.41 RZ363.2
TPM_PIRQ#: length 65.4
  TOP w0.109: UZ12.18 122.91,22.41 123.43,21.89 v1(123.43,21.59) 123.43,21.46 v2(123.73,21.16) 123.86,21.03 124.29,21.03 RZ69.2
  IN2 w0.081: v2(117.01,18.23) 117.97,18.23 118.97,17.23 118.97,16.81 119.96,15.82 123.75,15.82 124.18,15.39 126.11,15.39 126.65,15.93 131.47,15.93 132.63,17.1 133.01,17.1 133.45,16.66 135.49,16.66 135.76,16.39 137.73,16.39 138.79,17.44 139.73,17.44 140.56,18.27 140.56,18.88 141.59,19.9 144.98,19.9 149.87,24.79 152.54,24.79 153.61,25.86 154.56,25.86 155.24,26.54 156.72,26.54 156.99,26.27 158.42,26.27 159.21,27.06 v2(159.81,27.06)
  BOTTOM w0.109: v2(117.01,18.23) 117.29,18.23 118.94,19.89 119.61,19.89 119.81,19.69 120.12,19.69 120.41,19.98 120.41,20.14 120.98,20.71 122.24,20.71 122.7,21.16 v2(123.73,21.16) ; RC560.2 161.19,28.72 RC561.2 160.5,28.72 159.56,27.78 159.56,27.3 v2(159.81,27.06)
TPM_PIRQ#_R: length 13.7
  TOP w0.102: v2(165.57,29.23) 166.12,29.77 170.71,29.77 170.77,29.83 170.8,29.85 173.29,29.85 173.39,29.96 173.78,29.96 173.98,29.76 174.76,29.76 174.94,29.58
  TOP w0.109: UH1.BD29 174.94,29.58
  BOTTOM w0.109: v2(165.57,29.23) 163.45,29.23 v1(163.07,29.61) 163.06,29.62 RC560.1
TPM_TYPE: length 4.9
  TOP w0.109: v2(178.87,26.53) 177.54,27.86 UH1.AW32
  BOTTOM w0.109: RH379.1 180.75,27.02 v1(180.63,26.9) 179.92,26.9 179.67,26.65 179.16,26.65 179.04,26.53 v2(178.87,26.53)
TRIP_+1VSP: length 3.5
  TOP w0.254: PR801.2 156.36,10.19 155.56,10.19 155.3,10.46 155.3,10.89 155.47,11.06 155.47,11.75 155.18,12.05 PU800.2
TSENSE_2PH: length 8.2
  TOP w0.203: v2(266.46,139.77) PR1166.1 266.06,140.02 266.06,140.72 265.38,141.39 PU1100.25
  BOTTOM w0.203: PC1129.1 267.07,142.91 267.25,142.73 267.25,140.11 v3(267.08,139.94) 266.9,139.77 v2(266.46,139.77)
TSENSE_4PH: length 4.6
  TOP w0.203: PR1165.1 v2(260.58,140.26) 260.98,140.67 PU1100.14
  BOTTOM w0.109: v1(259.73,140.73) 260.1,140.73 v2(260.58,140.26)
  BOTTOM w0.254: PC1127.1 260.06,139.75 v2(260.58,140.26)
TYPEC_CON_SEL1: length 6.8
  TOP w0.109: UH1.BA24 176.84,32.08 v2(176.44,32.48)
  BOTTOM w0.109: v2(176.44,32.48) 176.44,32.72 176.33,32.82 174.95,32.82 174.61,32.49 v1(174.47,32.49) 174.16,32.49 173.92,32.73 172,32.73 RH556.1 RH555.1
TYPEC_CON_SEL2: length 13.4
  TOP w0.109: v2(179.69,32.53) 179.89,32.34 UH1.AP24
  BOTTOM w0.109: RH553.1 169.22,33.51 RH554.1 169.22,33.91 169.44,34.13 170.53,34.13 171.16,33.51 171.16,33.2 171.38,32.99 174.83,32.99 174.88,33.04 177.8,33.04 177.94,32.9 v1(178.75,32.9) 179.42,32.9 179.69,32.63 v2(179.69,32.53)
TYPEC_ID: length 16.5
  TOP w0.109: v2(118.65,27.07) 118.55,27.17 118.55,27.81 118.76,28.03 127.25,28.03 129.63,25.65 130.33,25.65 UE1.F2
  BOTTOM w0.109: v2(118.65,27.07) 118.83,26.89 CE62.1 120,26.02 RE343.2
UART2_RXD: length 160.5
  TOP w0.102: UH1.BD20 175.21,33.53 174.51,33.53 174.34,33.7 172.93,33.7 172.88,33.66 171.57,33.66 171.13,34.09 170.48,34.09 169.93,33.55 167.53,33.55 167.1,33.12 164.95,33.12 164.72,33.34 164.18,33.34 RH361.2
  TOP w0.109: v2(160.74,34.3) 160.77,34.33 160.77,34.78 161.15,35.16 162.33,35.16 RH376.2 162.82,35.64 RH361.2 ; RT552.2 55.98,40.71 v2(55.98,41.39) 55.98,41.63 v1(56.34,41.99) ; v2(78.3,47.13) 77.27,46.1 77.27,44.77 75.92,43.42 75.92,42.58 75.49,42.16 74.53,42.16 v2(74.28,42.41)
  IN2 w0.081: v2(160.74,34.3) 160.74,33.91 160.12,33.29 159.82,33.29 155.88,29.35 149.69,29.35 144.86,24.53 142.35,24.53 142.14,24.32 139.95,24.32 138.46,22.83 138.18,22.83 137.92,22.57 137.92,20.57 137.04,19.68 132.48,19.68 132.22,19.42 131.26,19.42 130.68,20.01 128.84,20.01 128.67,19.83 126.01,19.83 124.28,21.56 122.78,21.56 122.66,21.43 121.11,21.43 119.96,22.58 119.53,22.58 119.06,23.06 118.18,23.06 117.63,23.61 117.63,23.91 116.89,24.65 116.05,24.65 114.66,26.05 109.45,26.05 108.84,26.65 104.65,26.65 100.62,30.68 100.62,30.68 100.22,31.08 100.07,31.08 97.76,33.4 97.76,35.66 97.43,35.99 94.3,35.99 91.82,38.46 88.35,38.46 88.02,38.79 82.52,38.79 80.89,40.43 80.4,40.43 79.69,41.13 75.56,41.13 v2(74.28,42.41)
  IN3 w0.081: v2(78.3,47.13) 78.1,46.93 77.42,46.93 76.12,48.23 69.92,48.23 69.4,47.71 68.56,47.71 67.9,47.06 67.9,43.16 66.45,41.7 66.33,41.58 65.78,41.58 65.08,40.88 57.38,40.88 56.87,41.39 v2(55.98,41.39)
UART2_TXD: length 164.3
  TOP w0.102: RH330.2 163.24,36.1 163.24,35.24 v2(163.42,35.06) 163.42,34.53 164.36,33.58 164.8,33.58 165.07,33.31 166.96,33.31 167.43,33.77 169.89,33.77 170.4,34.29 171.21,34.29 171.65,33.85 172.8,33.85 172.85,33.89 174.42,33.89 174.54,33.77 UH1.BE20
  TOP w0.109: RH330.2 162.82,37.42 RH360.2 ; v2(74.69,42.88) 74.72,42.88 76.77,44.94 76.77,46.4 v2(77.71,47.34) 77.71,49.87 v1(77.41,50.17) ; v2(55.13,41.4) 55.07,41.34 RT551.2
  IN2 w0.081: v2(163.42,35.06) 163.39,35.03 160.51,35.03 159.26,33.78 159.26,33.24 159.26,33.05 155.79,29.58 149.62,29.58 144.77,24.73 141.85,24.73 141.66,24.55 139.9,24.55 139.01,23.66 138.19,23.66 137.92,23.39 137.92,23.09 137.68,22.85 137.26,22.85 137.15,22.74 137.15,20.7 136.92,20.47 133.86,20.47 133.24,19.85 132.41,19.85 132.15,19.59 131.33,19.59 130.68,20.24 128.84,20.24 128.64,20.04 126.12,20.04 124.39,21.77 122.7,21.77 122.57,21.64 121.2,21.64 120.05,22.79 119.62,22.79 118.96,23.45 118.96,23.65 118.5,24.12 117.79,24.12 117.05,24.86 116.49,24.86 114.28,27.07 109.9,27.07 108.25,28.72 102.88,28.72 100.26,31.34 100.11,31.34 97.96,33.48 97.96,35.77 97.55,36.19 95.4,36.19 92.92,38.67 88.43,38.67 88.08,39.02 82.59,39.02 80.97,40.64 80.54,40.64 79.84,41.34 75.89,41.34 74.69,42.54 v2(74.69,42.88)
  IN3 w0.081: v2(55.13,41.4) 55.52,41.8 56.76,41.8 57.47,41.09 64.99,41.09 65.69,41.79 66.24,41.79 66.36,41.91 67.7,43.24 67.7,47.14 68.66,48.1 68.66,49.04 69.58,49.96 71.77,49.96 72.71,49.02 76.03,49.02 v2(77.71,47.34)
UART2RXD: length 4.5
  TOP w0.109: v2(55.35,39.49) 55.35,39.54 55.92,40.11 RT552.1 56.37,40.11 v1(57.14,40.87)
  BOTTOM w0.109: JCCG1.9 55,38.65 55.35,39 v2(55.35,39.49)
UART2TXD: length 5.6
  TOP w0.109: v2(54.76,39.49) 55.07,39.8 RT551.1 55.32,40.11 55.55,40.34 55.55,41.66 55.18,42.03 v1(54.83,42.03)
  BOTTOM w0.109: JCCG1.8 54.5,38.76 54.74,39 54.74,39.48 v2(54.76,39.49)
UG_1.2V: length 16.8
  BOTTOM w0.762: 220.03,4.84 219.42,4.84 217.95,6.32 212.09,6.32 211.67,5.9 210.27,5.9 209.64,6.53 209.64,9.31 208.41,10.54 207.58,10.54
  vias: v1(206.28,10.34) v2(206.08,10.82) v2(206.7,10.82) v2(220.3,4.04) v2(220.91,4.04)
UG_+1VSP: length 5
  BOTTOM w0.762: 151.61,10.65 151.61,10.19 v3(149.7,8.28) 148.81,7.4 148.81,6.82
  vias: v2(148.07,6) v2(148.66,5.99) v2(150.91,11.16) v2(151,11.73)
UGATE_CHG: length 11.8
  IN3 w0.762: 295.65,20.02 292.33,23.34 292.33,29.36 292.36,29.38
  BOTTOM w0.109: v2(290.87,30.96) v1(291.89,30.96)
  vias: v2(290.32,30.73) v2(297.18,20.59) v2(297.19,19.99)
UIM_CLK: length 146.3
  IN2 w0.081: v2(275.05,16.13) 274.9,16.13 274.65,15.88 274.65,15.38 278.62,11.4 284.35,11.4 285.41,10.34 286.56,10.34 287.9,8.99 297.17,8.99 297.25,8.91 v2(297.25,8.82) ; v2(278.46,20.24) 278.59,20.37 278.59,23.41 282.39,27.21 282.39,30.99 286.62,35.21 286.62,37.52 288.7,39.61 288.7,44.51 293.92,49.72 295.51,49.72 297.27,51.49 300.02,51.49 301.44,50.07 306.48,50.07 310.76,45.79 v2(311.1,45.79)
  IN3 w0.081: v2(275.05,16.13) 275.16,16.25 275.16,16.94 v2(278.46,20.24)
  IN4 w0.102: v2(311.1,45.79) 311.53,45.79 311.63,45.7 312.07,45.7 312.63,45.14 314.53,45.14 315.39,44.28 317.35,44.28 318.03,43.6 318.85,43.6 319.72,44.47 321.03,44.47 325.08,40.42 330.63,40.42 334.44,44.24 343.04,44.24 344.54,42.74 346.71,42.74 348.26,44.29 348.26,49.18 347.32,50.12 347.32,51.39 347.68,51.75 v2(347.68,52.09)
  BOTTOM w0.109: JSIM1.4 348.35,47.66 347.66,48.34 CZ38.1 347.18,49.72 347.18,50.52 347.46,50.79 347.46,51.87 v2(347.68,52.09) ; JNGFF2.24 v2(297.25,8.82)
UIM_DATA: length 146.7
  IN2 w0.081: v2(275.05,15.55) 275.18,15.41 275.18,15.39 278.78,11.79 284.51,11.79 285.57,10.72 286.72,10.72 288.06,9.38 297.4,9.38 v2(297.96,8.82) ; v2(311.63,45.29) 310.68,45.29 306.31,49.66 301.27,49.66 299.85,51.08 297.44,51.08 295.68,49.32 294.09,49.32 289.1,44.34 289.1,39.44 287.02,37.36 287.02,35.07 282.79,30.85 282.79,27.04 279,23.24 279,20.36 v2(279.09,20.27)
  IN3 w0.081: v2(275.05,15.55) 275.25,15.55 275.57,15.87 275.57,16.77 279.06,20.27 v2(279.09,20.27)
  IN4 w0.102: v2(348.4,51.55) 348.06,51.55 347.73,51.22 347.73,50.28 348.67,49.34 348.67,44.12 346.88,42.33 344.37,42.33 342.87,43.83 334.61,43.83 330.8,40.02 324.91,40.02 320.86,44.06 319.89,44.06 319.02,43.19 317.86,43.19 317.18,43.87 315.23,43.87 314.36,44.73 312.46,44.73 311.9,45.29 v2(311.63,45.29)
  BOTTOM w0.109: JNGFF2.26 297.75,9.02 v2(297.96,8.82) ; JSIM1.3 349.05,47.62 348.5,48.16 348.5,48.99 CZ39.1 349.26,49.75 349.26,50.57 348.4,51.44 v2(348.4,51.55) v1(347.86,51.55)
UIM_RESET: length 126.1
  TOP w0.109: v2(345.94,51.53) v3(345.07,51.53) ; v2(279.29,15.44) 279.12,15.61 278.11,15.61 277.45,16.27 277.45,18.65 278.06,19.26 279.83,19.26 v2(280.04,19.47)
  IN2 w0.081: v2(345.94,51.53) 345.65,51.53 340.68,46.56 337.2,46.56 335.47,44.83 331.72,44.83 327.21,40.32 320.74,40.32 319.82,39.41 318,39.41 317.31,40.1 317.31,40.88 316.73,41.45 314.79,41.45 314.56,41.68 314.56,42.25 314.37,42.44 311.78,42.44 308.7,45.52 302.65,45.52 300.11,42.98 298.22,42.98 297.65,42.4 292.91,42.4 290.91,40.4 290.91,38.64 290.1,37.82 290.1,35.62 288.65,34.17 288.65,33.18 287.81,32.34 286.81,32.34 284.09,29.61 284.09,26.6 281.07,23.58 281.07,20.5 v2(280.04,19.47) ; v2(296.37,11.51) 296.14,11.28 290.77,11.28 288.11,13.94 279.74,13.94 279.29,14.39 v2(279.29,15.44)
  BOTTOM w0.109: JNGFF2.22 296.75,10.72 296.37,11.1 v2(296.37,11.51) ; v2(345.94,51.53) 346.23,51.24 346.23,50.62 346.15,50.54 346.15,49.77 CZ40.1 346.95,48.97 JSIM1.6
USB2_COMP: length 10.5
  TOP w0.109: v1(196.19,50.77) 196.31,50.77 197.21,49.86 RH193.1 196.65,49.24 196.65,48.52 196.5,48.37 196.5,46.06 193.85,43.42 193.85,43.05 193.98,42.93 193.98,42.33 UH1.F4
USB2_ID: length 6
  TOP w0.109: UH1.G3 193.76,42.43 193.76,42.83 193.64,42.96 193.64,43.57 196,45.93 RH365.1
USB2_VBUSSENSE: length 5.7
  TOP w0.109: UH1.F3 194.26,42.93 194.11,43.08 194.11,43.36 197.02,46.26 RH364.1
USB3_PRX_DTX_N1: length 223.1
  TOP w0.102: UH1.D11 194.96,37.93 195.35,37.93 195.5,38.08 195.54,38.08 195.54,38.08 198.04,38.08 198.34,38.39 198.34,38.73 198.16,38.92 v2(198.16,39.15)
  IN4 w0.102: v2(198.16,39.15) 198.56,38.75 198.83,38.75 199.15,39.07 199.15,39.47 199.68,40.01 202.97,40.01 204.98,38 204.98,36.84 209.88,31.93 211.7,31.93 212.28,31.35 212.88,31.35 216.95,27.29 226.74,27.29 227.81,26.23 231.21,26.23 231.82,26.84 233.5,26.84 234.39,27.72 235.56,27.72 236.45,26.84 248.01,26.84 250.42,24.43 251.2,24.43 256.35,19.28 268.48,19.28 269.67,20.47 273.59,20.47 278.02,16.04 278.02,15.32 279.83,13.51 284.27,13.51 285.24,12.53 288.48,12.53 289.25,11.77 290.02,11.77 291.52,10.27 296.17,10.27 296.3,10.15 307.21,10.15 308.26,11.2 311.05,11.2 311.82,10.43 317.93,10.43 318.23,10.12 322.3,10.12 325.07,12.89 329.93,12.89 330.14,13.11 338.7,13.11 340.58,14.98 340.58,17.92 340.45,18.06 340.45,31.68 344.68,35.91 345.88,35.91 347.14,37.16 347.14,38.41 348.1,39.38 348.1,39.87 352.1,43.86 352.1,49.67 351.26,50.5 351.26,54.93 351.94,55.62 352.81,55.62 v2(353.04,55.84)
  BOTTOM w0.102: JUSB1.5 359.17,57.5 359.07,57.4 358.55,57.4 356.35,55.2 356.22,55.2 356.06,55.35 DI1.1 DI1.9 354.62,55.35 354.48,55.21 354.14,55.21 353.99,55.36 353.52,55.36 v2(353.04,55.84)
USB3_PRX_DTX_N2: length 128.8
  TOP w0.102: RI28.1 299.67,10.07 LI16.2 299.14,10.07 298.84,9.77 298.16,9.77 297.59,10.35 297.59,11.75 297.68,11.85 297.68,12.18 297.44,12.42 297.2,12.42 296.96,12.66 v2(296.96,12.82) ; UH1.B9 195.7,39.25 197.12,39.25 200.32,42.44 201.22,42.44 203.47,44.7 203.85,44.7 203.92,44.62 203.92,44.52 v2(203.59,44.18)
  IN4 w0.102: v2(203.59,44.18) 203.7,44.29 203.7,44.55 203.59,44.67 203.09,44.67 202.91,44.48 202.91,43.61 205.85,40.66 205.85,39.93 207.8,37.98 208.96,37.98 210.95,35.99 210.95,35.01 212.18,33.78 212.39,33.78 212.77,33.4 214,33.4 215.16,32.25 216.23,32.25 219.33,29.14 227.75,29.14 228.69,28.21 230.39,28.21 230.87,28.69 232.18,28.69 233.04,29.55 236.56,29.55 237.42,28.69 248.89,28.69 251.14,26.44 252.13,26.44 256.28,22.29 275.03,22.29 278.31,19.01 280.39,19.01 281.55,17.84 284.55,17.84 288.07,14.32 293.02,14.32 293.6,13.73 295.65,13.73 296.41,12.97 296.41,12.52 296.64,12.29 296.83,12.29 296.96,12.42 v2(296.96,12.82)
USB3_PRX_DTX_N3: length 202.5
  TOP w0.102: UH1.B10 195.55,38.59 195.64,38.68 197.12,38.68 200.3,41.86 202.94,41.86 204.29,43.2 204.77,43.2 205.15,42.82 v2(205.15,42.6) ; JUSB2.5 359.17,35.5 359.07,35.4 358.57,35.4 357.74,34.56 357.74,33.86 357.63,33.76 357.3,33.76 357.14,33.91 DI6.9 DI6.1 355.45,33.91 355.14,33.6 354.48,33.6 352.44,35.65 347.59,35.65 346.42,36.83 345.4,36.83 345.18,37.05 345.18,37.31 v2(345.65,37.78)
  IN4 w0.102: v2(345.65,37.78) 345.65,37.16 345.42,36.93 344.27,36.93 338.91,31.58 338.91,29.37 337.15,27.6 336.24,27.6 334.86,26.23 334.86,23.27 333.44,21.85 333.44,21.05 332.61,20.22 330.79,20.22 330.54,19.98 330.54,18.37 329.05,16.88 323.88,16.88 323.11,16.11 321.07,16.11 320.67,15.71 320.67,14.75 319.85,13.92 318.05,13.92 315.62,11.49 312.22,11.49 311.51,12.2 298.98,12.2 296.93,14.24 293.76,14.24 293.28,14.72 288.24,14.72 284.63,18.33 281.98,18.33 277.6,22.71 256.53,22.71 249.31,29.93 246.21,29.93 245.49,30.64 229.88,30.64 229.02,29.79 219.42,29.79 216.47,32.73 215.33,32.73 214.22,33.85 212.91,33.85 212.57,34.18 212.38,34.18 211.89,34.68 211.89,35.76 208.86,38.78 208.4,38.78 206.39,40.8 206.39,42.48 206.08,42.78 205.34,42.78 v2(205.15,42.6)
USB3_PRX_DTX_P1: length 223
  TOP w0.102: UH1.C11 195.11,38.12 195.27,38.12 195.42,38.27 195.46,38.27 195.46,38.27 197.96,38.27 198.15,38.47 198.15,38.66 197.99,38.82 197.82,38.82 v2(197.74,38.74)
  IN4 w0.102: v2(197.74,38.74) 198.3,38.74 198.48,38.56 198.91,38.56 199.33,38.99 199.33,39.4 199.76,39.82 202.89,39.82 204.79,37.92 204.79,36.76 209.8,31.74 211.62,31.74 212.21,31.16 212.81,31.16 216.87,27.1 226.67,27.1 227.73,26.04 231.29,26.04 231.9,26.65 233.58,26.65 234.46,27.53 235.48,27.53 236.37,26.65 247.93,26.65 250.34,24.24 251.12,24.24 256.27,19.09 268.56,19.09 269.75,20.28 273.52,20.28 277.83,15.97 277.83,15.24 279.75,13.32 284.19,13.32 285.17,12.35 288.41,12.35 289.17,11.58 289.94,11.58 291.44,10.08 296.09,10.08 296.22,9.96 307.28,9.96 308.33,11.01 310.97,11.01 311.74,10.24 317.85,10.24 318.15,9.93 322.38,9.93 325.15,12.71 330.01,12.71 330.22,12.92 338.78,12.92 340.77,14.91 340.77,18 340.63,18.13 340.63,31.6 344.75,35.72 345.96,35.72 347.32,37.08 347.32,38.33 348.29,39.3 348.29,39.79 352.29,43.79 352.29,49.75 351.45,50.58 351.45,54.86 352.02,55.43 352.95,55.43 353.11,55.27 353.11,54.95 v2(353,54.84)
  BOTTOM w0.102: v2(353,54.84) 353.34,55.17 353.91,55.17 354.06,55.02 354.48,55.02 354.65,54.85 DI1.8 DI1.2 356.07,54.85 356.22,55.01 356.43,55.01 358.63,57.2 359.07,57.2 359.17,57.1 JUSB1.6
USB3_PRX_DTX_P2: length 128.8
  TOP w0.102: v2(203.85,45.2) 203.85,45.14 203.6,44.89 203.39,44.89 201.14,42.64 200.24,42.64 197.04,39.44 195.56,39.44 UH1.C9 ; v2(296.96,11.9) 297.28,12.22 297.37,12.22 297.49,12.1 297.49,11.92 297.4,11.83 297.4,10.21 v4(297.75,9.86) 298.03,9.58 298.76,9.58 299.12,9.22 LI16.3 299.68,9.22 RI27.1
  IN4 w0.102: v2(296.96,11.9) 296.76,12.1 296.57,12.1 296.22,12.45 296.22,12.9 295.57,13.55 293.52,13.55 292.94,14.13 287.99,14.13 284.47,17.65 281.48,17.65 280.31,18.82 278.23,18.82 274.95,22.1 256.2,22.1 252.05,26.25 251.07,26.25 248.82,28.51 237.35,28.51 236.48,29.37 233.12,29.37 232.26,28.51 230.95,28.51 230.47,28.02 228.61,28.02 227.68,28.96 219.26,28.96 216.15,32.06 215.08,32.06 213.92,33.22 212.69,33.22 212.31,33.59 212.11,33.59 210.77,34.93 210.77,35.91 208.89,37.79 207.72,37.79 205.67,39.85 205.67,40.58 202.72,43.53 202.72,44.56 203.01,44.85 203.5,44.85 v2(203.85,45.2)
USB3_PRX_DTX_P3: length 202.6
  TOP w0.102: UH1.C10 195.6,38.87 197.04,38.87 200.22,42.05 v4(200.6,42.05) 202.86,42.05 204.21,43.39 v2(205.18,43.39) ; JUSB2.6 359.17,35.1 359.07,35.2 358.65,35.2 357.93,34.48 357.93,33.78 357.71,33.57 357.27,33.57 357.12,33.41 DI6.8 DI6.2 354.41,33.41 352.36,35.46 347.51,35.46 346.34,36.64 345.32,36.64 344.99,36.97 v2(344.99,37.78)
  IN4 w0.102: v2(205.18,43.39) 205.6,42.97 206.16,42.97 206.58,42.55 206.58,40.87 208.48,38.97 208.94,38.97 212.08,35.83 212.08,34.76 212.46,34.37 212.65,34.37 212.98,34.04 214.29,34.04 215.41,32.92 216.55,32.92 219.5,29.97 228.94,29.97 229.8,30.83 245.57,30.83 246.29,30.12 249.39,30.12 256.61,22.9 277.68,22.9 282.06,18.52 284.71,18.52 288.32,14.91 293.36,14.91 293.84,14.43 297.01,14.43 299.05,12.39 311.59,12.39 312.3,11.68 315.54,11.68 317.97,14.11 319.77,14.11 320.49,14.82 320.49,15.79 321,16.3 323.03,16.3 323.8,17.07 328.97,17.07 330.35,18.44 330.35,20.06 330.71,20.41 332.53,20.41 333.25,21.13 333.25,21.93 334.67,23.35 334.67,26.31 336.16,27.79 337.07,27.79 338.73,29.44 338.73,31.66 344.19,37.12 345.34,37.12 345.46,37.24 345.46,37.37 345.06,37.78 v2(344.99,37.78)
USB3_PRX_L_DTX_N2: length 19.5
  TOP w0.102: RI28.2 300.75,10.16 300.84,10.07 LI16.1 301.49,10.07 301.59,9.97 302.53,9.97 303.48,9.02 303.48,7.7 303.65,7.53 303.65,6.07 302.11,4.54 301.92,4.54 301.15,3.76 v4(299.23,3.76) 297.52,3.76 297.49,3.73 296.88,3.73 296.84,3.76 296.34,3.76 295.85,4.26 295.85,4.96 v2(295.61,5.2)
  BOTTOM w0.102: v2(295.61,5.2) 295.61,4.52 296.5,3.63 JNGFF2.21
USB3_PRX_L_DTX_P2: length 19.3
  TOP w0.102: RI27.2 300.75,9.14 300.83,9.22 LI16.4 301.53,9.22 301.68,9.36 301.68,9.64 301.82,9.78 302.45,9.78 303.29,8.94 303.29,7.62 303.46,7.46 303.46,6.15 302.03,4.73 301.84,4.73 301.07,3.95 299.58,3.95 299.54,3.99 298.94,3.99 298.9,3.95 v4(297.17,3.95) 296.42,3.95 296.04,4.34 296.04,4.96 v2(296.27,5.2)
  BOTTOM w0.102: v2(296.27,5.2) 296.19,5.2 295.8,4.81 295.8,4.6 296.69,3.71 296.69,3.43 296.77,3.36 296.94,3.36 297,3.29 JNGFF2.23
USB3_PTX_C_DRX_N1: length 7.9
  BOTTOM w0.102: JUSB1.8 359.17,51.5 359.07,51.39 358.63,51.39 358.17,51.86 358.17,51.91 357.72,52.36 357.72,52.62 v4(356.99,53.35) 356.64,53.7 356.2,53.7 356.05,53.85 DI1.4 DI1.7 354.61,53.85 354.45,53.69 354.29,53.69 354.23,53.76 353.9,53.76 CI16.1
USB3_PTX_C_DRX_N2: length 2.2
  TOP w0.102: CZ28.2 299.17,7.66 299.68,7.66 299.98,7.96 LI17.2 300.56,7.96 RI29.1
USB3_PTX_C_DRX_N3: length 8.1
  TOP w0.102: JUSB2.8 359.17,29.5 359.07,29.39 358.79,29.39 357.93,30.26 357.93,31.85 357.52,32.26 357.26,32.26 357.1,32.41 DI6.7 DI6.4 355.37,32.41 355.21,32.26 355.09,32.26 354.96,32.39 354.6,32.39 354.5,32.49 CI65.1
USB3_PTX_C_DRX_P1: length 7.9
  BOTTOM w0.102: JUSB1.9 359.17,51.1 359.07,51.2 358.55,51.2 v4(357.77,51.99) 357.53,52.22 357.53,52.54 357.09,52.98 357.04,52.98 356.65,53.37 356.65,53.39 356.53,53.51 356.26,53.51 356.11,53.35 DI1.5 DI1.6 354.61,53.35 354.46,53.5 354.21,53.5 354.15,53.57 353.94,53.57 CI13.1
USB3_PTX_C_DRX_P2: length 2.2
  TOP w0.102: RI30.1 300.56,7.11 LI17.3 300.02,7.11 299.7,7.43 299.19,7.43 CZ29.2
USB3_PTX_C_DRX_P3: length 8.1
  TOP w0.102: JUSB2.9 359.17,29.1 359.07,29.2 358.71,29.2 357.74,30.18 357.74,31.77 357.44,32.07 357.29,32.07 357.14,31.91 DI6.6 DI6.5 355.34,31.91 355.18,32.07 355.01,32.07 354.88,32.2 354.6,32.2 354.5,32.1 CI63.1
USB3_PTX_DRX_N1: length 216.4
  TOP w0.102: UH1.F9 v2(193.1,39.36)
  IN4 w0.102: v2(193.1,39.36) 193.9,39.36 194.1,39.57 195.04,39.57 197.97,36.63 201.72,36.63 202.58,35.78 203.91,35.78 210.31,29.38 211.4,29.38 213,27.78 214.21,27.78 216.11,25.87 226.02,25.87 227.05,24.84 231.81,24.84 232.39,25.42 247.29,25.42 249.81,22.9 250.58,22.9 255.68,17.79 270.23,17.79 271.05,18.61 273.47,18.61 275.52,16.56 275.52,14.69 278.63,11.58 280.66,11.58 281.88,10.35 289.46,10.35 291,8.81 295.62,8.81 296.22,8.21 299.19,8.21 299.28,8.3 306.44,8.3 306.54,8.2 307.56,8.2 308.25,8.89 309.18,8.89 309.38,8.69 312.61,8.69 313.2,8.11 317.14,8.11 318.29,9.25 322.54,9.25 325.4,12.11 338.85,12.11 341.52,14.79 341.52,18.12 341.23,18.42 341.23,31.35 345,35.12 346.22,35.12 347.93,36.84 347.93,38.01 348.89,38.97 348.89,39.5 353.58,44.19 353.58,50.72 353.78,50.91 354.05,50.91 v2(354.27,50.69)
  BOTTOM w0.102: v2(354.27,50.69) 353.48,50.69 353.22,50.95 353.22,51.38 v4(352.6,52) 352.3,52.3 351.73,52.87 351.73,53.5 352.06,53.83 352.71,53.83 CI16.2
USB3_PTX_DRX_N2: length 128.4
  TOP w0.089: UH1.C3 v2(194.73,42.4)
  TOP w0.102: CZ28.1 297.69,7.52 294.68,7.52 294.38,7.83 294.38,10.39 294.82,10.84 294.82,11.18 v2(295.34,11.71)
  IN4 w0.102: v2(295.34,11.71) 294.44,10.8 291.56,10.8 290.19,12.18 289.42,12.18 288.65,12.94 285.41,12.94 283.94,14.41 283.94,16 283.48,16.46 278.22,16.46 273.8,20.89 255.45,20.89 251.47,24.86 250.64,24.86 248.23,27.27 236.61,27.27 235.74,28.13 234.08,28.13 233.21,27.27 231.66,27.27 231.03,26.64 228.08,26.64 227.01,27.72 217.11,27.72 212.95,31.88 212.33,31.88 211.81,32.4 211.26,32.4 209.14,34.52 207.88,34.52 206.91,35.48 206.91,36.71 204.09,39.53 204.09,40.31 202.6,41.8 196.34,41.8 195.11,43.03 194.38,43.03 194.21,42.87 194.21,42.4 194.34,42.27 194.59,42.27 v2(194.73,42.4)
USB3_PTX_DRX_N3: length 201
  TOP w0.102: v2(346.73,33.72) 346.98,33.48 347.22,33.48 347.6,33.1 347.6,32.37 348.1,31.87 349.42,31.87 v4(349.94,31.35) 350.14,31.15 352.07,31.15 352.8,31.88 352.8,32.12 353.08,32.4 353.83,32.4 353.92,32.49 CI65.2 ; v2(193.75,38.81) UH1.F11
  IN4 w0.102: v2(193.75,38.81) 193.46,38.52 193.46,38.32 194.23,37.55 195.02,37.55 196.87,35.7 197.86,35.7 198.13,35.97 199.26,35.97 199.83,35.41 199.83,33.77 200.4,33.2 205.89,33.2 207.6,31.5 207.6,30.85 209.93,28.53 211.66,28.53 212.82,27.37 213.94,27.37 215.85,25.46 225.79,25.46 226.84,24.4 232.08,24.4 232.69,25.01 247.07,25.01 254.7,17.37 271.33,17.37 272.09,16.6 272.09,15.22 272.4,14.92 274.57,14.92 278.35,11.13 280.53,11.13 281.81,9.85 283.17,9.85 283.63,9.38 289.52,9.38 290.52,8.38 295.41,8.38 295.99,7.8 300.28,7.8 300.38,7.9 306.22,7.9 307.58,6.53 312.23,6.53 313.4,7.7 318.35,7.7 318.85,8.19 322.05,8.19 324.6,10.74 336.47,10.74 337.08,11.34 338.81,11.34 342,14.52 342,18.32 341.64,18.68 341.64,29.7 343.34,31.4 343.34,31.67 345.17,33.5 346.51,33.5 v2(346.73,33.72)
USB3_PTX_DRX_P1: length 216.4
  TOP w0.102: v2(193.37,39.88) 193.48,39.99 UH1.F7
  IN4 w0.102: v2(354.27,51.4) 353.97,51.1 353.7,51.1 353.4,50.79 353.4,44.27 348.7,39.57 348.7,39.04 347.74,38.09 347.74,36.91 346.14,35.31 344.92,35.31 341.04,31.43 341.04,18.34 341.33,18.05 341.33,14.86 338.77,12.3 325.32,12.3 322.46,9.44 318.21,9.44 317.07,8.29 313.28,8.29 312.69,8.88 309.45,8.88 309.26,9.08 308.17,9.08 307.48,8.39 306.61,8.39 306.51,8.49 299.2,8.49 299.11,8.4 296.3,8.4 295.7,9 291.08,9 289.54,10.54 281.96,10.54 280.74,11.76 278.71,11.76 275.71,14.77 275.71,16.64 273.55,18.8 270.97,18.8 270.15,17.98 255.76,17.98 250.66,23.09 249.89,23.09 247.37,25.6 232.31,25.6 231.73,25.02 227.13,25.02 226.09,26.06 216.19,26.06 214.28,27.96 213.08,27.96 211.48,29.57 210.39,29.57 203.99,35.96 202.65,35.96 201.8,36.82 198.05,36.82 195.11,39.75 194.03,39.75 193.82,39.55 193.45,39.55 193.37,39.63 v2(193.37,39.88)
  BOTTOM w0.102: v2(354.27,51.4) 354.27,51.28 353.87,50.88 353.56,50.88 353.41,51.03 353.41,51.46 353.01,51.86 353.01,51.91 352.49,52.43 352.44,52.43 351.92,52.95 351.92,53.42 352.14,53.64 352.88,53.64 353,53.53 CI13.2
USB3_PTX_DRX_P2: length 128.4
  TOP w0.089: UH1.D4 v2(194.41,41.7)
  TOP w0.102: CZ29.1 297.9,7.33 294.6,7.33 294.18,7.75 294.18,10.47 294.63,10.92 v2(294.63,11.71)
  IN4 w0.102: v2(194.41,41.7) 194.41,41.93 194.02,42.32 194.02,42.95 194.3,43.22 195.19,43.22 196.42,41.99 202.68,41.99 204.28,40.39 204.28,39.61 207.1,36.79 207.1,35.56 207.95,34.71 209.22,34.71 211.33,32.59 211.88,32.59 212.41,32.07 213.03,32.07 217.19,27.9 227.09,27.9 228.16,26.83 230.95,26.83 231.58,27.45 233.13,27.45 234,28.32 235.82,28.32 236.69,27.45 248.31,27.45 250.71,25.05 251.55,25.05 255.53,21.07 273.88,21.07 278.3,16.65 283.56,16.65 284.13,16.08 284.13,14.49 285.49,13.13 288.73,13.13 289.5,12.36 290.27,12.36 291.64,10.99 294.36,10.99 294.63,11.26 v2(294.63,11.71)
USB3_PTX_DRX_P3: length 201
  TOP w0.094: v2(193.08,38.43) UH1.G12
  TOP w0.102: CI63.2 353.92,32.1 353.8,32.21 353.16,32.21 352.99,32.04 352.99,31.8 352.15,30.96 350,30.96 349.54,31.42 349.54,31.48 349.34,31.68 348.02,31.68 347.41,32.29 347.41,33.02 347.14,33.29 346.96,33.29 v2(346.73,33.06)
  IN4 w0.102: v2(346.73,33.06) 346.73,33.24 346.66,33.31 345.24,33.31 343.52,31.59 343.52,31.32 341.82,29.62 341.82,18.76 342.18,18.4 342.18,14.44 338.89,11.15 337.15,11.15 336.55,10.55 324.67,10.55 322.13,8.01 318.92,8.01 318.43,7.51 313.48,7.51 312.31,6.34 307.51,6.34 306.14,7.71 300.46,7.71 300.36,7.61 295.91,7.61 295.34,8.19 290.44,8.19 289.44,9.19 283.56,9.19 283.09,9.66 281.74,9.66 280.45,10.94 278.28,10.94 274.49,14.73 272.32,14.73 271.91,15.14 271.91,16.53 271.25,17.19 254.62,17.19 246.99,24.82 232.77,24.82 232.16,24.21 226.77,24.21 225.71,25.27 215.77,25.27 213.87,27.18 212.74,27.18 211.58,28.34 209.85,28.34 207.41,30.77 207.41,31.42 205.81,33.02 200.32,33.02 199.64,33.69 199.64,35.33 199.19,35.78 198.2,35.78 197.93,35.51 196.79,35.51 194.94,37.36 194.15,37.36 v2(193.08,38.43)
USB3_PTX_L_DRX_N2: length 12.5
  TOP w0.102: v2(297.49,5.21) 297.67,5.03 297.67,4.7 297.88,4.49 300.91,4.49 301.58,5.16 301.82,5.16 v4(302.12,5.47) 302.94,6.28 302.94,7.42 302.65,7.71 302.43,7.71 302.18,7.96 LI17.1 301.64,7.96 RI29.2
  BOTTOM w0.102: v2(297.49,5.21) 297.49,4.36 298,3.85 JNGFF2.27
USB3_PTX_L_DRX_P2: length 12.5
  TOP w0.102: RI30.2 301.64,7.11 LI17.4 302.05,7.11 302.47,7.52 302.57,7.52 302.74,7.35 302.74,6.36 302.23,5.85 302.18,5.85 301.68,5.35 301.5,5.35 300.83,4.68 297.96,4.68 297.86,4.78 297.86,5.03 298.03,5.21 v2(298.15,5.21)
  BOTTOM w0.102: JNGFF2.29 298.5,3.27 298.44,3.33 298.31,3.33 298.19,3.44 298.19,3.93 297.68,4.44 297.68,4.69 297.78,4.79 298.22,4.79 298.3,4.86 298.3,5.07 v2(298.15,5.21)
USB20_N1: length 209.6
  TOP w0.102: v2(192.23,44.95) 192.08,44.81 191.77,44.81 191.55,44.58 191.55,44.2 191.71,44.05 191.71,42.81 191.78,42.74 191.78,42.41 UH1.J3 ; v2(350.28,45.32) 350.54,45.58 350.54,46.79 350.26,47.07 350.26,47.62 350.11,47.76 UI1.2
  IN4 w0.102: v2(192.23,44.95) 192.7,44.48 192.9,44.48 193.14,44.71 193.14,45.93 193.79,46.59 196.04,46.59 199.97,42.66 203,42.66 205.09,40.57 205.09,39.75 207.45,37.39 208.72,37.39 210.36,35.74 210.36,34.7 211.88,33.18 212.13,33.18 212.56,32.76 213.8,32.76 214.46,32.1 214.46,31.73 217.68,28.5 227.42,28.5 228.44,27.49 230.72,27.49 231.29,28.05 232.63,28.05 233.52,28.94 236.23,28.94 237.12,28.05 248.58,28.05 250.88,25.75 251.91,25.75 255.96,21.69 274.67,21.69 278,18.37 280.17,18.37 281.29,17.25 283.81,17.25 284.75,16.31 284.75,14.71 285.74,13.72 288.98,13.72 289.75,12.96 290.51,12.96 291.31,12.16 294.17,12.16 294.95,12.94 295.51,12.94 295.8,12.65 295.8,12.25 295.95,12.1 295.95,11.33 296.44,10.83 306.91,10.83 307.87,11.79 311.34,11.79 312.1,11.03 315.88,11.03 317.28,12.43 318.93,12.43 319.62,13.12 320.83,13.12 321.11,12.84 321.67,12.84 322.8,13.97 325.56,13.97 325.7,14.12 327.9,14.12 334.25,20.46 334.9,20.46 335.62,21.19 335.62,26.24 336.12,26.74 337.85,26.74 339.85,28.74 339.85,31.92 344.44,36.51 345.62,36.51 346.4,37.29 346.4,41.02 349.29,43.91 350.32,43.91 350.56,44.15 350.56,45.04 v2(350.28,45.32)
USB20_N1_R: length 22.7
  TOP w0.102: JUSB1.2 360.67,54.1 360.77,54.2 361.45,54.2 362.17,54.92 362.17,58.86 361.33,59.69 357.81,59.69 v4(355.96,57.84) 355.26,57.14 355.26,56.38 355.22,56.34 355.22,55.76 355.26,55.72 355.26,54.11 354.89,53.74 354.27,53.74 354.12,53.89 DI2.2 353.26,53.47 353.03,53.47 352.81,53.24 352.2,53.24 LI3.4 351.82,53.62 RI60.2
USB20_N2: length 204
  TOP w0.094: UH1.N13 190.66,36.82 190.82,36.82 v2(191.09,37.08)
  TOP w0.102: UI2.2 349.88,37.41 350.03,37.25 350.03,37.07 v2(349.66,36.7)
  IN4 w0.102: v2(191.09,37.08) 191.29,36.88 194.02,36.88 197.91,32.99 199.31,32.99 200.51,31.8 202.87,31.8 203.52,32.44 205.57,32.44 206.76,31.26 206.76,30.22 209.1,27.87 211.46,27.87 214.47,24.86 225.48,24.86 226.56,23.78 232.44,23.78 233.07,24.41 246.58,24.41 254.24,16.75 267.52,16.75 269.94,14.32 274.16,14.32 278.14,10.34 280.2,10.34 280.83,9.71 281.11,9.71 281.57,9.25 282.92,9.25 283.39,8.79 289.27,8.79 290.29,7.76 295.13,7.76 295.68,7.21 300.56,7.21 300.65,7.3 305.79,7.3 307.26,5.83 307.45,5.83 307.45,5.83 308.99,5.83 312.22,5.83 312.35,5.7 313.1,5.7 314.02,4.77 315.43,4.77 315.65,4.55 322.56,4.55 323.2,5.19 323.2,6.81 325.61,9.22 331.82,9.22 333.38,7.66 335.41,7.66 337,9.25 337.89,9.25 343.36,14.72 343.36,15.81 342.6,16.57 342.6,17.3 343.42,18.12 343.42,18.57 342.23,19.76 342.23,29.44 343.79,31.01 344.12,31.01 345.53,32.41 346.88,32.41 350.16,35.7 350.16,36.59 350.05,36.7 v2(349.66,36.7)
USB20_N2_R: length 18.7
  TOP w0.102: RI68.2 353.93,40.36 LI4.4 353.75,39.8 353.58,39.63 353.58,39.49 353.7,39.37 354.74,39.37 354.97,39.15 354.97,38.95 DI3.2 355.07,38.08 354.97,37.98 354.97,37.42 355.28,37.1 358.05,37.1 358.35,37.39 360.87,37.39 361.79,36.48 361.79,32.34 361.52,32.07 361.33,32.07 360.67,31.41 JUSB2.2
USB20_N4: length 216.9
  TOP w0.102: UH1.M10 v2(191.28,38.58)
  IN1 w0.102: v2(17.17,33.24) 17,33.08 16.48,33.08 16.1,32.69 16.1,31.01 19.63,27.48 19.63,25.82 21.09,24.36 25.98,24.36 27.45,22.89 31.22,22.89 32.01,22.09 35.06,22.09 35.6,21.55 42.59,21.55 43.09,21.05 44.03,21.05 46.11,18.97 48.44,18.97 48.48,18.92 49.67,18.92 50.08,18.51 51.91,18.51 52.12,18.31 53.92,18.31 55.52,16.71 56.57,16.71 58.5,18.64 59.67,18.64 60.27,19.24 61.7,20.66 65.88,20.66 67.47,22.25 70.38,22.25 73.35,25.22 76.92,25.22 77.23,25.53 79.25,25.53 79.53,25.8 83.08,25.8 84.19,24.7 87.01,24.7 88.27,23.43 92.04,23.43 92.77,22.71 93.83,22.71 96.32,20.21 97.86,20.21 98.36,19.71 100.88,19.71 101.38,20.21 107.31,20.21 107.72,20.62 109.49,20.62 109.82,20.96 111.17,20.96 111.92,20.21 117,20.21 117.81,19.4 118.33,19.4 118.87,19.94 119.26,19.94 119.7,19.5 120.36,19.5 120.61,19.74 120.61,20.13 121.26,20.79 121.8,20.79 124.35,23.35 126.96,23.35 127.6,23.98 127.6,24.35 130.31,27.07 130.31,28.77 130.76,29.22 136.9,29.22 137.55,28.57 139.27,28.57 139.9,27.94 140.37,27.94 140.92,27.39 142.11,27.39 142.88,28.16 145.04,28.16 145.05,28.17 145.71,28.17 146.58,29.04 147.03,29.04 147.19,28.87 148.02,28.87 148.65,29.5 154.33,29.5 154.79,29.97 156.18,29.97 157.67,31.46 157.67,32.14 158.85,33.32 158.85,33.79 160.42,35.37 161.82,35.37 162.73,34.45 164.51,34.45 165.11,35.06 165.11,35.58 165.39,35.86 165.79,35.86 166.36,36.43 168.54,36.43 169.29,37.18 173.65,37.18 174.34,37.87 174.34,40.34 173.56,41.12 173.56,41.39 175.03,42.85 175.94,42.85 176.71,42.08 189.07,42.08 190.25,40.9 190.76,40.9 191.35,40.31 191.35,39.75 190.86,39.27 190.86,38.99 v2(191.28,38.58)
  BOTTOM w0.102: RT560.2 19.11,33.48 18.89,33.48 18.42,33.01 17.4,33.01 v2(17.17,33.24)
USB20_N5: length 217.9
  TOP w0.102: v2(190.8,43.9) 190.94,44.04 191.18,44.04 191.32,43.9 191.32,43.09 191.24,43.01 191.11,43.01 191.05,43.07 UH1.M1
  IN1 w0.102: v2(17.83,34.67) 17.83,34.28 17.99,34.11 18,34.11 18.01,34.1 18.49,34.1 18.74,33.85 18.74,32.19 20.2,30.73 25.91,30.73 27.54,29.1 27.54,24.89 28.55,23.88 31.35,23.88 32.35,22.88 35.39,22.88 35.92,22.34 42.91,22.34 43.4,21.85 44.36,21.85 46.39,19.81 48.87,19.81 48.98,19.7 50,19.7 50.4,19.3 52.23,19.3 52.44,19.09 54.25,19.09 54.83,18.5 56.94,18.5 58.87,20.43 60.05,20.43 61.05,21.43 61.2,21.43 61.21,21.44 64.19,21.44 66.19,23.45 66.85,23.45 66.89,23.48 67.4,23.48 67.41,23.46 68.47,23.46 68.54,23.54 70.56,23.54 73.02,26 76.58,26 76.9,26.31 78.94,26.31 79.37,26.75 81.06,26.75 81.68,27.37 82.88,27.37 83.13,27.12 86.39,27.12 87.2,26.31 89.71,26.31 91.73,24.29 92.32,24.29 93.01,23.6 95.58,23.6 98.67,20.51 100.53,20.51 101.02,21 106.98,21 107.94,21.96 111.28,21.96 112.24,21 114.1,21 114.64,21.54 117.09,21.54 117.72,20.92 120.25,20.92 120.95,21.62 121.46,21.62 125.41,25.57 127.43,25.57 129.51,27.65 129.51,29.12 130.82,30.43 131.12,30.43 132.13,31.43 133.53,31.43 133.53,31.43 134.49,31.43 135.38,30.55 136.91,30.55 138.17,29.29 139.81,29.29 140.72,30.2 141.88,30.2 142.39,29.68 142.39,29.19 142.6,28.98 145.42,28.98 146.73,30.3 154.01,30.3 154.46,30.75 154.78,30.75 155.47,31.44 156.51,31.44 156.86,31.79 156.86,32.44 158.05,33.63 158.05,34.35 160.94,37.24 164.36,37.24 164.9,36.7 165.52,36.7 166.04,37.22 167.55,37.22 168.57,38.24 169.44,38.24 169.72,37.97 173.08,37.97 173.52,38.4 173.52,39.84 172.69,40.67 172.69,41.64 174.68,43.63 176.15,43.63 176.59,44.07 178.13,44.07 179.28,42.93 190.98,42.93 191.46,43.4 191.46,43.77 191.21,44.03 190.93,44.03 v2(190.8,43.9)
  BOTTOM w0.102: v2(17.83,34.67) 17.9,34.59 17.9,34.18 17.83,34.11 17.74,34.11 17.42,34.43 17.32,34.43 16.93,34.83 16.14,34.83 16.04,34.92 16.04,35.54 16.15,35.65 16.38,35.65 16.44,35.59 RT556.1
USB20_N6: length 3.8
  TOP w0.102: UH1.K7 192.04,40 v2(192.22,39.82)
  BOTTOM w0.102: v2(192.22,39.82) 192.11,40.11 191.97,40.17 191.67,40.48 191.67,41.23 191.92,41.49 191.92,41.86 T313.1
USB20_N8: length 141.3
  TOP w0.102: UH1.G4 193.46,41.66 193.46,41.56 193.41,41.51 193.24,41.51 193.1,41.64 193.1,41.81 193.19,41.89 193.19,42.9 193.02,43.07 193.02,43.39 193.48,43.85 193.48,44.99 193.55,45.06 193.67,45.06 v2(194.11,44.62)
  IN4 w0.102: v2(292.32,4.22) 291.66,3.56 285.86,3.56 285.54,3.88 283.29,3.88 282.37,4.8 276.27,4.8 275.54,5.53 273.19,5.53 273.05,5.38 261.5,5.38 261.28,5.6 261.28,8.4 261.86,8.98 261.86,10.69 259.97,12.57 252.67,12.57 246.75,18.49 233.19,18.49 232.08,19.6 213.73,19.6 209.91,23.42 208.42,23.42 208.23,23.61 207.39,23.61 206.5,24.49 202.09,24.49 199.85,26.74 199.13,26.74 195.09,30.79 192.14,30.79 190.55,32.38 190.55,34.39 190.86,34.7 190.86,35.61 190.47,36.01 190.47,37.6 191.05,38.18 191.49,38.18 192.4,39.1 192.4,39.47 192.73,39.8 192.73,40.08 192.98,40.33 192.98,42.85 194.77,44.64 194.77,44.91 194.67,45.01 194.49,45.01 v2(194.11,44.62)
  BOTTOM w0.102: JNGFF2.9 291.5,3.12 291.35,3.28 291.35,3.36 291.4,3.41 291.7,3.41 291.96,3.67 291.96,4.08 292.1,4.22 v2(292.32,4.22)
