# Allegro board LAH271PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N65854016: length 15.8
  TOP w0.109: RZ1484.1 280.41,4.76 280.41,5.69 v3(280.74,6.02) 280.85,6.13 283.04,6.13 284.99,8.08 287.5,8.08 288.26,8.84 289.21,8.84 289.69,9.33 289.69,10.49 288.66,11.52 JKBTP1.11
N65860844: length 4.9
  BOTTOM w0.109: RZ371.1 334.16,20.59 v1(334.16,20.39) 334.16,20.3 332.65,18.79 JNGFF1.56
N66104468: length 4
  TOP w0.109: QZ3.1 137.17,8.59 RZ25.1 137.73,8.21 138.74,8.21 139.03,7.92 v1(139.28,7.92)
N66179590: length 1.9
  TOP w0.127: PR1216.2 253.11,139.31 253.11,138.98 252.74,138.6 PU1200.17
N66179919: length 2.5
  TOP w0.254: v2(253.1,138.33) 252.87,138.1 PU1200.16
  BOTTOM w0.109: v1(252.57,137.81) 253.09,138.33 v2(253.1,138.33)
  BOTTOM w0.254: v2(253.1,138.33) 252.34,139.09 PR1217.2
N66180146: length 2.4
  TOP w0.254: PU1201.16 245.04,137.99 245.34,138.3 v2(245.47,138.3)
  BOTTOM w0.254: PR1219.2 244.78,137.74 v1(245.05,138) 245.34,138.3 v2(245.47,138.3)
N66180155: length 1.6
  TOP w0.254: PR1218.2 245.81,138.89 245.38,138.89 244.98,138.49 PU1201.17
N66180292: length 2.3
  TOP w0.254: v2(237.71,138.08) 237.63,137.99 PU1202.16
  BOTTOM w0.109: v1(238.29,137.57) 237.78,138.08 v2(237.71,138.08)
  BOTTOM w0.254: PR1221.2 237.21,138.58 v2(237.71,138.08)
N66180301: length 1.3
  TOP w0.254: PU1202.17 237.35,138.49 237.42,138.56 238.32,138.56 PR1220.2
N66180583: length 2.2
  TOP w0.254: v2(229.85,135.68) 229.74,135.57 PU1203.16
  BOTTOM w0.109: v1(229.29,135.17) 229.8,135.68 v2(229.85,135.68)
  BOTTOM w0.254: PR1223.2 229.85,136.12 v2(229.85,135.68)
N66180592: length 1.4
  TOP w0.254: PR1222.2 229.58,136.2 229.45,136.07 PU1203.17
N66492810: length 0.9
  TOP w0.109: UT34.1 118.28,14.56 RT499.2
N66492814: length 2
  TOP w0.109: UT34.2 118.31,13.91 RT500.2 118.14,13.74 v1(118.14,12.74)
N66628280: length 7.6
  TOP w0.109: QV23.2 86.82,31.91 87.11,32.2 87.11,32.96 86.82,33.25 86.82,33.89 RV907.2 87.96,34.22 88.31,33.88 v1(88.31,32.55) 88.31,32.28 88.79,31.79 RV908.1
N66686075: length 3.4
  TOP w0.109: v1(84.76,28.68) 85.03,28.41 RV909.2 86.82,29.29 QV23.5 QV23.6
N66765158: length 3.2
  BOTTOM w0.109: QZ18.5 QZ18.6 337.61,2.26 RZ381.2 336.96,3.65 v1(336.63,3.98)
N66765204: length 3.1
  TOP w0.109: QZ17.5 QZ17.6 339.79,2.26 340.18,2.66 RZ377.2 v1(340.68,1.66)
N66985757: length 15.9
  TOP w0.102: v2(256.21,109.37) 256.08,109.37 UC1.BL31
  BOTTOM w0.102: v2(256.21,109.37) 256.9,108.68 258.9,108.68 259.21,108.99 259.69,108.99 260.96,110.26 269.25,110.26 T297.1
N66985767: length 27.6
  TOP w0.089: v2(239.03,92.47) UC1.AJ8
  BOTTOM w0.109: T298.1 219.43,89.3 220.97,89.3 221.38,89.71 221.38,89.86 221.83,90.32 222.16,90.32 222.77,90.93 226.04,90.93 226.76,91.65 227.34,91.65 228.11,90.88 232.64,90.88 232.89,90.64 236.44,90.64 236.66,90.86 236.66,91.19 237.04,91.56 237.71,91.56 237.87,91.4 238.32,91.4 238.53,91.6 238.53,91.97 v2(239.03,92.47)
N66985777: length 17.6
  TOP w0.102: UC1.G13 222.44,95.82 v2(222.09,95.47)
  BOTTOM w0.109: T299.1 212.28,87.32 215.2,90.25 217.94,90.25 219.61,91.92 222.92,91.92 223.2,92.2 223.2,94.29 222.09,95.41 v2(222.09,95.47)
N66985787: length 9.9
  TOP w0.109: T300.1 213.6,116.72 215.47,114.85 219.23,114.85 UC1.C38
N66985797: length 8.2
  TOP w0.102: UC1.C1 219.25,87.59 218.37,86.71 T301.1
N66985807: length 7.2
  TOP w0.076: UC1.BR2 258.23,88.07 258.23,87.39 258.9,86.72 v2(260.56,86.72)
  BOTTOM w0.102: v2(260.56,86.72) 260.56,85.43 262.07,83.93 T302.1
N66985817: length 5.3
  TOP w0.076: UC1.BP1 257.87,87.46 258.97,86.36 259.83,86.36 259.91,86.28 v2(260.98,86.28)
  BOTTOM w0.102: T303.1 261.51,85.18 260.98,85.71 v2(260.98,86.28)
N66985819: length 7.5
  TOP w0.109: T304.1 213.5,115.61 214.88,114.23 219.07,114.23 UC1.B38
N66985837: length 8.7
  TOP w0.102: UC1.B2 218.2,87.26 212.09,87.26 T305.1
N66986008: length 4.2
  TOP w0.102: T18.1 217.02,109.08 219.04,109.08 UC1.B30
N66986010: length 10.9
  TOP w0.076: v2(218.06,109.77) 218.77,109.77 218.96,109.58 219.33,109.58 219.68,109.23 UC1.C30
  BOTTOM w0.109: T19.1 212.51,110.98 212.56,110.93 215.49,110.93 216.66,109.77 v2(218.06,109.77)
N66986012: length 9.5
  TOP w0.076: UC1.G3 222.36,88.89 222.12,89.12 v2(222.12,89.88)
  BOTTOM w0.102: v2(222.12,89.88) 221.26,89.02 220.63,89.02 216.33,84.73 T21.1
N66986014: length 6.9
  TOP w0.076: v2(222.9,89.26) 223.27,88.89 UC1.J3
  BOTTOM w0.102: T20.1 220.52,86.11 221.28,86.87 221.28,88.43 222.11,89.26 v2(222.9,89.26)
N66986016: length 17.3
  TOP w0.076: UC1.BR31 258.38,109.79 258,109.41 v2(257.53,109.41)
  BOTTOM w0.102: v2(257.53,109.41) 259.76,109.41 260.85,110.5 272.88,110.5
  BOTTOM w0.109: T24.1 272.88,110.5
N66986018: length 13.7
  TOP w0.076: UC1.BH30 254.21,109 v2(254.6,109.39)
  BOTTOM w0.102: v2(254.6,109.39) 254.21,109.78 254.21,111.48 255.03,112.3 255.03,112.66 255.84,113.48 256.76,113.48 257.83,114.55 257.83,119.42 T22.1
N66986020: length 7.9
  TOP w0.076: 262.43,112.59 262.03,112.19 259.89,112.19 259.46,111.76 258.88,111.76 UC1.BR35
  TOP w0.102: 262.43,112.59 T23.1
N66986604: length 8.3
  TOP w0.076: UC1.D1 220.28,87.59 219.38,86.69 219.38,86.66
  TOP w0.102: T1.1 213.86,86.46 219.18,86.46 219.38,86.66
N66986606: length 21
  TOP w0.102: v2(228.06,96.36) 228.36,96.05 UC1.R14
  BOTTOM w0.109: T13.1 215.88,89.93 218.14,89.93 219.32,91.11 222.39,91.11 222.6,91.32 225.8,91.32 226.65,92.18 226.65,95.21 226.97,95.53 227.23,95.53 v2(228.06,96.36)
N66986608: length 11.2
  TOP w0.076: v2(227.02,109.33) 227.02,108.68 UC1.N29
  BOTTOM w0.102: T14.1 226.72,116.47 226.26,116 226.26,110.12 227.02,109.35 v2(227.02,109.33)
N66986610: length 11.5
  TOP w0.076: UC1.AE29 235.7,108.71 v2(235.7,109.36)
  TOP w0.109: T15.1 239.74,116.62 239.31,116.2 238.29,116.2 v2(237.14,115.04)
  IN1 w0.102: v2(235.7,109.36) 235.7,110.03 236.17,110.51 236.17,112.3 236.04,112.43 236.04,112.86 237.21,114.03 237.21,114.98 v2(237.14,115.04)
N66986612: length 26.5
  TOP w0.109: UC1.AA14 233.15,96.05 v2(233.6,96.5)
  BOTTOM w0.109: v2(233.6,96.5) 233.31,96.5 232.18,95.37 232.18,91.74 231.52,91.08 228.19,91.08 227.42,91.85 226.68,91.85 225.95,91.12 222.68,91.12 222.07,90.52 221.75,90.52 221.18,89.95 221.18,89.79 220.9,89.52 216.54,89.52 214.79,87.76 T12.1
N66986614: length 1.3
  TOP w0.102: v2(223.46,104.11) 223.14,104.43 UC1.H24
  BOTTOM w0.102: v2(223.46,104.11) 223.28,104.29 T10.1
N66986616: length 1.2
  TOP w0.102: v2(224.36,104.43) 224.29,104.5 UC1.J24
  BOTTOM w0.109: T9.1 224.42,104.43 v2(224.36,104.43)
N66986618: length 14.3
  TOP w0.076: v2(256.89,110.15) 256.89,110.25 UC1.BN33
  BOTTOM w0.102: v2(256.89,110.15) 256.93,110.11 259.85,110.11 264.7,114.96 264.7,116.58
  BOTTOM w0.109: T11.1 264.7,116.58
N66986620: length 9.1
  TOP w0.076: v2(255.4,111.98) 255.42,111.98 UC1.BL34
  BOTTOM w0.102: v2(255.4,111.98) 255.41,112 255.41,112.53 256.13,113.25 257.14,113.25 258.18,114.28 258.18,118.43 T8.1
N66986622: length 7.2
  TOP w0.076: v2(257.54,111.75) 257.21,112.08 UC1.BN35
  BOTTOM w0.102: 258.7,112.86 257.6,111.75 v2(257.54,111.75)
  BOTTOM w0.109: 258.7,112.86 259.46,113.62 T7.1
N66986624: length 4.5
  TOP w0.076: UC1.BT2 v2(259.56,87.78)
  BOTTOM w0.102: v2(259.56,87.78) 259.56,85.31 T6.1
N66986626: length 6.3
  TOP w0.076: v2(260.14,87.15) 259.16,87.15 258.72,87.59 UC1.BR1
  BOTTOM w0.102: v2(260.14,87.15) 260.14,85.25 261.22,84.18 T5.1
N66986628: length 5.1
  TOP w0.076: v2(220.08,86.85) 220.08,86.85 220.08,86.85 220.08,86.85 220.48,87.26 220.65,87.26 220.84,87.46 220.84,87.61 221.01,87.77 UC1.E2
  BOTTOM w0.102: T4.1 218.49,85.27 220.07,86.85 220.08,86.85 v2(220.08,86.85)
N66986633: length 4.8
  TOP w0.076: UC1.E1 220.71,86.99 v2(220.71,86.9)
  BOTTOM w0.102: T2.1 219.51,85.69 v2(220.71,86.9)
N66986635: length 3.3
  TOP w0.076: v2(243.46,96.79) 243.14,96.47 UC1.AP14
  BOTTOM w0.109: v2(243.46,96.79) 243.46,97.63 T27.1
N66986637: length 14.6
  TOP w0.102: v2(243.07,107.58) 243.08,107.58 243.19,107.68 UC1.AP29
  BOTTOM w0.109: T28.1 246.99,118.92 244.01,115.93 244.01,114.33 243.8,114.13 243.8,113.72 244.01,113.52 244.01,113.01 243.83,112.83 243.83,112.37 244.01,112.2 244.01,111.71 243.8,111.51 243.8,111.1 244.01,110.9 244.01,110.34 243.44,109.78 243.44,107.76 243.27,107.58 v2(243.07,107.58)
N66986743: length 1.6
  TOP w0.102: v2(255.49,107.91) 255.26,107.69 UC1.BK28
  BOTTOM w0.109: T29.1 254.93,107.91 v2(255.49,107.91)
N66986745: length 1.3
  TOP w0.076: UC1.BJ28 v2(254.1,106.91)
  BOTTOM w0.109: T30.1 254.29,106.73 v2(254.1,106.91)
N66986975: length 26
  TOP w0.076: UC1.AT13 244.92,95.4 244.6,95.71 v2(244.54,95.71)
  BOTTOM w0.109: v2(244.54,95.71) 244.54,95.7 244.99,95.25 244.99,91.82 245.91,90.91 248.1,90.91 248.15,90.86 256.34,90.86 256.95,90.25 259.21,90.25 259.47,89.99 260.27,89.99 261.96,88.29 261.96,87.23 T26.1
N66986977: length 25.2
  TOP w0.076: v2(246.38,95.71) 246.7,95.4 UC1.AW13
  BOTTOM w0.109: T25.1 264.5,88.01 262.7,89.81 262.02,89.81 260.7,91.13 258.04,91.13 257.59,90.68 257.08,90.68 256.5,91.25 248.44,91.25 248.34,91.35 247.11,91.35 246.82,91.64 246.82,95.28 v2(246.38,95.71)
N66986979: length 25.2
  TOP w0.076: v2(245.43,95.71) 245.49,95.71 245.81,95.4 UC1.AU13
  BOTTOM w0.109: T31.1 263.23,88.94 262.6,89.57 261.92,89.57 260.6,90.89 258.09,90.89 257.64,90.44 257.03,90.44 256.42,91.05 248.27,91.05 248.21,91.12 246.45,91.12 245.93,91.64 245.93,95.21 v2(245.43,95.71)
N66986981: length 24.4
  TOP w0.076: UC1.AY13 247.58,95.4 v2(247.27,95.71)
  BOTTOM w0.109: v2(247.27,95.71) 247.73,95.25 247.73,92.3 248.58,91.45 256.41,91.45 256.47,91.51 257.31,91.51 257.46,91.36 260.8,91.36 262.12,90.05 262.86,90.05 T32.1
N67164217: length 2.1
  BOTTOM w0.109: CD25.2 235.36,31.79 RD12.1 v1(236.22,32.87)
N67172576: length 2.9
  BOTTOM w0.109: RD37.1 236.51,64.04 RD34.2 RD36.2 v1(233.69,64.04)
N67172641: length 1.9
  BOTTOM w0.109: RD33.1 CD87.2 v1(272.38,81.96)
N67430793: length 115.2
  TOP w0.109: v2(161.69,38.08) 161.92,38.31 162.94,38.31 163.48,37.77 163.48,35.6 163.91,35.17 163.91,34.37 164.36,33.91 RZ545.2
  IN1 w0.102: v2(97.86,47.45) 96.48,47.45 93,43.97 86.2,43.97 83.83,46.33 83.83,49.63 84.01,49.8 84.01,50.39 83.49,50.9 83.02,50.9 82.18,51.74 81.29,51.74 80.73,52.31 80.73,54.8 78.17,57.36 v2(77.43,57.36)
  IN3 w0.081: v2(97.86,47.45) 98.25,47.85 104.57,47.85 105.41,47.01 108.93,47.01 109.05,47.13 114.14,47.13 114.67,46.6 114.67,45.64 117.24,43.07 117.99,43.07 118.61,42.45 123.62,42.45 125.37,44.21 135.22,44.21 136.75,45.73 138.48,45.73 139.15,45.06 140.57,45.06 140.9,44.73 140.9,44.29 141.62,43.56 150.9,43.56 151.86,44.53 152.73,44.53 154.62,42.64 157.9,42.64 158.62,41.92 158.62,41.15 v2(161.69,38.08)
  BOTTOM w0.109: v1(97.42,48.28) 97.86,47.85 v2(97.86,47.45) ; v2(77.43,57.36) QZ1.2 75.73,56.97 CV954.1
N67987936: length 3.7
  TOP w0.109: v1(324.25,27.77) 324.25,26.39 C193.2
  TOP w0.203: C193.2 325.41,25.22 325.41,25.09 325.59,24.92 UZ44.12
N67987971: length 2.5
  TOP w0.109: C195.1 202.55,127.09 v1(202.12,127.51)
  TOP w0.254: C195.1 203.17,126.43 203.18,126.41 UZ7.6
N67988016: length 1.8
  TOP w0.203: UZ44.10 326.39,25.42 325.91,25.9 C192.2
N67988067: length 1.9
  TOP w0.109: UZ9.12 90.89,27.22 90.95,27.28 C202.2
N67988081: length 2.1
  TOP w0.109: UZ9.10 90.84,26.42 91.05,26.22 v1(91.23,26.22) 91.99,26.22 C201.2
N67988141: length 2.6
  TOP w0.254: UZ58.6 317.2,13.17 316.92,13.45 316.92,14.03 C207.1
N67988280: length 1.4
  BOTTOM w0.109: v1(344.23,24.82) 344.23,25.15 343.79,25.58 QN1.5
N69253627: length 3.3
  TOP w0.109: T286.1 198.32,31.32 198.26,31.26 197.8,31.26 197.66,31.4 UH1.A25
N69724739: length 2
  TOP w0.109: QV44.1 95.47,36.58 v1(95.5,36.61) 95.77,36.89 RV742.1
N69725252: length 18.5
  TOP w0.109: RV741.1 108.03,26.2 v1(107.95,26.12) 107.81,25.99 104.77,25.99 102.36,28.4 98.57,28.4 94.82,32.15 QV44.5

## Copper pours and planes (outline as drawn)
+0.6V_DDR_VTT on TOP (solid shape): 209.33,52.52 209.33,50.77 209.39,50.71 209.39,50.25 208.7,49.56 208.69,49.56 208.53,49.47 208.44,49.31 208.43,49.3 208.08,48.94 206.56,48.94 205.79,49.71 205.79,51.56 206.06,51.83 206.59,51.83 206.78,51.64 206.78,51.17 207.33,50.62 208.9,50.62 209,50.71 209,52.48 209.1,52.58 209.26,52.58
+0.6V_DDR_VTT on TOP (solid shape): outline of 207 points within 201.79,12.3 212.9,40.34
+0.6V_DDR_VTT on BOTTOM (solid shape): 202.58,40.15 202.58,39.32 202.02,38.76 202.02,37.71 201.95,37.64 201.13,37.64 201.07,37.71 201.07,40.23 201.21,40.37 202.35,40.37
+0.6V_DDR_VTT on BOTTOM (solid shape): 206.91,51.5 206.91,51.5 206.91,48.52 207.45,47.99 209.15,47.99 209.48,47.66 209.48,46.98 209.33,46.82 209.33,45.07 209.27,45.02 209.1,45.02 209.02,45.1 209.02,46.82 208.77,47.08 207.34,47.08 206.32,46.05 204.02,46.05 203.83,46.15 203.62,46.12 203.55,46.12 203.49,46.16 203.46,46.2 203.43,46.23 203.43,46.29 203.49,46.31 203.91,46.47 203.84,46.92 203.8,46.98 203.82,47.06 203.79,47.54 203.31,47.54 203.27,47.53 203.24,47.55 203.15,47.62 203.04,47.67 202.97,47.73 202.99,47.83 203.05,48.17 202.78,48.4 202.75,48.42 202.74,48.46 202.72,48.65 202.63,48.82 202.61,48.86 202.63,48.89 202.31,49.62 201.99,48.89 202.01,48.86 201.99,48.82 201.91,48.36 202.3,48.09 202.34,48.08 202.35,48.04 202.42,47.85 202.58,47.72 202.64,47.65 202.61,47.55 202.49,47.26 202.62,46.92 202.49,46.59 202.6,46.3 202.53,46.24 201.19,46.24 201.14,46.28 201.14,49.66 201.36,49.88 201.36,51.47 201.52,51.63 204.68,51.63 204.84,51.8 206.61,51.8
+0.6V_DDR_VTT on VCC: 202.76,38.08 202.02,38.82 202.02,42.04 205.07,45.09 205.07,52.2 205.96,53.09 207.74,51.31 207.74,40.34 205.47,38.08
+0.6V_P on TOP (solid shape): 207.12,14.31 207.12,12.98 207.13,12.96 207.15,12.95 207.64,12.95 207.66,12.93 207.66,12.76 207.65,12.74 207.12,12.74 207.11,12.72 207.11,12.34 207.1,12.33 206.86,12.33 206.83,12.35 205.69,12.35 205.55,12.21 204.74,12.21 204.67,12.28 204.67,12.43 205,12.76 205,13.23 205.24,13.46 205.24,13.85 205.09,14 204.5,14 204.09,13.59 204.09,12.7 204.01,12.62 203.95,12.62 203.86,12.71 203.86,14.99 204.02,15.15 206.28,15.15
+0.9V_LAN on BOTTOM (solid shape): 182.65,127.62 182.65,126.05 182.58,125.99 181.91,125.99 181.52,125.6 181.52,124.84 181.38,124.71 179.68,124.71 179.5,124.88 179.5,127.4 179.83,127.73 182.54,127.73
+0.9V_LAN on BOTTOM (solid shape): 188.47,124.88 188.47,123.94 188.59,123.82 188.8,123.82 188.91,123.72 188.91,123.3 188.76,123.16 188.53,123.16 188.34,122.97 188.34,122.58 188.31,122.55 187.73,122.55 187.69,122.59 187.69,123.53 187.82,123.66 187.82,124.88 187.91,124.97 188.38,124.97
+0.9V_LAN on IN1 (solid shape): outline of 497 points within 180.3,122.27 195.38,131.92
+0.9V_TBT_LVR_OUT on TOP (solid shape): 28.11,44.68 28.11,44.31 28.17,44.25 28.29,44.12 28.29,44.1 28.42,43.97 28.42,42.68 28.14,42.41 28.14,41.92 28.38,41.68 28.36,41.64 28.46,41.28 28.83,41.2 28.93,41.19 28.97,41.11 28.97,40.09 28.89,40.01 28.51,40.01 28.46,40.06 28.46,40.47 28.44,40.49 28.44,40.55 28.38,40.55 28.3,40.63 28.34,40.67 28.34,41.11 27.91,41.22 27.79,41.23 27.74,41.33 27.74,41.42 27.74,41.43 27.75,41.55 27.73,41.66 27.73,41.67 27.73,42.03 27.75,42.05 27.75,42.19 27.75,42.37 27.73,42.4 27.52,42.6 27.52,44.8 27.6,44.87 27.91,44.87
+0.9V_TBT_PCIE on TOP (solid shape): 30.87,36.58 31.44,36.58 31.57,36.45 31.57,35.08 31.6,35.05 31.6,35.03 31.81,34.72 32.18,34.77 32.2,34.78 32.29,34.78 33.62,33.45 33.64,33.44 34.73,33.44 34.73,33 34.73,32.92 34.8,32.85 35.41,32.85 35.59,32.66 35.84,32.66 36.06,32.88 36.33,32.88 36.63,32.58 36.63,31.79 36.6,31.76 36.11,31.76 36.08,31.79 33.18,31.79 32.53,32.44 32.53,33.88 32.42,33.99 32.42,34.02 32.39,34.02 32.37,34.04 30.16,34.04 29.72,34.48 29.72,34.62 29.76,34.71 29.86,34.72 30.36,35.04 29.86,35.36 29.76,35.37 29.72,35.46 29.72,35.81 29.86,35.95 30.2,35.95 30.27,36.01 30.27,36.1 30.28,36.11 30.36,36.27 30.35,36.45 30.34,36.48 30.44,36.58 30.87,36.58
+0.9V_TBT_PCIE on IN4 (solid shape): outline of 236 points within 29.66,32.21 36.6,36.64
+0.9V_TBT_SVR on TOP (solid shape): 28.96,52.31 28.96,50.47 29.14,50.29 30.78,50.29 30.88,50.28 30.98,50.29 31.44,50.29 31.53,50.28 31.61,50.29 31.64,50.29 31.74,50.2 31.74,49.77 31.73,49.74 31.71,49.63 31.71,49.52 31.71,49.41 31.73,49.31 31.74,49.29 31.74,49.2 31.69,49.16 27.49,49.16 27.17,49.47 26.46,49.47 26.03,49.9 26.03,52.62 26.27,52.85 28.41,52.85
+0.9V_TBT_SVR on BOTTOM (solid shape): 23.1,53.98 23.1,49.48 22.86,49.24 21.07,49.24 20.91,49.4 20.91,50.71 18.81,52.81 18.81,54.3 19.18,54.67 22.41,54.67
+0.9V_TBT_SVR on IN1 (solid shape): outline of 1701 points within 18.8,35.04 34.05,54.35
+0.9V_TBT_SVR on IN3 (solid shape): outline of 1473 points within 19.17,35.66 34.48,44.65
+1.0V_ALW_PCH on TOP (solid shape): 197.12,15.53 197.12,13.65 195.36,11.88 194.61,11.88 194.31,12.18 194.31,12.68 195.72,14.09 195.72,15.55 195.89,15.71 196.94,15.71
+1.0V_ALW_PCH on TOP (solid shape): 202.19,19.91 202.19,18.79 202.1,18.71 200.97,18.71 200.88,18.79 200.88,19.91 201.04,20.07 201.04,20.07 201.08,20.11 201.98,20.11
+1.0V_ALW_PCH on TOP (solid shape): 198.82,52.15 198.82,51.08 198.81,51.08 198.81,49.72 198.41,49.32 198.41,49.02 198.31,48.92 198.08,48.92 198.02,48.94 197.97,48.95 197.74,49.18 197.74,50.89 198.08,51.23 198.08,52.1 198.24,52.26 198.71,52.26
+1.0V_ALW_PCH on BOTTOM (solid shape): outline of 333 points within 183.77,11.13 195.51,19.63
+1.0V_ALW_PCH on BOTTOM (solid shape): outline of 1978 points within 183.75,14.96 206.61,52
+1.0V_AMPHYPLL on TOP (solid shape): 195.58,19.69 195.58,19.5 195.87,19.2 200.44,19.2 200.6,19.04 200.6,18.71 200.84,18.47 202.05,18.47 202.19,18.33 202.19,17.56 202.01,17.38 201.29,17.38 201.14,17.23 201.14,16.52 200.82,16.21 200.08,16.21 199.87,16 197.29,16 196.96,16.32 196.96,16.86 197,16.88 197.18,17.12 197.11,17.42 197.08,17.5 197.11,17.59 197.16,18 196.78,18.18 196.75,18.17 196.63,18.3 195.05,18.3 194.62,18.72 194.62,19.1 194.36,19.36 194.36,19.71 195.16,19.71 195.17,19.73 195.53,19.73
+1.0V_BCLKPLL2 on TOP (solid shape): 199.7,50.96 199.7,50.39 199.64,50.33 199.64,49.65 199.8,49.49 199.8,48.44 199.75,48.39 199.3,48.39 199.21,48.47 199.21,49.42 199.15,49.48 199.15,50.99 199.21,51.04 199.62,51.04
+1.0V_BCLKPLL2_R on TOP (solid shape): 199.08,49.23 199.08,47.58 198.66,47.15 198.66,46.29 198.25,45.88 198.25,44.32 197.36,43.43 197.21,43.43 197.2,43.44 196.8,43.44 196.79,43.44 196.56,43.4 196.4,43.23 196.39,43.21 196.26,43.14 196.25,43.14 196.01,42.98 196.04,42.7 196.04,42.52 195.98,42.36 196.04,42.2 196.04,42.02 196.01,41.98 195.97,41.94 195.69,41.94 195.59,42.03 195.59,43 195.66,43.09 195.69,43.2 195.69,43.22 195.87,43.39 195.98,43.39 196.49,43.9 196.53,43.9 197.02,43.93 196.9,44.41 196.87,44.42 196.87,45.82 197.75,46.7 197.76,46.72 197.76,47.97 198.53,48.75 198.53,48.96 198.54,48.97 198.54,49.22 198.6,49.28 199.02,49.28
+1.0V_CLPLLEBB on BOTTOM (solid shape): outline of 248 points within 186.56,17.05 193.19,28.97
+1.0V_DUSB on BOTTOM (solid shape): 195.12,36.47 195.12,35.15 195.08,35.1 194.4,35.1 194.15,34.86 193.66,34.86 193.47,34.67 192.98,34.67 192.65,34.34 190.36,34.34 190.1,34.47 189.85,34.34 189.76,34.34 189.65,34.23 189.59,34.23 189.57,34.24 189.13,34.2 189.06,33.77 189.09,33.73 187.74,32.37 187.38,32.37 187.25,32.5 187.25,32.89 187.41,33.05 187.53,33.05 187.54,33.04 187.91,33.13 187.93,33.51 187.92,33.53 187.92,33.69 188.1,33.87 188.1,34.35 188.88,35.13 188.97,35.16 189.05,35.1 189.42,34.9 189.66,35.25 189.68,35.34 189.76,35.37 190.02,35.37 190.1,35.34 190.12,35.25 190.43,34.88 190.75,35.25 190.77,35.34 190.85,35.37 191.08,35.37 191.16,35.33 191.17,35.24 191.38,34.86 191.78,35.04 191.8,35.08 191.85,35.1 191.87,35.08 191.9,35.06 192.27,35.05 192.45,35.38 192.45,35.41 192.69,35.65 192.76,35.68 192.84,35.64 193.17,35.51 193.41,35.78 193.42,35.8 193.57,35.95 194.05,35.93 194.11,36.42 194.09,36.43 194.09,36.5 194.14,36.55 195.04,36.55
+1.0V_MPHY on BOTTOM (solid shape): outline of 2093 points within 187.34,18.39 199.79,32.24
+1.0V_MPHY on IN4 (solid shape): outline of 3045 points within 182.61,22.29 199.24,33.44
+1.0V_OC on BOTTOM (solid shape): 193.54,37.91 193.54,36.82 192.34,35.62 192.29,35.65 192.01,35.7 191.78,35.53 191.77,35.5 190.52,35.5 190.43,35.51 190.34,35.5 189.46,35.5 189.45,35.5 189.34,35.52 189.24,35.5 189.23,35.5 189.07,35.5 188.65,35.09 188.56,35.06 188.49,35.13 187.97,35.24 188.08,34.72 188.14,34.64 188.11,34.55 187.97,34.4 187.97,33.92 187.84,33.79 187.33,33.79 187.26,33.87 187.26,34.79 187.26,35.37 187.91,36.02 188.6,36.02 188.62,36.01 188.77,35.98 188.92,36.01 188.93,36.02 189.69,36.02 189.7,36.02 189.8,36 189.91,36.02 189.92,36.02 190,36.02 190.29,36.3 190.29,36.51 190.63,36.85 190.87,36.85 190.88,36.84 190.91,36.78 190.88,36.74 191.1,36.08 191.25,36.75 191.26,36.8 191.37,36.95 191.4,37.08 191.42,37.1 191.6,37.1 191.88,37.38 191.88,37.59 191.98,37.69 192.5,37.69 192.78,37.97 193.48,37.97
+1.0V_OCPLL1 on BOTTOM (solid shape): 199.39,43.4 199.39,42.38 199.39,42.38 199.39,40.94 198.9,40.45 198.9,40.33 198.58,40.01 197.84,40.01 197.74,40.11 197.74,41 197.83,41.04 197.92,41 198.54,41.24 197.92,41.48 197.79,41.45 197.7,41.57 197.7,42.63 198.25,43.18 198.25,43.52 198.34,43.61 199.18,43.61
+1.0V_OCPLL1_R on BOTTOM (solid shape): 199.19,44.45 199.19,43.87 199.13,43.81 198.23,43.81 198.14,43.9 197.53,43.9 197.52,43.9 196.64,43.9 196.54,44 196.54,44.09 196.54,44.09 196.54,44.35 196.73,44.54 199.1,44.54
+1.0V_PRIM_CNV_HVLO on BOTTOM (solid shape): outline of 434 points within 182.29,35.29 185.27,45.27
+1.0V_PRIM_FUSE on BOTTOM (solid shape): 185.77,28.79 185.76,28.76 185.76,28.64 185.8,28.52 185.81,28.5 185.81,26.95 185.71,26.85 185.71,25.03 185.71,25.03 185.71,24.95 185.89,24.76 185.89,21.4 185.89,21.39 185.98,21 186.37,21.01 186.42,21.02 186.46,21 186.5,20.96 186.5,20.03 186.47,19.99 185.72,19.99 185.55,20.16 185.55,20.35 185.3,20.6 185.3,28.36 185.07,28.59 185.07,28.84 185.17,28.94 185.62,28.94
+1.0V_SRC on BOTTOM (solid shape): 185.79,45.81 185.79,45.28 185.7,45.18 185.7,43.65 186.12,43.23 186.12,43.22 186.51,42.83 186.51,41.85 186.44,41.74 186.3,41.76 185.76,41.54 186.3,41.31 186.44,41.34 186.51,41.22 186.51,41.06 186.42,40.85 186.51,40.63 186.51,38.24 186.47,38.15 186.38,38.14 185.95,37.84 186.38,37.55 186.47,37.53 186.51,37.45 186.51,37.12 186.6,37.04 186.6,36.19 186.56,36.1 186.47,36.09 186.06,35.78 186.47,35.48 186.56,35.46 186.6,35.38 186.6,35.25 187.13,34.72 187.13,33.87 187.08,33.82 186.5,33.82 186.43,33.89 186.43,33.95 186.44,33.96 186.47,34.15 186.39,34.33 185.4,35.32 185.4,37.65 185.4,37.66 185.4,42.51 185,42.92 185,44.33 185.04,44.37 185.07,44.38 185.4,44.73 185.07,45.09 185.04,45.09 184.99,45.14 184.99,45.84 185.76,45.84
+1.0V_VCCSFR on BOTTOM (solid shape): 208.09,109.02 208.09,107.69 208.54,107.24 208.54,106.79 208.45,106.7 208.13,106.7 206.89,107.93 206.89,109.05 206.97,109.14 207.98,109.14
+1.0V_VCCSFR on IN3 (solid shape): 197.12,84.01 197.12,82.91 196.86,82.66 195.99,82.66 195.9,82.75 195.9,84.06 195.99,84.15 196.98,84.15
+1.0V_VCCSFR on IN3 (solid shape): 208.52,107.3 208.52,106.07 208.33,105.88 207.38,105.88 207.18,106.09 207.18,107.56 207.39,107.77 208.05,107.77
+1.0V_VCCSFR on IN4: 195.22,82.55 194.9,82.87 194.9,84.35 194.6,84.65 194.6,84.69 194.42,84.87 194.42,90.11 193.08,91.45 191.29,91.45 190.33,90.49 190.33,86.76 190.16,86.6 188.83,86.6 188.64,86.78 188.64,90.46 189.01,90.83 189.01,92.3 189.53,92.82 193.21,92.82 194.32,91.71 194.32,91.53 194.96,90.89 195.57,90.89 196.8,89.66 196.8,87.59 197.05,87.34 197.05,82.83 196.77,82.55
+1.0V_VCCSFR_R on TOP (solid shape): 224.73,107.06 224.73,106.69 224.73,106.68 224.53,106.46 224.35,106.69 224.37,106.76 224.17,106.96 224.11,107.01 224.08,107.05 224.06,107.07 223.95,107.18 223.19,107.18 223.04,107.34 223.01,107.42 222.96,107.49 222.96,107.76 223.01,107.81 223.97,107.81
+1.0V_VCCSFR_R on BOTTOM (solid shape): 224.65,107.33 224.65,106.92 224.76,106.8 224.76,106.5 224.74,106.37 224.76,106.24 224.76,106.12 224.58,105.93 224.05,105.93 223.98,106 223.98,107.36 224.08,107.46 224.52,107.46
+1.0V_VCCSFR_R on BOTTOM (solid shape): 214.15,110.67 214.15,109.95 213.89,109.69 211.23,109.69 211.13,109.71 211.02,109.69 210.67,109.69 210.41,109.43 207.07,109.43 206.91,109.59 206.91,110.56 207.07,110.72 209.53,110.72 209.64,110.7 209.75,110.72 210.51,110.72 210.53,110.75 214.07,110.75
+1.0V_VCCSFR_R on IN3 (solid shape): 215.81,110.63 215.81,109.91 215.39,109.49 212.16,109.49 212,109.65 212,110.61 212.13,110.74 215.71,110.74
+1.0V_VCCSFR_R on IN3 (solid shape): 224.83,108 224.83,107.44 224.73,107.21 224.83,106.98 224.83,106.59 224.78,106.53 224.75,106.46 224.64,106.35 224.02,106.35 223.94,106.43 223.94,107.5 223.94,107.5 223.94,108.07 224.04,108.17 224.65,108.17
+1.0V_VCCST on TOP (solid shape): 183.64,93.37 183.64,92.99 183.99,92.65 183.99,92.42 183.86,92.3 182.74,92.3 182.56,92.47 182.56,93.36 182.67,93.46 183.56,93.46
+1.0V_VCCST on TOP (solid shape): 192.22,86.39 192.22,85.65 191.86,85.3 188.77,85.3 188.66,85.41 188.66,86.41 188.73,86.49 189.56,86.49 189.56,86.43 190.12,86.43 190.12,86.49 191.2,86.49 191.2,85.96 191.64,85.96 191.64,86.52 192.09,86.52
+1.0V_VCCST on BOTTOM (solid shape): 269.44,150.2 269.44,149.78 268.9,149.25 264.52,149.25 264.51,149.27 264.35,149.42 264.14,149.45 264.11,149.45 264.05,149.51 264.05,150.21 264.25,150.41 269.23,150.41
+1.0V_VCCST on BOTTOM (solid shape): 222.76,109.97 222.76,109.66 222.36,109.26 222.36,108.5 222.28,108.41 220.18,108.41 220.11,108.42 220.05,108.41 216.87,108.41 216.65,108.51 216.42,108.41 216.29,108.41 216.28,108.42 216.04,108.49 215.8,108.41 215.7,108.41 213.79,106.51 210.03,106.51 209.97,106.57 209.97,107.88 210.04,107.95 210.65,107.95 210.81,108.11 210.81,109.41 210.92,109.52 213.96,109.52 214.51,110.08 215.99,110.08 216.53,109.53 217.66,109.53 217.82,109.38 220.61,109.38 220.93,109.69 221.73,109.69 222.13,110.08 222.15,110.08 222.27,110.09 222.38,110.14 222.59,110.14
+1.0V_VCCST_C on TOP (solid shape): 192.66,88.24 192.66,87.85 193.31,87.2 193.31,86.58 193.27,86.54 192.37,86.54 192.27,86.64 190.72,86.64 190.51,86.85 190.51,88.23 190.69,88.41 192.5,88.41
+1.0V_VCCSTG on TOP (solid shape): 193.8,98.07 194.52,98.07 194.69,97.9 194.69,96.86 194.48,96.65 193.77,96.65 193.77,96.65 192.21,96.65 192.21,97.19 192.2,97.19 191.77,97.19 191.77,96.65 191.1,96.65 190.93,96.82 190.93,97.81 191.19,98.08 193.8,98.08
+1.0V_VCCSTG_C on TOP (solid shape): 192.83,96.27 192.83,94.92 192.62,94.72 190.72,94.72 190.06,95.39 190.06,96.4 190.16,96.5 192.6,96.5
+1.0VS_VCCIO on TOP (solid shape): outline of 107 points within 221.88,97.25 225.29,107.05
+1.0VS_VCCIO on BOTTOM (solid shape): 224.02,102.84 224.04,102.78 224.04,102.71 224.02,102.69 224.02,99.42 224.04,99.4 224.05,99.4 224.64,98.8 224.64,97.42 224.51,97.29 224.22,97.29 224.12,97.39 224.12,97.8 224.06,97.85 223.36,97.85 222.96,98.25 221.98,98.25 221.88,98.35 221.88,98.96 221.97,99.05 222.1,99.05 222.14,99.06 222.44,99.43 222.05,99.71 222.05,99.71 221.88,99.71 221.88,100.34 222.15,100.62 222.43,100.8 222.44,101.13 222.44,102.67 222.67,102.9 223.97,102.9
+1.0VS_VCCIO on BOTTOM (solid shape): outline of 815 points within 259.57,102.16 268.42,110.07
+1.0VS_VCCIO on IN3 (solid shape): outline of 1071 points within 169.69,82 178.48,99.01
+1.0VS_VCCIO on IN3 (solid shape): outline of 16756 points within 218.25,91.62 269.61,111.18
+1.0VS_VCCIO on VCC: 219.93,95.86 219.93,106.93 221.56,108.56 258.13,108.56 260.17,110.6 267.45,110.6 269.71,108.33 269.71,96.22 269.35,95.86
+1.0VS_VCCIOP on TOP (solid shape): 276.29,109.86 276.29,109.3 276.17,109.19 272.12,109.19 272.09,109.22 272.09,109.55 272.48,109.95 276.19,109.95
+1.0VS_VCCIOP on BOTTOM (solid shape): 276.48,109.8 276.48,108.87 275.45,107.84 275.45,106.12 274.69,105.36 269.95,105.36 269.54,104.95 269.54,104.34 269.23,104.04 268.59,104.04 268.59,104.8 268.04,104.8 268.03,104.8 268.03,105.24 268.59,105.24 268.59,106 268.02,106 268.02,106.45 268.03,106.46 268.57,106.46 268.58,106.47 268.58,107.17 271.35,109.94 276.34,109.94
+1.2V_MEM on TOP (solid shape): 247.26,12.4 247.26,10.14 247.16,10.04 246.52,10.04 246.47,10.04 246.46,10.03 246.42,10.03 246.42,9.99 246.42,9.5 246.4,9.48 245.96,9.48 245.95,9.49 245.95,10.06 245.2,10.06 245.2,9.5 245.18,9.48 244.77,9.48 244.75,9.5 244.75,10.05 244.74,10.05 244.74,10.07 241.16,10.07 241.16,9.5 240.73,9.5 240.72,9.52 240.72,10.07 239.97,10.07 239.97,9.53 239.94,9.5 239.54,9.5 239.51,9.53 239.51,10.08 238.84,10.08 238.75,10.16 238.75,12.7 239.09,13.05 246.61,13.05
+1.2V_MEM on TOP (solid shape): outline of 92 points within 271.89,71.69 286.43,84.71
+1.2V_MEM on TOP (solid shape): outline of 111 points within 196.55,60.91 201.67,73.82
+1.2V_MEM on TOP (solid shape): outline of 191 points within 232.97,60.97 248.44,63.2
+1.2V_MEM on TOP (solid shape): outline of 342 points within 233.35,47.06 248.14,50.56
+1.2V_MEM on BOTTOM (solid shape): 286.06,72.69 286.06,71.61 285.85,71.4 285.27,71.4 284.69,70.82 284.43,70.82 284.21,71.04 284.21,71.83 283.37,72.67 283.37,73.21 283.49,73.33 285.42,73.33
+1.2V_MEM on BOTTOM (solid shape): 200.58,69.27 202.21,69.27 202.39,69.09 202.39,67.61 202.25,67.47 200.51,67.47 200.19,67.15 200.19,65.27 200.87,64.59 200.87,63.78 200.49,63.39 198.46,63.39 196.91,64.94 196.91,68.17 196.91,68.18 196.91,68.88 197.35,69.31 200.54,69.31
+1.2V_MEM on BOTTOM (solid shape): outline of 318 points within 175.76,66.71 184.54,77.48
+1.2V_MEM on BOTTOM (solid shape): outline of 127 points within 222.65,84.55 226.91,90.81
+1.2V_MEM on BOTTOM (solid shape): outline of 4371 points within 224.21,83.11 258.31,90.81
+1.2V_MEM on IN3 (solid shape): outline of 264 points within 183.38,63.65 200.81,68.18
+1.2V_MEM on IN4 (solid shape): outline of 764 points within 277.58,41.81 292.26,73.54
+1.2V_MEM on BOTTOM: outline of 249 points within 212.98,11.11 271.53,36.42 ; 1 cut-out
+1.2V_MEM on VCC: 252.93,26.78 248.61,31.09 226.68,31.09 226.43,30.84 224.22,30.84 223.84,31.22 216.73,31.22 213.45,34.5 213.45,53.68 203.78,63.35 198.57,63.35 198.08,63.84 198.08,73.66 211.8,87.38 211.8,89.22 212.41,89.83 215.36,89.83 217.64,92.11 217.64,93.22 219.78,95.36 269.56,95.36 269.57,95.36 270,95.36 272.38,92.98 272.38,87.69 272.77,87.29 273.59,87.29 273.6,87.29 273.9,86.99 273.9,85.43 272.38,83.91 272.38,75.31 283.51,64.18 280,60.66 280,34.37 272.4,26.78
+1.2V_MEM on VCC: 182.7,66.65 182.08,67.27 182.08,69.93 180.3,71.71 180.3,76.84 181.04,77.58 182.61,77.58 184.88,75.31 184.88,67.27 184.26,66.65
+1.2V_MEN_P on TOP (solid shape): 201.74,15.92 201.74,15.36 201.94,15.16 202.52,15.16 202.59,15.09 202.59,13.77 202.89,13.47 202.89,12.68 202.83,12.62 202.19,12.62 201.02,13.79 201.02,14.16 201.02,14.17 201.02,15.91 201.11,16.01 201.65,16.01
+1.2V_MEN_P on TOP (solid shape): 206.95,12.12 206.95,11.81 206.85,11.7 206.01,11.7 205.89,11.82 204.74,11.82 204.68,11.88 204.68,12.03 204.74,12.09 205.6,12.09 205.62,12.1 205.71,12.19 206.88,12.19
+1.2V_MEN_P on TOP (solid shape): 239.38,9.91 239.38,9.43 239.44,9.38 240.07,9.38 240.1,9.4 240.1,9.91 240.12,9.94 240.55,9.94 240.58,9.91 240.58,9.4 240.6,9.38 241.29,9.38 241.31,9.4 241.31,9.91 241.34,9.94 241.87,9.94 241.9,9.91 244.59,9.91 244.62,9.88 244.62,9.4 244.67,9.35 245.3,9.35 245.33,9.38 245.33,9.88 245.35,9.91 245.79,9.91 245.81,9.88 245.81,9.4 245.86,9.35 246.52,9.35 246.55,9.38 246.55,9.88 246.57,9.91 247.19,9.91 247.27,9.83 247.27,8.48 247.05,8.26 244.85,8.26 244.69,8.11 243.07,8.11 242,7.04 242,4.73 240.98,3.71 234.96,3.71 232.35,6.32 232.35,8.81 232.6,9.06 234.54,9.06 234.89,8.79 235.23,9.06 235.41,9.06 236.29,9.94 239.36,9.94
+1.2V_MEN_P on BOTTOM (solid shape): 233.79,9.53 233.79,8.15 233.5,7.87 232.45,7.87 231.66,8.66 231.66,10.07 232.07,10.48 232.84,10.48
+1.2V_MEN_P on BOTTOM (solid shape): 207.47,12.75 207.79,12.75 207.91,12.63 207.91,11.77 207.82,11.67 205.88,11.67 205.73,11.83 205.73,12.56 205.93,12.76 207.47,12.76
+1.2V_RUN on TOP (solid shape): 138.97,47.66 138.97,47.19 138.68,46.9 138.68,46.19 138.6,46.1 137.86,46.1 137.76,46.21 137.76,47.25 138.04,47.53 138.04,48.05 138.17,48.18 138.46,48.18
+1.2V_RUN on TOP (solid shape): 140.31,37.12 140.31,36 140.06,35.75 139.39,35.75 139.24,35.91 139.24,36.48 139.36,36.6 139.36,37.12 139.45,37.21 140.23,37.21
+1.2V_RUN on TOP (solid shape): 150.77,36.76 150.77,36.27 150.71,36.21 150.66,36.16 150.61,36.1 150.57,36.07 150.57,36.04 150.57,36.03 150.55,35.92 150.56,35.81 150.57,35.78 150.44,35.64 150.03,35.64 149.87,35.81 149.87,36.81 149.93,36.88 150.65,36.88
+1.2V_RUN on BOTTOM (solid shape): 74.18,28.63 74.26,28.55 74.36,28.49 74.37,28.48 74.42,28.44 74.42,27.88 74.4,27.82 74.14,27.56 72.47,27.56 72.38,27.65 72.38,28.52 72.49,28.63
+1.2V_RUN on BOTTOM (solid shape): 179.8,71.24 179.8,70.74 180.3,70.74 180.32,70.72 180.32,70.49 179.8,70.49 179.8,69.94 180.32,69.94 180.32,69.69 179.78,69.69 179.78,68.83 179.65,68.69 178.91,68.69 178.46,68.24 177.63,68.24 177.43,68.44 177.43,68.97 178.34,69.87 178.34,71.12 178.73,71.52 179.52,71.52
+1.2V_RUN on BOTTOM (solid shape): 63.07,30.25 63.07,28.37 63.36,28.08 64.12,28.08 64.27,27.93 64.27,27.17 64.23,27.13 63.34,27.13 63.14,27.2 62.94,27.13 62.47,27.13 61.47,28.13 61.47,28.69 61.61,28.83 62.16,28.83 62.51,29.18 62.51,30.25 62.59,30.33 62.98,30.33
+1.2V_RUN on BOTTOM (solid shape): outline of 317 points within 139.27,32.94 162.34,49.13
+1.2V_RUN on IN2 (solid shape): outline of 132 points within 66.16,27.37 75.88,39.32
+1.2V_RUN on VCC: 62.58,30.47 76.38,30.47 77.19,29.66 74.56,27.02 68.62,27.02 67.14,28.51 63.41,28.51 62.58,29.33
+1.2V_RUN on VCC: 121.27,40.9 120.04,42.12 112.36,42.12 111.29,43.2 95.64,43.2 93.79,41.34 82.73,41.34 78.88,45.2 78.88,50.62 81.4,53.15 83.73,53.15 83.73,52.4 84.23,51.18 85.45,50.68 116.59,50.68 117.22,49.95 118.15,49.68 131.4,49.68 132.33,49.95 132.96,50.68 155.36,50.68 169.67,64.99 169.67,76.69 179.8,76.69 179.8,71.5 181.57,69.72 181.57,66.47 170.31,55.21 169.23,55.21 158.67,44.65 139.22,44.65 136.34,41.77 134.6,41.77 133.74,40.9
+1.2V_RUN_PWR on BOTTOM (solid shape): 181.99,73.38 181.99,68.9 181.79,68.7 180.13,68.7 179.92,68.9 179.92,69.56 180.46,69.56 180.46,70.07 179.92,70.07 179.92,70.36 180.46,70.36 180.46,70.87 179.92,70.87 179.92,72.09 180.07,72.23 180.07,73.12 180.42,73.47 181.9,73.47
+1.05V_PRIM on TOP (solid shape): 163.73,13.98 163.73,12.75 163.73,12.75 163.73,12.61 163.44,12.33 163.44,12.26 163.37,12.19 162.36,12.19 162.24,12.31 162.24,12.9 162.12,13.02 162.12,13.02 162.01,13.13 162.01,13.17 161.98,13.17 161.96,13.18 161.35,13.18 161.35,13.65 161.36,13.66 161.36,13.71 161.33,13.74 160.63,13.74 160.61,13.73 160.61,13.19 160.61,13.19 160.17,13.19 160.16,13.19 160.16,13.73 160.15,13.74 159.43,13.74 159.42,13.73 159.42,13.2 159.4,13.19 158.88,13.19 158.83,13.24 158.83,14.44 158.95,14.56 162.32,14.56 162.32,14.58 163.13,14.58
+1.05V_PRIM on TOP (solid shape): 193.37,94.45 193.37,92.87 193.27,92.77 192.42,92.77 192.21,92.55 192.21,91.89 192.5,91.6 192.51,91.58 192.58,91.45 192.7,91.35 192.74,91.34 192.85,91.32 192.9,91.32 193.5,91.32 193.82,91 193.82,90.52 193.75,90.4 193.62,90.42 193.04,90.14 193.62,89.86 193.75,89.87 193.82,89.76 193.82,88.97 193.66,88.81 192.71,88.81 192.54,88.64 189.79,88.64 189.75,88.68 189.75,90.28 189.83,90.35 190.84,90.35 191.03,90.54 191.03,91.39 190.57,91.85 189.64,91.85 189.57,91.91 189.57,92.66 189.68,92.77 190.38,92.77 190.69,93.07 190.69,94.33 190.85,94.49 193.33,94.49
+1.05V_PRIM on BOTTOM (solid shape): 198.3,16.53 198.04,16.27 195.54,16.27 195.16,16.65 195.16,18.09 195.29,18.22 198.3,18.22
+1.05V_PRIM on BOTTOM (solid shape): 8.19,22.02 8.19,18.32 8.12,18.24 6.92,18.24 6.82,18.35 6.82,20.2 6.82,20.2 6.82,20.3 6.67,20.44 5.79,20.44 5.36,20.02 5.09,20.02 4.84,20.27 4.84,21.97 4.98,22.11 8.11,22.11
+1.05V_PRIM on BOTTOM (solid shape): outline of 90 points within 182.49,28.14 184.84,29.93
+1.05V_PRIM on IN3 (solid shape): outline of 8386 points within 159.4,11.85 197.13,34.91
+1.05V_PRIM on IN4 (solid shape): outline of 589 points within 185.99,59.91 195.15,91.29
+1.05V_PRIM on VCC: 37.17,1.22 37.17,8.23 37.66,8.23 37.88,8.46 50.46,8.46 55.95,13.95 62.05,13.95 62.05,13.96 66.63,13.96 67.85,15.17 67.85,19.75 72.33,24.24 76.02,24.24 77.67,25.89 79.87,25.89 80.48,25.27 80.48,24.38 81.65,23.22 87.23,23.22 97.52,12.93 130.54,12.93 130.77,12.7 130.77,10.54 131.43,9.88 132.28,9.88 132.53,10.14 139.9,10.14 142.06,12.3 146.63,12.3 147.01,12.68 157.42,12.68 159.33,14.58 162.15,14.58 162.22,14.51 163.18,14.51 164.05,13.65 164.05,13.64 163.92,13.52 163.92,12.95 166.48,10.39 165.21,9.12 145.15,9.12 143.24,7.22 127.15,7.22 126.15,8.22 110.64,8.22 108.85,10.01 90.37,10.01 89.1,11.28 73.14,11.28 72.1,10.24 72.1,1.22
+1.05V_PRIM on VCC: 183.33,28.93 182.59,29.68 182.59,33.88 182.66,34.11 182.59,34.34 182.59,53.21 190.32,60.94 192.52,60.94 193.12,60.34 193.12,58.44 193.51,58.05 193.51,32.6 189.85,28.93
+1.05V_PRIM on IN4: outline of 124 points within 3.52,2.43 40.78,21.34
+1.05V_PRIMP on TOP (solid shape): outline of 152 points within 155.6,3.06 163.68,13.59
+1.05V_VDD on BOTTOM (solid shape): 6.23,26.75 7.11,26.6 7.99,26.62 8.04,26.58 8.04,24.92 7.9,24.79 6.88,24.79 6.22,25.45 6.22,26.74
+1.05V_VDD on BOTTOM (solid shape): 22.4,12.56 22.4,11.51 22.64,11.27 22.64,11.19 22.82,11 22.82,6.98 22.7,6.86 22.15,6.86 22.01,7 22.01,9.47 22.49,9.95 22.49,10.97 22.18,11.28 22.18,12.55 22.26,12.63 22.34,12.63
+1.05V_VDD on BOTTOM (solid shape): 33.89,18.7 35.38,18.7 35.57,18.51 35.57,16.29 35.17,15.88 34.1,15.88 33.77,16.21 33.77,16.47 33.43,16.82 33.02,16.82 32.86,16.65 31.82,16.65 31.75,16.72 31.75,18.76 31.89,18.9 33.69,18.9
+1.05V_VDD on BOTTOM (solid shape): 23.6,12.58 23.6,11.78 24.51,10.88 25.33,10.88 25.82,10.38 25.82,8.21 26.17,7.86 26.17,7.03 25.92,6.77 24.82,6.77 24.63,6.96 24.63,10.04 24.63,10.19 23.39,11.43 23.39,12.55 23.46,12.62 23.56,12.62
+1.05V_VDD on BOTTOM (solid shape): 21.2,12.56 21.2,11.7 21.24,11.66 21.24,11.61 21.31,11.54 21.31,10.81 21.28,10.77 21.25,10.73 21.22,10.71 21.22,10.7 20.44,9.91 20.22,9.91 20.13,9.82 20.13,6.6 19.94,6.41 19.52,6.41 19.34,6.58 19.34,9.96 19.62,10.24 20.31,10.24 20.97,10.9 20.97,12.55 21.05,12.62 21.14,12.62
+1.05V_VDD on BOTTOM (solid shape): 17.76,13.6 17.85,13.61 17.98,13.61 18.04,13.54 18.04,13.42 17.98,13.36 17.98,13.02 17.89,12.93 17.63,12.93 17.4,12.93 17.24,12.77 16.71,12.77 16.56,12.62 16.56,12.58 16.54,12.56 15.61,12.56 15.47,12.42 15.47,11.23 15.35,11.11 14.25,11.11 14.13,11.23 14.13,13.11 14.63,13.61 17.67,13.61
+1.05V_VDD on BOTTOM (solid shape): 22.81,22.15 23.39,22.15 23.44,22.09 23.44,21.52 23.36,21.44 23.16,21.44 23.06,21.34 23.06,20.19 22.67,19.81 22.67,19.36 22.65,19.34 22.65,19.22 22.65,19.22 22.65,19.01 22.4,18.77 22.4,17.89 22.32,17.81 21.85,17.81 21.77,17.9 21.77,18.97 21.88,19.08 21.89,19.09 22.1,19.4 21.98,19.77 21.98,20 21.94,20.04 21.93,20.07 21.85,20.29 21.66,20.43 21.63,20.45 21.63,20.76 21.5,20.89 21.5,22.58 21.66,22.75 22.21,22.75
+1.05V_VDD on IN1 (solid shape): 8.29,26.64 8.29,24.32 8.41,24.2 8.42,24.2 8.46,24.16 9.66,24.16 10.03,23.78 10.03,22.69 9.84,22.49 7.38,22.49 7.04,22.83 7.04,24.79 6.16,25.66 6.16,26.79 6.4,27.03 7.91,27.03
+1.05V_VDD on IN2: 17.55,9.24 17.45,9.24 17.45,9.3 17.23,9.57 16.89,9.53 16.85,9.5 16.78,9.47 16.72,9.49 16.54,9.57 16.36,9.54 16.22,9.44 16.15,9.28 16.14,9.24 14.52,9.24 14.02,9.74 14.02,12.52 14.56,13.06 16.7,13.06 17.36,13.72 17.43,13.75 17.51,13.71 18.02,13.7 18.01,14.22 17.98,14.29 18.01,14.36 20.44,16.79 24.42,16.79 25.2,17.57 25.2,17.6 26.86,19.26 32.06,19.26 32.1,19.21 34.06,19.21 35.06,18.21 35.86,18.21 35.93,18.15 35.93,15.48 35.46,15.01 35.42,15.01 35.09,14.92 34.99,14.59 35,14.55 34.68,14.23 34.64,14.21 34.55,14.15 34.48,14.06 34.46,14.03 30.58,14.03 30.56,14.03 30.37,14.08 30.18,14.03 30.17,14.03 29.92,14.03 29.84,14.07 29.83,14.17 29.49,14.65 29.16,14.17 29.15,14.07 29.07,14.03 26.58,14.03 23.69,11.13 20.92,11.13 19.35,9.55 19.32,9.55 19.04,9.28 17.58,9.28
+1.05V_VDD on IN3: outline of 129 points within 7.49,5.55 25.47,23.74
+1.8V_ALW_PCHRES on IN3 (solid shape): outline of 462 points within 165.89,26.62 177.65,36.75
+1.8V_ALW_VTR3 on TOP (solid shape): 132.62,15.59 132.62,15.04 132.64,15.03 132.64,14.93 132.61,14.91 132.14,14.91 132.13,14.9 132.13,14.36 132.12,14.35 131.94,14.35 131.93,14.36 131.93,14.85 131.92,14.86 131.92,14.9 131.41,14.9 131.41,14.88 131.13,14.88 131.11,14.89 130.92,14.95 130.72,14.88 130.67,14.84 130.63,14.79 130.45,14.61 130.44,14.61 130.19,14.35 130.18,14.35 130.09,14.27 128.73,14.27 128.2,13.73 127.44,13.73 127.29,13.88 127.29,15.12 127.44,15.27 127.72,15.27 128.36,15.91 132.3,15.91
+1.8V_ALW_VTR3 on IN3 (solid shape): 133.5,19.03 133.51,18.92 133.51,16.55 133.17,16.21 133.03,16.21 131.86,15.04 129.65,15.04 128.36,13.75 127.96,13.75 127.64,14.07 127.64,14.95 128.61,15.92 131.02,15.92 131.76,16.66 132.53,16.66 132.54,16.6 132.55,16.55 132.57,16.5 132.6,16.46 132.63,16.41 132.67,16.38 132.71,16.35 132.76,16.32 132.81,16.31 132.86,16.3 132.92,16.3 132.97,16.31 133.02,16.32 133.07,16.35 133.11,16.38 133.15,16.41 133.19,16.46 133.21,16.5 133.23,16.55 133.24,16.6 133.25,16.66 133.24,16.71 133.23,16.76 133.21,16.81 133.19,16.86 133.15,16.9 133.11,16.93 133.07,16.96 133.02,16.99 132.97,17 132.92,17.01 132.86,17.01 132.81,17 132.76,16.99 132.71,16.96 132.67,16.93 132.63,16.9 132.6,16.86 132.57,16.81 132.55,16.76 132.54,16.71 132.53,16.66 131.76,16.66 132.98,17.88 132.98,18.68 132.95,18.71 132.95,18.73 132.77,18.91 132.77,19.13 132.87,19.23 133.3,19.23
+1.8V_PHVLDO on BOTTOM (solid shape): 175.83,35.9 175.92,35.9 175.94,35.89 176.13,35.81 176.33,35.86 176.37,35.87 176.46,35.8 176.46,35.78 176.56,35.54 176.8,35.43 176.83,35.43 177.01,35.25 177.85,35.25 178.13,34.97 178.61,34.97 178.64,34.97 178.82,34.97 179.03,34.89 179.24,34.97 179.42,34.97 179.45,34.97 180.14,34.97 180.18,34.97 180.29,34.97 180.56,34.85 180.82,34.97 180.93,34.97 181,34.97 181.01,34.96 181.24,34.96 181.88,34.31 181.88,34.09 181.89,34.07 181.99,33.86 182.19,33.76 182.21,33.76 182.38,33.59 183.89,33.59 184.18,33.88 184.18,34.27 184.27,34.35 184.79,34.35 184.91,34.23 184.91,33.34 184.5,32.93 181.79,32.93 181.11,33.6 181.11,34.12 180.92,34.31 180.36,34.31 180.27,34.23 180.12,34.23 179.88,34.32 179.65,34.23 179.22,34.23 179.21,34.24 179.05,34.28 178.89,34.24 178.87,34.23 177.47,34.23 177.35,34.31 177.22,34.33 177.17,34.33 176.9,34.6 176.9,34.67 176.55,35.02 174.79,35.02 174.69,35.12 174.69,36 174.79,36.1 175.64,36.1
+1.8V_PRIM on TOP (solid shape): 138.68,4.25 138.68,2.83 138.52,2.67 137.66,2.67 137.5,2.83 137.5,3.57 137.49,3.58 136.96,3.58 136.95,3.59 136.95,3.77 136.96,3.78 137.48,3.78 137.51,3.8 137.51,4.23 137.69,4.41 138.52,4.41
+1.8V_PRIM on TOP (solid shape): 132.72,14.62 132.69,14.57 132.6,14.39 132.63,14.19 132.64,14.18 132.64,13.75 132.97,13.42 132.97,12.67 133.11,12.54 133.11,12.28 132.92,12.09 132.15,12.09 131.99,12.26 131.99,12.47 132.1,12.58 132.1,13.44 131.95,13.59 131.47,13.59 131.28,13.78 131.28,14.44 131.3,14.52 131.29,14.59 131.28,14.62 131.42,14.76 131.8,14.76 131.8,14.31 131.8,14.25 131.84,14.22 132.23,14.22 132.24,14.24 132.25,14.24 132.27,14.26 132.27,14.77 132.28,14.78 132.56,14.78
+1.8V_PRIM on BOTTOM (solid shape): 171.97,38.43 172.68,38.43 172.83,38.29 172.83,37.28 172.76,37.21 171.87,37.21 171.71,37.04 170.9,37.04 170.85,37.09 170.85,38.64 170.85,38.64 170.85,38.76 170.98,38.88 171.52,38.88
+1.8V_PRIM on BOTTOM (solid shape): outline of 159 points within 126.63,6.65 133.08,12.67
+1.8V_PRIM on IN3 (solid shape): 136.41,19.11 136.41,18.27 136.34,18.29 136.27,18.29 135.89,17.94 136.27,17.58 136.39,17.59 136.49,17.64 137.04,17.09 137.04,15.18 136.86,15.01 136.83,14.77 134.97,12.91 133.79,12.91 133.04,12.16 132.08,12.16 131.85,12.39 131.85,12.96 132.44,13.55 134.68,13.55 135.28,14.16 135.39,14.16 136.34,15.11 136.34,15.71 135.14,16.91 135.14,17.74 135.87,18.46 135.87,19.16 135.92,19.21 136.31,19.21
+1.8V_PRIM on IN4 (solid shape): 129.97,6.96 138.4,6.96 138.74,6.63 138.74,3.47 138.44,3.17 132.66,3.17 131.42,4.4 129.43,4.4 129.41,4.48 129.39,4.53 129.37,4.58 129.33,4.62 129.29,4.65 129.25,4.68 129.2,4.71 129.15,4.72 129.1,4.73 129.04,4.73 128.99,4.72 128.94,4.71 128.89,4.68 128.85,4.65 128.81,4.62 128.78,4.58 128.75,4.53 128.73,4.48 128.71,4.4 127.53,4.4 127.36,4.57 127.36,5.66 128.09,5.66 128.09,5.63 128.09,5.58 128.11,5.53 128.13,5.48 128.16,5.44 128.2,5.4 128.24,5.36 128.29,5.34 128.34,5.32 128.39,5.31 128.44,5.3 128.49,5.31 128.55,5.32 128.6,5.34 128.64,5.36 128.68,5.4 128.72,5.44 128.75,5.48 128.77,5.53 128.79,5.58 128.8,5.63 128.8,5.68 128.79,5.74 128.77,5.79 128.75,5.84 128.72,5.88 128.68,5.92 128.64,5.95 128.6,5.98 128.55,6 128.49,6.01 128.44,6.01 128.39,6.01 128.34,6 128.29,5.98 128.24,5.95 128.2,5.92 128.16,5.88 128.13,5.84 128.11,5.79 128.09,5.74 128.09,5.68 128.09,5.66 127.36,5.66 127.36,6.99 127.68,7.31 129.62,7.31
+1.8V_PRIM on IN2: 257.28,25.64 257.29,25.68 257.32,25.72 257.06,26.32 256.8,25.72 249.4,25.72 249.4,27.71 249.62,27.93 258.36,27.93 258.73,27.56 258.73,25.87 258.5,25.64
+1.8V_PRIM on IN2: outline of 102 points within 267.41,17.65 287.64,27.16
+1.8V_PRIM on IN2: 214.8,20.11 214.61,20.3 214.61,23.13 218.63,27.16 233.91,27.16 234.12,26.94 234.12,25.96 233.88,25.72 220.49,25.72 216.27,21.49 216.27,20.26 216.11,20.11
+1.8V_PRIM on VCC: 134.59,17.37 132.17,19.79 133.1,20.71 135.59,20.71 136.1,20.21 136.26,20.21 136.26,19.59 136.24,19.57 136.24,19.36 136.64,18.96 139.21,18.96 140.36,20.11 141.85,20.11 142.03,19.93 142.64,19.93 142.77,20.06 143.72,20.06 144.09,20.43 144.09,20.79 144.22,20.92 144.22,22.14 145.31,23.23 152.9,23.23 153.24,22.89 154.88,22.89 156.01,24.03 163.47,24.03 164.15,23.35 164.15,23.35 164.85,22.65 165.03,22.65 165.34,22.35 165.98,22.35 166.09,22.46 166.19,22.46 166.32,22.34 167.89,22.34 169.18,23.63 169.18,23.64 170.25,24.71 170.25,24.79 170.65,25.18 170.65,25.48 170.81,25.48 170.96,25.62 171.95,25.62 174.05,27.73 182.46,27.73 183.16,28.43 189.85,28.43 190.96,27.32 202.55,27.32 208,21.87 215.96,21.87 216.12,21.72 216.12,19.89 204.84,19.89 201.6,23.12 175.26,23.12 173.11,20.98 165.59,20.98 164.87,21.7 157.53,21.7 157.11,21.29 146.24,21.29 143.88,18.93 141.2,18.93 139.64,17.37
+1.8V_PRIM on IN4: 170.35,28.76 171.05,28.06 171.12,27.99 171.12,26 171.11,25.99 171.11,24.79 170.83,24.52 168.94,24.52 168.42,25.04 168.42,25.91 168.65,26.15 168.65,26.85 168.65,26.86 168.65,26.93 167.96,27.61 167.96,30.61 168.19,30.84 168.19,31.59 167.68,32.1 167.68,33.52 167.69,33.53 167.69,34.59 168.19,35.09 168.19,36.11 170.36,38.28 170.36,38.85 170.48,38.97 171.53,38.97 171.69,38.82 171.69,34.62 171.64,34.61 171.41,34.28 171.64,33.94 171.69,33.93 171.69,33.84 171.67,33.83 171.67,33.06 170.35,31.74
+1.8V_PRIM on IN4: 311.21,20.05 302.24,20.05 301.92,19.73 288.39,19.73 287.59,20.53 287.01,20.53 286.89,20.65 286.89,21.51 287.01,21.63 287.01,21.88 287.42,22.29 314.61,22.29 315.08,22.75 315.12,22.73 315.56,22.78 315.61,23.22 315.59,23.26 317.36,25.03 325.62,25.03 325.87,24.93 326.12,25.03 327.03,25.03 327.12,25.02 327.21,25.03 327.37,25.03 327.43,25.09 329.27,26.93 331.29,26.93 331.43,26.79 331.43,25.24 331.23,25.03 330.24,25.03 328.21,23.01 322.54,23.01 319.58,20.05 311.21,20.05
+1.8V_PRIM_PCH on BOTTOM (solid shape): outline of 411 points within 171.89,33.78 184.03,38.37
+1.8V_PRIM_PCH on IN1 (solid shape): outline of 452 points within 175.73,36.09 181.08,39.56
+1.8V_PRIM_PCH on IN3: 189.16,37.19 194.34,37.19 195.86,35.67 195.86,33.57 195.67,33.38 194.4,33.38 192.37,35.41 188.91,35.41 188.54,35.04 182.69,35.04 182.3,34.65 180.3,34.65 179.8,35.16 179.8,36.81 181.54,38.55 187.8,38.55
+1.8V_PRIMP on TOP (solid shape): 138.32,5.76 138.32,4.67 138.25,4.59 137.64,4.59 137.37,4.32 137.37,3.92 137.36,3.92 136.81,3.92 136.8,3.91 136.8,3.45 136.81,3.44 137.36,3.44 137.36,3.43 137.36,2.84 137.14,2.61 134.19,2.61 133.94,2.86 133.94,5.53 134.32,5.91 138.17,5.91
+1.8V_RUN on BOTTOM (solid shape): outline of 606 points within 335.22,13.69 348.66,25.4
+1.8V_RUN_PWR on BOTTOM (solid shape): 335.87,26.89 335.87,25.32 335.64,25.09 335.64,25.06 335.64,24.76 335.64,24.76 335.52,24.64 335.21,24.64 335.2,24.62 335.11,24.62 335.09,24.61 335.09,24.09 335.11,24.08 335.63,24.08 335.64,24.07 335.64,23.83 335.63,23.83 335.18,23.83 335.18,23.83 335.1,23.83 335.09,23.82 335.09,23.31 335.11,23.28 335.62,23.28 335.65,23.25 335.65,22.95 335.64,22.93 333.94,22.93 333.89,22.99 333.93,23.04 334.08,23.46 333.7,23.7 333.62,23.72 333.59,23.8 333.59,25.29 333.76,25.59 333.59,25.9 333.59,26.8 333.73,26.94 335.82,26.94
+2.5V_MEM on TOP (solid shape): 289.18,56.82 289.18,55.36 289.07,55.24 286.66,55.24 286.64,55.27 286.64,55.78 286.62,55.79 286.12,55.79 286.09,55.77 286.09,55.26 286.07,55.24 285.86,55.24 285.84,55.27 285.84,55.78 285.83,55.79 285.3,55.79 285.28,55.77 285.28,55.26 285.26,55.24 285,55.24 284.85,55.39 284.85,56.94 284.92,57.01 288.99,57.01
+2.5V_MEM on TOP (solid shape): 209.53,60.72 209.54,60.72 209.58,60.68 209.58,58.99 209.45,58.86 206.23,58.86 205.2,57.84 205.2,55.98 206.44,54.74 207.7,54.74 208.1,54.34 208.1,54.29 208.11,54.24 208.11,53.51 207.17,52.57 205.97,52.57 205.2,51.8 205.2,49.65 208.06,46.8 209.48,46.8 209.58,46.7 209.58,45.1 209.5,45.02 208.84,45.02 208.61,45.25 206.65,45.25 203.49,48.4 203.49,48.84 202.69,49.63 202.17,49.63 201.95,49.85 201.95,52.99 201.57,53.37 201.53,53.37 200.96,53.37 200.84,53.49 200.84,54.34 200.96,54.47 201.51,54.47 202.15,55.11 202.15,56.83 202.21,56.89 203.2,56.89 203.49,57.18 203.49,58.9 205.36,60.77 209.48,60.77
+2.5V_MEM on BOTTOM (solid shape): 208.08,54.51 208.08,53.27 208.39,52.96 209.12,52.96 209.58,52.51 209.58,50.9 209.49,50.81 208.2,50.81 207.95,51.06 207.95,51.61 206.68,52.89 206.68,54.14 207.34,54.8 207.79,54.8
+2.5V_MEM on BOTTOM (solid shape): outline of 255 points within 201.54,26.92 212.08,38.58
+2.5V_MEM on IN2 (solid shape): outline of 5909 points within 207.25,29.82 289.31,57.15
+2.5V_MEM on VCC: 207.46,34.65 205.83,36.28 205.83,37.72 208.24,40.13 208.24,51.52 206.21,53.55 206.21,56.9 207.86,58.55 212.94,53.47 212.94,34.65
+2.5V_MEMP on TOP (solid shape): 286.49,55.64 286.49,55.1 286.5,55.1 287.26,55.1 287.7,54.65 287.7,51.6 287.48,51.37 283.14,51.37 282.83,51.68 282.83,55.36 282.95,55.48 284.21,55.48 284.6,55.1 285.42,55.1 285.44,55.11 285.44,55.64 285.44,55.64 285.68,55.64 285.68,55.63 285.68,55.11 285.69,55.1 286.23,55.1 286.24,55.11 286.24,55.64 286.24,55.64 286.48,55.64
