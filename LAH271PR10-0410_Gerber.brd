# Allegro board LAH271PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DEBUG_TX: length 25.6
  IN3 w0.081: v2(65.41,8.79) 65.03,8.79 63.92,7.68 63.92,5.36 v2(62.82,4.26)
  BOTTOM w0.109: JDEG1.9 59.75,4.42 60.82,5.49 61.94,5.49 RE74.2 62.82,4.61 v2(62.82,4.26) ; v2(65.41,8.79) 64.96,8.79 v1(64.76,8.6) 63.92,7.76 60.83,7.76 60.82,7.76 55.54,7.76 55.23,8.07 52.82,8.07 51.89,7.14 RE30.1
DG_GPIO8: length 2.1
  TOP w0.109: RT503.1 RT553.1 34.63,41.46 v2(34.56,41.54)
  BOTTOM w0.109: UT1.W6 v2(34.56,41.54)
DG_PA_USB2_MXCTL: length 3.8
  BOTTOM w0.089: UT1.R2 32.12,43.45 32.12,44.57
  BOTTOM w0.109: RT508.1 v1(31.88,45.8) 31.88,44.81 32.12,44.57
DG_PB_USB2_MXCTL: length 5.9
  BOTTOM w0.109: RT509.1 33.11,48.12 33.24,48.12 33.47,47.9 33.47,47.46 v1(33.04,47.03) 33.04,46.68 32.22,45.86 32.22,44.78 32.37,44.64 32.37,44.09 32.36,44.08 UT1.R1
DGFF_ALERT#: length 27.5
  TOP w0.109: QV41.3 181.65,79.97 RV803.2 180.75,79.89 180.49,79.63 v1(180.49,79.24) 180.49,78.57 180.9,78.16 182.03,78.16 v2(182.93,77.26) ; JDGFF1.A10 171.67,89.9 v2(171.31,90.26)
  IN1 w0.102: v2(182.93,77.26) 180.23,79.96 180.23,84.99 177.85,87.37 177.85,88.1 176.59,89.37 172.2,89.37 v2(171.31,90.26)
DGFF_BIA_PWM: length 90.4
  TOP w0.109: JDGFF2.E1 178.51,98.76 v1(179.1,98.17) 179.51,97.77 v2(179.51,97.21) ; v2(136.18,50.08) 137.62,50.08 137.81,49.88 137.81,48.58 136.4,47.17 136.4,46.69 136.79,46.3 UV65.2
  IN3 w0.081: v2(179.51,97.21) 180.56,96.16 180.56,94.32 181.21,93.67 181.21,91.82 181.62,91.41 181.62,89.12 182.19,88.55 182.19,83.86 176.56,78.22 176.56,76.49 177.13,75.91 177.13,70.55 158.84,52.26 157.66,52.26 155.57,50.17 155.01,50.17 153.81,48.97 140.12,48.97 139.47,49.62 138,49.62 137.77,49.85 136.41,49.85 v2(136.18,50.08)
DGFF_CLK_REQ#: length 46.7
  TOP w0.109: RV807.2 187.78,91.47 187.92,91.61 QV42.3 187.92,95.29 v2(187.84,95.38) ; JDGFF2.C9 172.27,102.42 172.08,102.61 171.12,102.61 v2(170.74,102.23)
  IN4 w0.102: v2(170.74,102.23) 170.23,102.74 170.23,109.23 171.3,110.3 181.23,110.3 186.22,105.31 189.23,105.31 190.3,104.25 190.3,102.38 188.04,100.12 188.04,95.58 v2(187.84,95.38)
DGFF_DP_HDMI_HPD: length 443
  TOP w0.109: v2(189.96,94.91) 189.78,95.09 189.78,96.17 189.35,96.6 189.35,97.72 189.75,98.12 190.74,98.12 191.14,98.52 192.19,98.52 DV33.1 192.88,99.21 DV32.1 ; DV32.1 194.15,100.81 RV905.1 ; DV32.1 192.88,102.38 DV43.1 193.85,102.39 v1(194.19,102.05) ; UE1.F5 v2(132.73,25.65)
  IN1 w0.102: v2(13.1,28.42) 13.1,27.38 12.34,26.62 12.34,23.81 13.32,22.83 13.32,19.98 12.79,19.45 12.79,17.73 11.22,16.16 11.22,10.93 9.15,8.86 v2(7.84,8.86)
  IN2 w0.081: v2(30.92,52.88) 30.23,52.2 29.41,52.2 28.49,51.28 28.49,49.7 26.75,47.95 25.83,47.95 25.59,47.71 25.59,44.87 25.35,44.63 24.46,44.63 23.77,43.94 23.77,41.22 21.81,39.26 20.4,39.26 18.26,37.11 18.26,34.8 18.53,34.52 18.53,32 17.74,31.21 17.74,30.08 16.27,28.61 14.91,28.61 14.55,28.97 13.65,28.97 v2(13.1,28.42)
  IN3 w0.081: v2(189.96,94.91) 190.91,93.96 190.91,90.61 190.49,90.19 190.49,84.88 188.16,82.55 186.62,82.55 184.03,79.96 183.34,79.96 182.77,79.39 182.77,78.35 183.35,77.76 183.35,72.19 160.41,49.25 158.43,49.25 157.95,49.73 155.2,49.73 153.99,48.53 139.91,48.53 139.24,49.2 137.77,49.2 137.58,49.39 127.12,49.39 122.46,44.73 119.71,44.73 114.03,50.4 95.68,50.4 89.11,43.83 85.74,43.83 82.55,47.03 79.91,47.03 77.25,49.69 73.04,49.69 72.05,50.67 69.2,50.67 68.04,49.5 68.04,49.27 67.07,48.3 67.07,43.5 65.98,42.41 65.43,42.41 64.52,41.5 57.64,41.5 56.76,42.39 44.69,42.39 40.94,46.14 40.94,49.27 38.08,52.14 37.12,52.14 35.38,52.62 31.79,52.62 31.53,52.88 v2(30.92,52.88) ; v2(7.84,8.86) 7.84,7.14 9.78,5.2 15.51,5.2 18.1,2.62 22.45,2.62 25.79,5.96 28.93,5.96 30.17,7.21 35.86,7.21 36.43,7.77 40.62,7.77 42.04,6.36 43.34,6.36 44.54,5.16 50.31,5.16 51.45,4.02 54.66,4.02 54.87,4.22 54.87,4.65 52.39,7.13 52.39,8.3 54.72,10.63 54.72,16.14 55.02,16.44 55.98,16.44 58.23,18.69 59.98,18.69 61,19.7 62.48,19.7 63.58,20.8 64.4,20.8 64.67,21.07 72.91,21.07 73.28,21.44 75.63,21.44 76.24,20.83 77.18,19.89 78.29,19.89 79.39,18.79 83.49,18.79 85.05,20.36 89.12,20.36 90.69,18.78 93.08,18.78 94.4,17.46 100.54,17.46 102.16,19.08 111.62,19.08 112.31,19.77 114.77,19.77 115.58,20.59 115.58,21.07 116.23,21.72 121.66,21.72 122.66,22.72 124.27,22.72 124.78,23.22 126.7,23.22 129.07,25.6 129.27,25.6 129.73,26.06 132.11,26.06 132.52,25.65 v2(132.73,25.65)
DGFF_ENVDD: length 95
  TOP w0.109: v2(180.13,99.91) v1(179.65,100.38) 179.43,100.61 177.28,100.61 177.07,100.81 JDGFF2.D1 ; v2(135.52,50.07) 135.74,49.85 135.74,48.95 135.31,48.52 135.31,47.72 135.74,47.29 135.74,45.51 134.96,44.72 DV3.3
  IN3 w0.081: v2(180.13,99.91) 179.7,99.48 179.7,97.8 180.79,96.71 180.79,94.42 181.44,93.77 181.44,91.94 181.85,91.52 181.85,89.21 182.42,88.64 182.42,83.77 176.79,78.13 176.79,76.58 177.38,75.99 177.38,70.47 158.75,51.84 157.56,51.84 155.67,49.94 155.11,49.94 153.91,48.74 140.02,48.74 139.35,49.41 137.88,49.41 137.7,49.6 135.99,49.6 v2(135.52,50.07)
DGFF_IFP_HPD: length 29
  TOP w0.109: DV43.2 190.78,102.92 190.26,103.44 v2(189.82,103.44) ; v2(187.25,95.38) 186.74,94.86 186.74,93.62 186.01,92.89 186.01,92.38 185.78,92.16 185.52,92.16 184.96,91.6 181.23,91.6 v1(180.86,91.97) 180.49,92.33 179.34,92.33 178.63,91.62 178.63,90.34 177.59,89.29 177.59,87.88 176.47,86.76 JDGFF1.C2
  IN4 w0.102: v2(189.82,103.44) 187.06,100.68 187.06,95.58 v2(187.25,95.38)
DGFF_OVERT#: length 25.9
  TOP w0.109: v1(188.41,81.28) 188.61,81.49 QV40.3 189.26,82.81 RV816.2 190.2,83.75 190.2,84.73 189.93,85.01 188.7,85.01 188.04,85.66 v2(187.76,85.66) ; v2(178.59,88.47) 178.59,88.28 177.07,86.76 JDGFF1.C1
  IN1 w0.102: v2(178.59,88.47) 178.59,87.05 179.4,86.24 180.05,86.24 180.46,86.64 180.46,88.14 180.77,88.46 187.31,88.46 188.33,87.44 188.33,86.23 v2(187.76,85.66)
DGFF_PANEL_BKEN: length 124.3
  TOP w0.109: JDGFF2.D2 176.47,100.66 176.92,100.21 178.77,100.21 v2(178.84,100.14) ; v2(179.14,76.16) 179.14,75.1 179.49,74.74 179.49,72.66 162.69,55.86 162.69,55.67 v1(162.09,55.07) 161.17,54.16 161.17,53.29 v2(161.6,52.86)
  IN3 w0.081: v2(178.84,100.14) 178.83,100.13 178.83,96.78 178.26,96.21 178.26,94.25 178.63,93.88 178.63,93.08 176.75,91.2 176.75,90.01 177.06,89.69 178.17,89.69 178.4,89.46 178.4,88.91 177.71,88.22 177.71,86.19 179.13,84.78 179.13,81.41 175.95,78.24 175.8,78.24 175.46,77.9 175.46,76.49 v2(176.09,75.86)
  BOTTOM w0.109: DV36.2 111.59,50.08 111.92,50.41 115.38,50.41 117,48.79 117,47.42 119.77,44.65 123.04,44.65 126.78,48.38 129.71,48.38 130.53,49.2 130.71,49.2 130.82,49.32 151.38,49.32 151.7,49.64 154.83,49.64 158.46,53.26 161.2,53.26 v2(161.6,52.86) ; v2(176.09,75.86) 178.84,75.86 v2(179.14,76.16)
DGFF_PWR_LEVEL: length 18.8
  TOP w0.109: UV60.4 182.91,98.76 182.67,99 182.08,99 181.21,98.12 v1(181.21,97.6) 181.15,97.55 RV819.2 180.8,94.05 179.45,92.7 178.92,92.7 178.69,92.48 172.14,92.48 171.67,92.94 JDGFF2.H10
DGFF_VGA_DIS#: length 260.3
  TOP w0.109: JDGFF1.D1 177.07,85.24 v2(177.73,84.58)
  IN1 w0.102: v2(11.13,10.2) 11.44,10.52 11.44,16.06 13.02,17.64 13.02,19.34 13.55,19.87 13.55,22.92 12.57,23.9 12.57,26.14 13.7,27.27 v2(13.7,28.4)
  IN2 w0.081: v2(13.7,28.4) 14,28.69 14.5,28.69 14.82,28.38 16.36,28.38 17.97,29.99 17.97,31.11 18.76,31.9 18.76,34.61 18.48,34.89 18.48,37.01 20.5,39.03 21.9,39.03 24,41.12 24,43.85 24.56,44.42 25.45,44.42 27.3,46.27 28.04,46.27 28.74,46.97 28.74,51.23 29.5,51.99 30.99,51.99 v2(31.4,52.39)
  IN3 w0.081: v2(31.4,52.39) 35.28,52.39 37.23,51.9 38.01,51.9 39.51,50.4 39.51,49.31 40.73,48.08 40.73,46.05 44.61,42.18 56.67,42.18 57.56,41.3 64.91,41.3 65.61,42 66.16,42 66.28,42.12 67.49,43.33 67.49,47.23 68.45,48.19 68.45,49.13 69.51,50.19 71.87,50.19 72.83,49.23 77.12,49.23 81.54,44.81 83.91,44.81 85.3,43.42 88.99,43.42 95.76,50.2 113.95,50.2 119.62,44.52 122.55,44.52 126,47.97 129.27,47.97 130.47,49.18 137.47,49.18 137.65,48.99 139.15,48.99 139.82,48.33 155.43,48.33 155.92,47.83 159.38,47.83 183.61,72.06 183.61,78.62 v2(183.24,78.99)
  IN4 w0.102: v2(177.73,84.58) 177.73,83.58 177.95,83.36 178.36,83.36 180.17,81.55 180.68,81.55 v2(183.24,78.99)
  BOTTOM w0.109: v2(11.13,10.2) 10.65,10.68 UE12.8 ; v1(13.98,29.32) 13.7,29.03 v2(13.7,28.4)
DGPU_ALERT#: length 249.2
  TOP w0.109: v1(186.96,79.54) 186.79,79.71 RV904.2 185.61,79.71 184.7,80.62 QV41.1 184.22,80.23 184.22,79.82 v2(184.47,79.57)
  IN1 w0.102: v2(14.31,28.27) 14.31,27.46 12.93,26.08 12.93,23.87 13.78,23.02 13.78,19.47 13.33,19.02 13.33,17.48 12.17,16.32 v2(12.17,13.55)
  IN2 w0.081: v2(31.81,51.97) 31.63,51.78 29.58,51.78 28.97,51.17 28.97,46.87 28.15,46.05 27.41,46.05 25.54,44.19 24.65,44.19 24.23,43.76 24.23,41.03 22,38.8 20.59,38.8 18.71,36.92 18.71,34.99 19,34.7 19,29.98 17.04,28.02 14.55,28.02 v2(14.31,28.27)
  IN3 w0.081: v2(31.81,51.97) 32.03,52.19 35.02,52.19 37.19,51.69 37.93,51.69 39.3,50.31 39.3,49.22 40.53,47.99 40.53,45.97 44.52,41.97 54.15,41.97 54.62,41.5 54.62,41.23 54.86,41 56.97,41 57.3,40.67 65.16,40.67 65.87,41.37 66.42,41.37 66.53,41.49 66.54,41.49 68.11,43.07 68.11,46.97 68.62,47.48 69.5,47.48 70.02,48 76.06,48 77.33,46.72 79.33,46.72 81.48,44.58 83.81,44.58 85.2,43.19 89.05,43.19 95.83,49.97 113.88,49.97 119.53,44.31 122.64,44.31 124.34,46.02 127.6,46.02 130.56,48.97 137.35,48.97 137.56,48.77 139.06,48.77 139.73,48.1 155.33,48.1 155.83,47.6 159.52,47.6 184,72.08 184,79.1 v2(184.47,79.57)
  BOTTOM w0.109: UE12.2 11.72,14.01 v2(12.17,13.55)
DGPU_HOLD_RST#: length 96.9
  TOP w0.089: UH1.BB20 176.05,34.16 v2(176.34,34.45)
  TOP w0.109: UV63.1 182.24,83.07 RV812.1 181.12,82.69 v1(180.28,83.53) 179.73,84.08 v2(179.73,86.68)
  IN1 w0.102: v2(179.73,86.68) 179.95,86.68 180.23,86.96 180.23,88.24 180.67,88.69 187.42,88.69 188.19,87.91 189.71,87.91 191.82,85.81 v2(191.82,84.47)
  IN2 w0.081: v2(176.34,34.45) 176.77,34.88 177.76,34.88 179.39,36.51 179.39,38.72 180.54,39.87 180.54,40.66 179.41,41.79 179.41,44.15 179.76,44.5 179.76,46.61 180.86,47.71 182.78,47.71 184.56,49.48 184.56,49.96 185.4,50.8 185.4,53.73 188.89,57.22 191.86,57.22 192.81,58.17 192.81,58.7 195.59,61.48 195.59,74.54 192.29,77.83 192.29,84 v2(191.82,84.47)
  BOTTOM w0.102: v2(176.34,34.45) 175.95,34.05 175.45,34.05 175.15,34.35 173.97,34.35 173.64,34.69 172.74,34.69 172.21,35.21 171.17,35.21 170.72,35.67 168.57,35.67 RH350.1
DGPU_PEX_RST#: length 28.2
  TOP w0.109: JDGFF1.F2 176.47,82.36 175.99,82.84 175.99,83.47 176.43,83.9 177.74,83.9 179.1,85.26 v1(179.1,87.33) 179.1,88.63 179.41,88.94 180.21,88.94 180.61,88.54 181.16,88.54 181.54,88.16 183.92,88.16 DV34.1 184.91,88.38 184.91,87.83 185.14,87.6 UV63.4 186.77,84.81 187.31,84.27 QV40.2 187.12,82.62 RV813.1 185.76,82.62 184.42,81.27 QV41.2
DGPU_PEX_RST#_D: length 21.2
  TOP w0.109: UV61.1 183.72,90.77 183.82,90.86 DV34.2 185.05,90.86 CV812.1 RV815.2 186.74,88.31 RV800.1 187.25,87.85 188.2,87.85 188.5,88.14 188.5,88.78 188.69,88.97 189.07,88.97 189.31,89.21 189.31,90.19 189.07,90.43 189.07,92.94 189.17,93.05 189.17,94.18 188.72,94.63 188.72,95.28 188.87,95.43 188.87,98.15 189.02,98.29 v1(189.02,98.57) 189.02,99.03 188.28,99.77 UV62.1
DGPU_PWR_EN: length 8
  TOP w0.109: UE11.2 126.88,16.84 126.76,16.96 126.51,16.96 126.35,17.11 125.92,17.11 125.72,17.31 v1(125.72,17.44) 125.72,17.84 126.66,18.77 127.01,18.77 127.02,18.77 127.98,18.77 128.38,19.18 128.38,19.54 128.87,20.02 129.51,20.02 UE1.M1
DGPU_PWR_EN_R: length 160.6
  TOP w0.109: v2(126.8,14.9) 126.34,14.9 126.23,14.79 UE11.4 ; v2(186.06,76.95) 186.06,76.48 186.35,76.19 186.35,75.32 185.88,74.85 v1(185.88,72.79) 185.88,72.29 182.82,69.23 181.77,69.23 167.84,55.3 167.84,52.74 168.14,52.44 168.14,51.82 167.85,51.53 167.22,51.53 v2(167.13,51.62) ; v2(178.35,96.93) 178.34,96.92 177.85,96.92 177.62,97.15 176.71,97.15 176.47,97.39 JDGFF2.F2
  IN4 w0.102: v2(186.06,76.95) 185.71,77.3 185.71,79.91 183.99,81.64 183.99,82.28 183.38,82.88 182.83,82.88 181.98,83.73 181.98,88.76 181.85,88.89 181.85,90.43 180.88,91.41 180.88,96.45 179.64,97.69 179.11,97.69 v2(178.35,96.93)
  BOTTOM w0.109: v2(126.8,14.9) 127.03,14.67 127.03,14.3 127.88,13.45 127.88,13.05 128.05,12.88 128.05,12.53 125.57,10.05 124.04,10.05 122.93,8.94 121.41,8.94 120.84,8.38 120.84,7.45 121.1,7.19 121.1,5.2 122.09,4.22 124.68,4.22 125.12,3.77 127.87,3.77 129.47,5.37 129.47,6.38 131.33,8.23 131.33,8.94 131.57,9.18 131.97,9.18 132.15,9 132.15,8.39 132.6,7.94 135.07,7.94 135.39,8.26 137.48,8.26 138.39,9.17 140.06,9.17 141.85,10.96 143.27,10.96 144.37,12.06 144.37,13.48 148.33,17.44 152.7,17.44 153.17,17.92 153.17,19.79 153.99,20.61 153.99,26.16 154.56,26.73 154.56,34.86 159.76,40.05 159.76,43.35 163.96,47.56 165.01,47.56 167.14,49.69 167.14,51.61 v2(167.13,51.62)
DGPU_PWROK: length 174
  TOP w0.089: UH1.AV16 v2(178.23,36.6)
  TOP w0.102: UE1.M4 v2(131.93,20.05)
  TOP w0.109: JDGFF1.F9 172.27,81.92 171.76,81.41 170.64,81.41 169.76,82.28 169.76,86.42 169.87,86.52 169.87,89.41 171.21,90.75 v2(171.81,90.75) ; v2(188.89,89.39) 188.53,89.39 188.25,89.12 188.25,88.78 RV806.2 186.87,89.23 RV800.2 RV818.1 187.29,90.63 187.29,91.38 187.43,91.52 187.43,92.13 186.95,92.61 QV42.2
  IN1 w0.102: v2(178.23,36.6) 178.23,36.46 176.98,35.22 173.73,35.22 173.33,34.82 171.6,34.82 171.42,34.65 166.56,34.65 165.9,33.99 162.1,33.99 161.95,34.15 161.22,34.15 160.93,33.86 160.52,33.86 159.95,33.29 159.4,33.29 158.12,32.02 158.12,31.34 156.35,29.56 154.96,29.56 154.48,29.08 148.83,29.08 147.51,27.77 145.23,27.77 145.21,27.75 143.05,27.75 142.13,26.83 139.69,26.83 138.85,27.67 135.8,27.67 135.55,27.42 135.55,26.94 134.66,26.05 131.78,26.05 131.52,25.78 131.52,25.36 131.41,25.25 130.95,25.25 130.34,24.65 130.34,22.42 129.76,21.84 129.76,20.89 128.67,19.8 128.67,19.45 128.91,19.21 129.3,19.21 130.41,20.33 131.65,20.33 v2(131.93,20.05) ; v2(188.89,89.39) 183.22,89.39 182.4,90.21 180.66,90.21 180.34,89.9 180.34,89.17 180.13,88.96 178.78,88.96 178.17,89.56 177.03,89.56 176.79,89.81 172.15,89.81 171.81,90.14 v2(171.81,90.75)
  IN2 w0.081: v2(175.55,45.17) 175.81,45.17 178.14,47.5 178.14,51.15 182.94,55.95 184.04,55.95 186.75,58.66 187.11,58.66 187.63,59.18 189.63,59.18 190.54,60.09 190.79,60.09 191,60.3 191,60.82 191.32,61.14 192.93,61.14 194.01,62.22 194.01,64.84 193.28,65.57 193.28,72.69 191,74.97 191,77.35 190.36,78 190.36,87.93 v2(188.89,89.39)
  IN4 w0.102: v2(175.55,45.17) 176.48,45.17 178.05,43.59 178.05,43.19 176.77,41.91 176.77,41.4 176.88,41.29 176.88,39.64 178.38,38.13 178.38,36.75 v2(178.23,36.6)
DGPU_SELECT#: length 229
  TOP w0.109: v2(79.47,50.06) 79.36,50.06 v1(78.92,50.5) ; v2(135.75,48.21) 136.06,47.91 136.06,46.59 136.62,46.03 136.62,45.83 136.8,45.65 UV65.1
  IN2 w0.081: v2(92.27,49.2) 93.51,49.2 93.89,49.59 105.43,49.59 106.03,50.19 113.94,50.19 119.27,44.86 122.83,44.86 127.65,49.68 134.29,49.68 v2(135.75,48.21)
  IN2 w0.102: v2(89.92,33.81) 90.32,33.81 v2(92.76,31.37)
  IN3 w0.081: v2(92.27,49.2) 92.27,47.73 88.79,44.25 85.91,44.25 83.71,46.46 83.71,50.59 83.17,51.12 82.79,51.12 81.97,51.95 81.35,51.95 80.67,52.62 80.67,54.77 81.27,55.36 81.27,57.51 80.69,58.09 80.69,60.06 v2(81.12,60.49) ; v2(9.67,18.89) 9.13,18.89 7.24,20.78 7.24,23.33 7.59,23.68 12.1,23.68 12.32,23.91 26.01,23.91 27.84,25.73 28.84,25.73 v2(29.14,26.02)
  IN4 w0.102: v2(92.76,31.37) 91.98,30.59 82.78,30.59 82.31,31.06 81.18,31.06 79.91,29.79 68.05,29.79 66.96,28.69 62.27,28.69 60.9,30.06 60.9,30.37 60,31.27 59.78,31.27 58.77,32.28 58.77,32.45 58.65,32.57 56.79,32.57 56.7,32.66 54.75,32.66 54.71,32.61 48.68,32.61 48.43,32.36 48.43,32.01 48.06,31.64 44.86,31.64 43.46,30.23 40.9,30.23 37.75,27.08 32.29,27.08 31.63,26.42 29.53,26.42 v2(29.14,26.02) ; v2(79.15,60.34) 79.15,58.02 77.62,56.49 77.62,51.9 v2(79.47,50.06)
  BOTTOM w0.109: v2(79.47,50.06) 78.87,49.46 78.87,48.14 81.03,45.98 81.03,45.42 81.93,44.52 81.93,40.24 82.68,39.49 82.68,36.98 81.74,36.04 81.74,35.7 82.54,34.89 82.88,34.89 83.34,34.43 84.5,34.43 84.94,34.87 86.6,34.87 87.24,34.23 89.5,34.23 v2(89.92,33.81) ; v2(79.15,60.34) 79.15,60.52 QV43.2 RV901.2 80.85,60.76 v2(81.12,60.49) ; v2(9.67,18.89) 9.8,18.89 10.34,18.35 10.34,17.48 10.65,17.17 UE12.28
DGPU_TYPE#: length 141.4
  TOP w0.109: RV742.2 97.26,37.47 98,38.21 98,39.97 v2(98.19,40.16) ; v2(177.1,84.59) 176.99,84.59 176.47,85.11 JDGFF1.D2
  IN3 w0.081: v2(177.1,84.59) 177.1,84.97 177.28,85.15 178.14,85.15 178.68,84.61 178.68,81.55 175.98,78.86 172,78.86 171.43,78.29 171.43,77.45 176.27,72.61 176.27,70.3 158.77,52.81 157.59,52.81 155.39,50.61 154.83,50.61 153.63,49.41 140.27,49.41 139.64,50.04 138.17,50.04 137.94,50.27 136.98,50.27 136.56,50.68 134.09,50.68 133.01,49.6 127.04,49.6 122.38,44.94 119.79,44.94 114.12,50.61 93.68,50.61 v2(93.31,50.25)
  BOTTOM w0.109: v2(93.31,50.25) 94.11,50.25 94.58,49.78 96.89,49.78 99.81,46.85 v1(99.81,45.91) 99.81,42.92 99.63,42.74 99.63,41.44 98.36,40.16 v2(98.19,40.16)
DID2_GPIO1: length 193.9
  TOP w0.109: RV741.2 109.41,27.27 109.6,27.46 RV738.2 110.72,27.47 111.42,28.17 111.42,29.21 109.86,30.78 109.86,32.55 109.14,33.27 v1(109.14,34.5) 109.14,38.52 108.46,39.2 106.63,39.2 105.3,40.53 v2(105.3,41.17)
  IN3 w0.081: v2(105.3,41.17) 103.75,39.62 101.15,39.62 100.92,39.39 98.05,39.39 97.73,39.07 91.75,39.07 91.52,39.3 91.51,39.3 90.72,40.09 88.64,40.09 88.23,39.68 85.15,39.68 84.77,39.3 84.76,39.3 84.09,38.62 81.15,38.62 80.69,39.09 80.69,39.78 79.38,41.09 74.34,41.09 72.9,42.52 71.77,42.52 70.54,41.29 70.54,40.9 69.88,40.24 68.96,40.24 67.63,38.9 67.63,38.7 67.04,38.12 66.96,38.04 66.12,38.04 65.98,38.17 61.59,38.17 60.65,37.23 59.7,37.23 59.05,36.59 56.16,36.59 54.94,37.81 51.94,37.81 51.65,38.1 50.11,38.1 49.5,37.49 47.75,37.49 47.4,37.14 47.4,36.6 47.06,36.26 46.61,36.26 46.4,36.46 46.4,36.88 44.6,38.68 44.13,38.68 43.6,39.21 43.6,40.11 41.82,41.89 39.96,41.89 38.87,42.98 38.87,44.72 39.6,45.45 39.6,48.32 38.83,49.09 38.17,49.09 37.85,49.42 37.85,49.89 35.98,51.75 35.02,51.97 32.39,51.97 31.94,51.52 31.63,51.52 29.88,53.28 29.88,53.74 29.17,54.44 26.88,54.44 26.34,53.91 22.6,53.91 22.14,54.37 19.04,54.37 17.27,52.61 17.27,48.75 15.63,47.11 15.63,41.12 12.6,38.09 12.6,34.28 14.36,32.52 14.36,29.53 15.14,28.76 15.14,28.04 14.9,27.8 11.08,27.8 10.54,27.26 8.45,27.26 7.61,28.1 5.63,28.1 3.83,26.3 3.83,19.8 3.6,19.57 3.6,13.06 4.44,12.22 5.59,12.22 5.97,12.6 5.97,13.42 7.74,15.18 9.38,15.18 v2(10.2,16)
  BOTTOM w0.109: UE12.27 v2(10.2,16)
DID2_GPIO1_HDR: length 20.7
  TOP w0.109: QV44.6 95.47,31.92 98.75,28.63 102.46,28.63 104.85,26.25 106.08,26.25 107.65,27.82 108.7,27.82 108.9,28.02 RV739.2 109.29,28.76 RV737.2 110.34,28.76 v1(110.61,28.49)
DID2_GPIO1_MUX: length 23.5
  TOP w0.109: JEDP1.26 107,42.6 106.35,41.95 105.18,41.95 v2(104.83,41.6) 104.83,40.66 106.53,38.96 108.37,38.96 108.79,38.54 108.79,33.1 109.6,32.29 RV737.1 109.77,29.34 110.09,29.66 110.45,29.66 111.04,29.07 111.04,28.33 110.77,28.06 RV738.1
  BOTTOM w0.109: v1(105.12,42.18) 105.12,41.89 v2(104.83,41.6)
DID2_GPIO1_R: length 25.7
  TOP w0.109: QV44.3 QV44.2 94.82,35.3 95.98,34.14 95.98,31.87 98.95,28.9 102.53,28.9 104.94,26.48 105.89,26.48 107.6,28.19 107.87,28.19 RV740.2 107.83,28.6 107.47,28.6 106.56,29.52 106.56,30.83 107.91,32.19 v1(108.38,32.19)
DID2_GPIO2: length 179.6
  TOP w0.109: JEDP1.27 107.5,42.52 106.53,41.54 v2(105.79,41.54)
  IN3 w0.081: v2(105.79,41.54) 105.79,40.65 105.51,40.38 104.87,40.38 103.9,39.41 101.24,39.41 101.01,39.18 98.22,39.18 97.86,38.82 91.69,38.82 90.68,39.83 88.67,39.83 88.31,39.47 85.24,39.47 84.18,38.41 81.06,38.41 80.47,39 80.47,39.69 79.28,40.88 74.25,40.88 74.04,41.09 74.03,41.09 72.81,42.31 71.85,42.31 70.75,41.21 70.75,40.81 69.97,40.02 69.05,40.02 67.85,38.82 67.85,38.62 67.13,37.91 67.05,37.83 66.03,37.83 65.89,37.96 61.68,37.96 60.73,37.02 59.79,37.02 59.15,36.38 56.08,36.38 54.86,37.6 51.85,37.6 51.56,37.89 50.19,37.89 49.58,37.28 47.91,37.28 47.63,37 47.63,36.53 47.14,36.05 46.52,36.05 46.19,36.38 46.19,36.79 44.51,38.48 43.24,38.48 42.52,37.76 41.95,37.76 40.59,39.13 40.59,40.96 38.66,42.89 38.66,44.8 39.4,45.54 39.4,48.24 38.75,48.89 38.09,48.89 37.64,49.33 37.64,49.8 35.88,51.56 35,51.76 32.48,51.76 32.03,51.31 31.51,51.31 29.67,53.15 29.67,53.65 29.09,54.23 26.96,54.23 26.43,53.7 22.52,53.7 22.05,54.16 19.12,54.16 17.48,52.52 17.48,48.66 15.84,47.02 15.84,41.04 12.82,38.01 12.82,34.37 14.57,32.62 14.57,29.62 15.34,28.85 15.34,27.94 14.98,27.58 11.15,27.58 10.63,27.06 8.32,27.06 7.51,27.87 5.69,27.87 4.04,26.21 4.04,19.71 3.81,19.49 3.81,13.15 4.53,12.43 5.5,12.43 5.76,12.69 5.76,13.5 7.65,15.39 9.25,15.39 9.53,15.66 v2(9.53,16)
  BOTTOM w0.109: UE12.26 9.75,15.78 v2(9.53,16) ; v1(106.56,41.98) 106.12,41.54 v2(105.79,41.54)
DIFFOUT_2PH: length 3.4
  TOP w0.203: PR1134.1 268.99,146.91 PR1136.2 267.81,145.73 PU1100.35
DIFFOUT_4PH: length 5.2
  TOP w0.203: PU1100.4 259.38,146.13 259.06,146.44 259.06,147.34 v1(258.73,147.67) 257.78,148.62 PR1131.2 257.65,148.61 PC1114.2
DIMM1_SA0: length 26.4
  TOP w0.109: v2(198.84,58.45) 198.84,58.45 198.35,58.95 v1(198.25,58.95)
  IN3 w0.081: v2(209.81,47.46) 210.1,47.46 210.7,48.06 210.7,49.57 205.97,54.3 202.98,54.3 201.18,56.09 199.69,56.09 198.84,56.94 v2(198.84,58.45)
  BOTTOM w0.109: v2(198.84,58.45) 198.75,58.45 197.76,59.43 196.87,59.43 195.93,58.49 RD18.1 195.71,59.41 RD78.1 ; JDIMM1.256 209.68,47.33 v2(209.81,47.46)
DIMM1_SA1: length 28.4
  IN3 w0.081: v2(207.24,43.4) 207.24,47.53 203.47,51.3 202.9,51.3 200.16,54.03 199.97,54.03 199.16,54.84 199.16,54.93 198.06,56.03 197.58,56.03 195.86,57.76 v2(195.86,60.62)
  BOTTOM w0.109: JDIMM1.260 208.68,44.84 v2(207.24,43.4) ; v1(195.12,60.62) v2(195.86,60.62) 196.12,60.88 RD14.2 196.73,59.93 RD79.2
DIMM1_SA2: length 46.2
  IN1 w0.102: v2(228.27,49.02) 227.53,49.02 225.13,51.41 208.33,51.41 200.66,59.08 200.4,59.08 199.62,59.86 199.62,60.19 198.01,61.8 v2(196.35,61.8)
  BOTTOM w0.109: v1(195.75,62.15) 196.09,61.8 v2(196.35,61.8) 196.81,61.8 RD15.2 197.08,62.96 RD80.2 ; JDIMM1.166 232.18,47.82 231.48,48.51 229.92,48.51 229.42,49.02 v2(228.27,49.02)
DIMM2_SA0: length 10.3
  TOP w0.254: JDIMM2.256 209.68,38.68 209.53,38.83 207.86,38.83 v2(207.81,38.78)
  BOTTOM w0.508: v2(207.81,38.78) 207.33,38.78 204.76,36.2 RD22.2 202.37,36.21 RD81.2
DIMM2_SA1: length 9.3
  TOP w0.254: JDIMM2.260 208.68,38.22 208.58,38.31 207.42,38.31 206.95,38.78 206.95,39.15
  TOP w0.508: v2(203.06,40.72) 205.38,40.72 206.95,39.15
  BOTTOM w0.508: v2(203.06,40.72) 202.41,41.37 RD23.2 202.42,41.48 RD82.2
DIMM2_SA2: length 10.3
  TOP w0.109: JDIMM2.166 232.18,36.59 231.61,36.03 231.61,34.73 v2(229.47,32.58)
  BOTTOM w0.109: RD83.2 228.41,29 RD24.2 v1(228.41,31.3) 228.41,31.53 v2(229.47,32.58)
DIMM3_SA0: length 15.9
  IN3 w0.081: v2(200.51,60.6) 201.49,59.63 208.04,59.63 208.8,58.86 208.8,58.28 v2(208.4,57.88)
  BOTTOM w0.102: JDIMM3.256 209.68,58.91 209.52,58.76 209.11,58.76 208.85,58.51 208.85,58.38 208.4,57.92 v2(208.4,57.88)
  BOTTOM w0.109: v1(200.29,61.57) 200.51,61.35 v2(200.51,60.6) 200.94,60.17 RD85.1 201.29,60.18 RD42.1
DIMM3_SA1: length 14
  TOP w0.109: v2(199.55,56.85) 199.55,56.2 v1(199.87,55.87)
  IN3 w0.081: v2(208.32,58.5) 201.96,58.5 200.45,57 199.91,57 199.76,56.85 v2(199.55,56.85)
  BOTTOM w0.102: JDIMM3.260 208.68,58.9 208.32,58.55 v2(208.32,58.5)
  BOTTOM w0.109: v2(199.55,56.85) RD86.1 199.55,55.72 199.56,55.71 199.56,54.93 RD43.1
DIMM3_SA2: length 43.7
  IN3 w0.081: v2(230.65,55.82) 229.76,55.82 226.46,59.11 210.48,59.11 209.58,60.01 203,60.01 201.65,61.35 200.48,61.35 199.5,60.38 v2(199.5,59.04)
  BOTTOM w0.109: RD40.2 198.58,57.66 RD87.2 198.77,57.66 199.34,58.23 199.34,58.88 v2(199.5,59.04) 199.5,59.82 v1(199.66,59.97)
  BOTTOM w0.14: v2(230.65,55.82) 230.65,55.82 230.62,55.84 230.62,55.97 230.99,56.34 230.99,57.74 232.18,58.92 JDIMM3.166
DIMM4_SA0: length 20.4
  TOP w0.102: v2(207.22,51.77) 208.23,52.79 209.49,52.79 209.68,52.61 JDIMM4.256
  TOP w0.109: v1(199.27,58.04) 199.55,57.76 v2(199.55,57.46)
  IN1 w0.102: v2(207.22,51.77) 200.3,58.69 199.86,58.69 199.55,58.37 v2(199.55,57.46)
  BOTTOM w0.109: v2(199.55,57.46) 200.03,56.98 201.82,56.98 202.32,56.47 RD89.2 202.32,55.41 RD46.2
DIMM4_SA1: length 14.8
  TOP w0.109: JDIMM4.260 208.68,50.93 208.54,50.79 207.86,50.79 v2(207.55,51.1)
  IN1 w0.102: v2(200.24,57.43) 201.06,57.43 206.77,51.73 206.77,51.33 207,51.1 v2(207.55,51.1)
  BOTTOM w0.109: v1(199.65,58.02) 200.23,57.43 v2(200.24,57.43) RD88.1 200.99,57.43 RD51.1
DIMM4_SA2: length 43.6
  TOP w0.102: JDIMM4.166 232.18,50.04 231.68,49.54 v2(231.29,49.54)
  IN1 w0.102: v2(231.29,49.54) 230.7,49.54 228.07,46.91 211.57,46.91 210.79,47.69 210.79,49.23 210.31,49.71 205.64,49.71 203.39,51.95 203.39,54.05 202.37,55.08 v2(200.4,55.08)
  BOTTOM w0.109: v1(200.83,52.58) 201.38,53.14 RD90.2 201.39,53.54 RD48.2 200.73,55.08 v2(200.4,55.08)
DISP_ON: length 14
  TOP w0.254: JEDP1.19 103.5,44.04 103.67,44.21 v2(103.67,44.41)
  IN1 w0.254: v2(108.99,47.56) 108.68,47.25 108.68,47.05 107.46,45.83 105.86,45.83 105.2,45.17 104.19,45.17 103.67,44.65 v2(103.67,44.41)
  BOTTOM w0.254: v2(108.99,47.56) 109.03,47.6 110.29,47.6 RV836.1 111.45,47.58 DV36.1 113.17,47.71 DV35.1 114.81,47.73 DV37.1
DMI_CRX_PTX_N0: length 86
  TOP w0.076: v2(220.86,92.31) 221.14,92.03 UC1.E8
  TOP w0.102: v2(201.2,27.56) 201.37,27.39 201.37,27.29 201.11,27.03 200.5,27.03 199.58,27.94 196.05,27.94 196.05,27.94 196.04,27.94 195.85,27.75 195.71,27.75 UH1.C33
  IN2 w0.094: v2(201.2,27.56) 201.27,27.63 201.27,30.76 200.05,31.98 200.05,32.96 200.72,33.63 201.97,33.63 202.6,34.26 202.6,35.08 203.25,35.74 203.61,35.74 204.49,36.62 204.49,40.12 203.96,40.65 203.96,43.9 204.25,44.19 204.25,45.84 204.67,46.26 204.67,47.99 203.66,49 203.66,52.49 204.55,53.38 204.55,58.16 206.13,59.74 206.13,79.22 216.29,89.38 216.29,90.08 217.49,91.28 217.49,91.54 218.95,92.99 220.35,92.99 220.68,92.66 220.68,92.49 v2(220.86,92.31)
DMI_CRX_PTX_N1: length 87.4
  TOP w0.076: UC1.F6 222.14,91.45 v2(222.14,91.5)
  TOP w0.102: v2(205.55,27.06) 205.33,27.27 205.33,27.5 205.12,27.7 202.97,27.7 202.25,28.43 198.67,28.43 198.65,28.45 198.44,28.45 198.08,28.45 198.08,28.44 195.48,28.44 195.35,28.34 UH1.C32
  IN2 w0.094: v2(205.55,27.06) 205.07,27.53 205.07,29.22 204.08,30.2 203.42,30.2 203.06,30.57 203.06,30.96 205.96,33.86 205.96,41.67 206.13,41.84 206.13,48.7 205.25,49.58 205.25,52 206.02,52.78 206.02,57.64 207.8,59.42 207.8,77.98 219.13,89.31 220.98,89.31 222.06,90.39 222.06,91.42 v2(222.14,91.5)
DMI_CRX_PTX_N2: length 84.2
  TOP w0.076: v2(220.84,90.74) 221.14,90.44 UC1.E5
  TOP w0.102: v2(203.51,28.91) 203.51,28.47 203.37,28.33 203.21,28.33 202.49,29.05 197.48,29.05 197.32,28.9 196.05,28.9 195.87,29.08 195.48,29.08 195.34,28.94 UH1.C31
  IN2 w0.094: v2(220.84,90.74) 220.66,90.91 220.66,91.07 220.38,91.35 219.21,91.35 217.56,89.71 217.56,89.57 206.81,78.82 206.81,59.58 205.17,57.94 205.17,53.11 204.37,52.31 204.37,49.17 205.32,48.23 205.32,45.99 204.86,45.53 204.86,43.95 204.55,43.65 204.55,41.52 205.14,40.94 205.14,34.19 202.11,31.16 202.11,30.18 202.91,29.38 203.62,29.38 203.72,29.27 203.72,29.13 v2(203.51,28.91)
DMI_CRX_PTX_N3: length 85.7
  TOP w0.076: v2(222.82,93.12) 223.14,92.8 UC1.J9
  TOP w0.102: UH1.C29 195.68,29.28 196,29.28 196.08,29.2 197.07,29.2 197.36,29.49 205.43,29.49 205.87,29.93 205.87,30.49 v2(206.09,30.71)
  IN2 w0.094: v2(222.82,93.12) 223.49,93.12 223.78,92.83 223.78,92.47 223.18,91.87 223.18,91.51 223.54,91.15 223.54,90.18 223.06,89.7 222.81,89.7 222.11,89 221.28,89 220.99,88.71 220.41,88.71 219.39,87.69 219.28,87.69 218.82,87.69 208.48,77.35 208.48,59.25 206.64,57.41 206.64,52.49 205.85,51.7 205.85,49.97 206.73,49.09 206.73,41.49 206.55,41.31 206.55,32.57 205.77,31.8 205.77,30.77 205.83,30.71 v2(206.09,30.71)
DMI_CRX_PTX_P0: length 86
  TOP w0.076: UC1.D8 220.49,91.92 v2(220.11,92.3)
  TOP w0.102: v2(201.91,27.56) 201.19,26.84 200.42,26.84 199.51,27.75 196.13,27.75 196.13,27.75 196.12,27.75 195.93,27.56 195.79,27.56 195.7,27.47 195.7,27.4 UH1.B33
  IN2 w0.094: v2(220.11,92.3) 220.26,92.15 220.41,92.15 220.48,92.23 220.48,92.58 220.27,92.8 219.03,92.8 217.69,91.45 217.69,91.2 216.48,90 216.48,89.3 206.32,79.14 206.32,59.66 204.74,58.08 204.74,53.3 203.86,52.41 203.86,49.08 204.86,48.08 204.86,46.18 204.45,45.76 204.45,44.11 204.15,43.82 204.15,40.74 204.69,40.2 204.69,36.54 203.69,35.54 203.34,35.54 202.79,35 202.79,34.18 202.05,33.43 200.8,33.43 200.25,32.88 200.25,32.06 201.47,30.85 201.47,28.01 v2(201.91,27.56)
DMI_CRX_PTX_P1: length 87.4
  TOP w0.076: UC1.E6 221.48,91.46 v2(221.48,91.51)
  TOP w0.102: UH1.B32 195.53,28.12 195.53,28.21 195.57,28.25 198.15,28.25 198.16,28.26 198.28,28.26 v4(198.36,28.26) 198.57,28.26 198.59,28.24 202.17,28.24 202.89,27.51 205.04,27.51 205.14,27.42 205.14,26.92 205.04,26.82 204.91,26.82 v2(204.68,27.06)
  IN2 w0.094: v2(221.48,91.51) 221.86,91.13 221.86,90.47 220.9,89.51 219.05,89.51 207.61,78.06 207.61,59.5 205.82,57.72 205.82,52.86 205.05,52.08 205.05,49.5 205.93,48.62 205.93,41.92 205.76,41.75 205.76,33.94 202.86,31.05 202.86,30.49 203.34,30.01 204,30.01 204.87,29.14 204.87,27.24 v2(204.68,27.06)
DMI_CRX_PTX_P2: length 84.1
  TOP w0.076: v2(220.09,90.72) 220.09,90.72 UC1.D5
  TOP w0.102: UH1.B31 195.49,28.73 195.49,28.82 195.56,28.89 195.79,28.89 195.97,28.71 197.4,28.71 197.56,28.86 202.41,28.86 203.13,28.14 203.45,28.14 v2(204.22,28.91)
  IN2 w0.094: v2(204.22,28.91) 204.05,28.91 203.92,29.05 203.92,29.35 203.7,29.57 202.99,29.57 202.3,30.26 202.3,31.07 205.34,34.11 205.34,41.02 204.75,41.6 204.75,43.57 205.05,43.87 205.05,45.45 205.51,45.91 205.51,48.31 204.57,49.25 204.57,52.23 205.37,53.03 205.37,57.86 207.01,59.5 207.01,78.74 217.76,89.49 217.76,89.62 219.29,91.15 220.3,91.15 220.47,90.99 220.47,90.69 220.37,90.6 220.22,90.6 v2(220.09,90.72)
DMI_CRX_PTX_P3: length 85.7
  TOP w0.076: v2(222.76,92.3) 222.93,92.13 UC1.J8
  TOP w0.102: UH1.B29 195.83,29.47 196.08,29.47 196.16,29.39 196.99,29.39 197.28,29.68 v4(199.35,29.68) 205.35,29.68 205.68,30.01 205.68,30.98 205.62,31.04 205.53,31.04 v2(205.2,30.71)
  IN2 w0.094: v2(222.76,92.3) 222.76,92.49 223.19,92.92 223.4,92.92 223.58,92.75 223.58,92.55 222.98,91.95 222.98,91.43 223.34,91.07 223.34,90.26 222.98,89.9 222.73,89.9 222.03,89.2 221.2,89.2 220.91,88.91 220.33,88.91 219.31,87.88 218.74,87.88 208.29,77.43 208.29,59.33 206.45,57.5 206.45,52.57 205.65,51.78 205.65,49.89 206.53,49.01 206.53,41.57 206.36,41.39 206.36,32.66 205.58,31.88 205.58,31.09 v2(205.2,30.71)
DMI_CTX_PRX_N0: length 87.4
  TOP w0.076: UC1.A8 218.8,91.9 218.89,91.99 218.89,92.16 218.83,92.22 218.38,92.22 218.29,92.31 217.72,92.31 217.7,92.29 217.68,92.29
  TOP w0.094: v2(191.67,26.2) 191.67,26.2 UH1.K34
  TOP w0.102: v2(215.46,93.17) 215.62,93.01 215.62,92.79 215.85,92.57 216.85,92.57 217.13,92.29 217.68,92.29
  IN2 w0.094: v2(191.67,26.2) 191.86,26.39 191.86,26.52 191.07,27.31 191.07,28.05 191.35,28.33 191.35,29.06 192.13,29.85 194.82,29.85 196.33,31.35 196.33,36.68 197.03,37.38 197.03,40.08 197.54,40.59 197.54,44.04 197.04,44.54 197.04,45.97 199.23,48.17 199.23,53 200.06,53.82 201.01,53.82 201.87,54.68 201.87,59.01 203.49,60.64 203.49,80.3 209.58,86.38 209.58,89.57 212.7,92.69 215.72,92.69 215.84,92.8 215.84,93 215.67,93.17 v2(215.46,93.17)
DMI_CTX_PRX_N1: length 82.8
  TOP w0.076: 217.68,91.67 217.7,91.67 217.72,91.69 218.01,91.69 218.26,91.43 219.44,91.43 219.54,91.33 219.54,91.19 219.46,91.12 UC1.B6
  TOP w0.094: v2(193.08,27.01) UH1.G33
  TOP w0.102: v2(215.04,91.94) 215.04,91.38 215.28,91.14 216.12,91.14 216.66,91.67 217.68,91.67
  IN2 w0.094: v2(193.08,27.01) 193.46,27.01 193.72,27.27 194.08,27.27 194.25,27.11 196.31,27.11 199.37,30.17 199.37,33.56 199.94,34.12 199.94,37.38 201.34,38.78 201.34,49.08 202.98,50.71 202.98,52.78 203.86,53.67 203.86,58.43 205.4,59.97 205.4,79.52 215.24,89.36 215.24,91.74 v2(215.04,91.94)
DMI_CTX_PRX_N2: length 84
  TOP w0.076: UC1.A5 218.58,90.31 218.77,90.31 218.87,90.41 218.87,90.57 218.78,90.67 218.29,90.67 218.13,90.5 217.66,90.5 217.64,90.48 217.62,90.48
  TOP w0.094: v2(191.63,27.59) UH1.K32
  TOP w0.102: v2(213.89,91.28) 214.07,91.47 214.1,91.47 214.23,91.47 215.21,90.48 217.62,90.48
  IN2 w0.094: v2(213.89,91.28) 214.07,91.46 214.27,91.46 214.39,91.34 214.39,89.48 204.77,79.85 204.77,60.2 203.2,58.63 203.2,53.94 201.68,52.42 201.68,50.25 200.54,49.12 200.54,47.34 199.28,46.08 199.28,44.69 199.56,44.41 199.56,40.96 200.32,40.19 200.32,38.6 199,37.28 199,35.79 199.34,35.45 199.34,34.58 198.7,33.94 198.7,32.37 197.86,31.53 197.86,30.13 195.5,27.77 194.42,27.77 194.31,27.89 193.01,27.89 192.96,27.94 192.41,27.94 191.95,27.47 191.75,27.47 v2(191.63,27.59)
DMI_CTX_PRX_N3: length 82
  TOP w0.076: UC1.B4 219.61,89.52 219.78,89.52 219.84,89.58 219.84,89.73 219.65,89.92 219.4,89.92 219.36,89.88 218.18,89.88 218.16,89.87 218.14,89.87
  TOP w0.094: v2(193.11,28.46) UH1.G30
  TOP w0.102: 218.14,89.87 212.53,89.87 212.22,90.17 v2(212.22,90.81)
  IN2 w0.094: v2(212.22,90.81) 212.51,90.51 212.51,89.94 210.79,88.21 210.79,86.75 204.1,80.06 204.1,60.4 202.57,58.87 202.57,54.27 201.01,52.72 201.01,50.45 199.83,49.27 199.83,47.68 197.94,45.78 197.94,44.77 198.72,43.99 198.72,40.8 199.17,40.35 199.17,39.48 198.13,38.44 198.13,36.13 197.18,35.18 197.18,31.02 195.26,29.1 193.9,29.1 193.26,28.46 v2(193.11,28.46)
DMI_CTX_PRX_P0: length 87.4
  TOP w0.076: 217.68,92.48 217.7,92.48 217.72,92.46 218.37,92.46 218.46,92.37 218.89,92.37 219.04,92.23 219.04,92.05 UC1.B8
  TOP w0.094: UH1.J35 192.4,26.18 v2(192.22,26)
  TOP w0.102: 217.68,92.48 217.21,92.48 216.93,92.76 215.92,92.76 215.82,92.87 215.82,93.05 215.94,93.17 v2(216.27,93.17)
  IN2 w0.094: v2(216.27,93.17) 216.03,92.94 216.03,92.72 215.81,92.49 212.78,92.49 209.78,89.49 209.78,86.3 203.69,80.22 203.69,60.56 202.07,58.93 202.07,54.59 201.09,53.62 200.14,53.62 199.43,52.91 199.43,48.09 197.23,45.89 197.23,44.63 197.74,44.12 197.74,40.51 197.23,40 197.23,37.3 196.52,36.6 196.52,31.27 194.9,29.65 192.21,29.65 191.54,28.98 191.54,28.25 191.26,27.97 191.26,27.4 192.06,26.6 192.06,26.16 v2(192.22,26)
DMI_CTX_PRX_P1: length 82.7
  TOP w0.076: 217.68,91.86 217.7,91.86 217.72,91.84 218.09,91.84 218.34,91.59 219.5,91.59 219.69,91.39 219.69,91.26 UC1.C6
  TOP w0.094: UH1.F34 v2(193.75,26.63)
  TOP w0.102: 217.68,91.86 216.58,91.86 216.04,91.33 215.36,91.33 215.23,91.46 215.23,91.6 215.57,91.94 v2(215.67,91.94)
  IN2 w0.094: v2(193.75,26.63) 193.75,27.02 193.8,27.08 194,27.08 194.16,26.91 196.39,26.91 199.57,30.09 199.57,33.47 200.13,34.04 200.13,37.29 201.54,38.7 201.54,49 203.17,50.63 203.17,52.7 204.05,53.59 204.05,58.35 205.6,59.89 205.6,79.44 215.44,89.28 215.44,91.71 v2(215.67,91.94)
DMI_CTX_PRX_P2: length 84
  TOP w0.076: UC1.B5 219.04,90.48 219.04,90.62 218.84,90.82 218.23,90.82 218.06,90.65 217.66,90.65 217.64,90.67 217.62,90.67
  TOP w0.094: v2(192.36,27.36) UH1.J32
  TOP w0.102: 217.62,90.67 215.29,90.67 214.3,91.66 214.23,91.66 214.1,91.66 v2(213.89,91.86)
  IN2 w0.094: v2(192.36,27.36) 192.36,27.61 192.5,27.75 192.87,27.75 192.93,27.69 194.23,27.69 194.34,27.58 195.58,27.58 198.05,30.04 198.05,31.44 198.9,32.29 198.9,33.86 199.53,34.5 199.53,35.53 199.19,35.87 199.19,37.2 200.51,38.52 200.51,40.27 199.75,41.04 199.75,44.49 199.47,44.77 199.47,46 200.74,47.26 200.74,49.04 201.87,50.17 201.87,52.34 203.39,53.86 203.39,58.55 204.96,60.11 204.96,79.77 214.59,89.4 214.59,91.42 214.35,91.66 214.09,91.66 v2(213.89,91.86)
DMI_CTX_PRX_P3: length 82
  TOP w0.076: 218.14,90.06 218.16,90.06 218.18,90.04 219.29,90.04 219.33,90.08 219.71,90.08 220,89.79 220,89.67 UC1.D4
  TOP w0.094: v2(193.85,28.27) UH1.F30
  TOP w0.102: v2(212.85,90.87) 212.41,90.43 212.41,90.25 212.6,90.06 218.14,90.06
  IN2 w0.094: v2(193.85,28.27) 193.71,28.41 193.71,28.63 193.98,28.9 195.34,28.9 197.38,30.94 197.38,35.1 198.33,36.05 198.33,38.36 199.36,39.39 199.36,40.43 198.91,40.88 198.91,44.07 198.13,44.85 198.13,45.7 200.03,47.6 200.03,49.19 201.21,50.37 201.21,52.63 202.77,54.19 202.77,58.79 204.29,60.32 204.29,79.98 210.99,86.67 210.99,88.13 212.71,89.85 212.71,90.73 v2(212.85,90.87)
DMIC0: length 335.3
  TOP w0.109: v2(105.56,27.06) 106.26,27.75 106.26,32.02 v1(103.72,34.56) 102.01,36.26 CV843.1 100.73,36.26 DV4.3 99.98,37.86 100.4,38.29 100.4,41.64 100.5,41.74 JEDP1.13 ; v2(337.35,20.12) 337.7,19.77 338.43,19.77 338.74,20.07 338.74,22.15 339.64,23.05 340.54,23.05 RA52.2 341.72,24.23 UA1.4 ; v2(273.93,24.05) 273.56,23.69 273.56,18.04 273.08,17.55 271.38,17.55 270.93,18 269.49,18 269.28,18.22 266.9,18.22 266.36,17.68 262.85,17.68 254.74,9.57 254.74,7.56 250.98,3.8 248.63,3.8 v2(247.52,2.69)
  IN1 w0.102: v2(337.35,20.12) 337.35,20.39 336.98,20.76 334.28,20.76 332.63,22.41 331.57,22.41 331.24,22.08 330.7,22.08 329.24,23.54 329.24,24.56 327.74,26.05 324.46,26.05 320.21,30.3 320.21,32.92 318.28,34.85 313.02,34.85 309.23,38.64 309.23,40.97 308.26,41.95 308.26,42.75 307.26,43.74 305.46,43.74 304.92,43.2 297.49,43.2 295.96,41.67 291.98,41.67 289.74,39.43 281.76,39.43 278.97,36.63 278.97,35.13 275.95,32.11 275.95,25.97 274.03,24.05 v2(273.93,24.05)
  IN4 w0.102: v2(105.56,27.06) 108.2,27.06 109.2,26.06 115.57,26.06 117.24,24.38 117.24,20.68 117.01,20.44 117.01,18.89 117.43,18.46 117.43,18.19 118.71,16.92 118.71,15.89 125.47,9.13 128.43,9.13 128.91,8.65 128.91,8.21 128.45,7.76 127.15,7.76 124.74,5.34 124.74,3.01 125.47,2.27 138.4,2.27 139.27,3.14 139.27,5.7 140.69,7.13 145.69,7.13 147.98,9.42 155.86,9.42 156.5,10.06 157.54,10.06 160.89,6.71 164.9,6.71 165.07,6.88 170.39,6.88 173.69,3.58 174.77,3.58 175.11,3.25 175.11,2.76 175.98,1.88 188.04,1.88 189.01,2.85 192.2,2.85 193.17,1.88 247.02,1.88 247.52,2.38 v2(247.52,2.69)
DMIC_CLK: length 335.8
  TOP w0.109: v2(248.13,2.67) 248.77,3.31 251.26,3.31 255.24,7.29 255.24,9.35 263.03,17.14 266.51,17.14 267.1,17.73 270.8,17.73 271.38,17.15 273.15,17.15 274.1,18.1 274.1,22.8 273.99,22.91 v2(273.99,23.33) ; RA14.1 341.03,22.3 CA54.1 339.63,21.38 339.04,20.79 339.04,20.1 338.47,19.52 v2(337.29,19.52) ; JEDP1.11 99.5,42.7 99.63,42.57 99.63,40.94 98.31,39.62 98.31,38.02 98.05,37.76 DV4.2 98.05,36.17 98.34,35.88 CV842.1 99.52,35.27 100.02,34.78 v1(100.27,34.78) 102.97,34.78 105.92,31.83 105.92,28.03 v2(104.95,27.06)
  IN1 w0.102: v2(273.99,23.33) 276.43,25.77 276.43,31.91 279.45,34.93 279.45,36.43 281.96,38.94 289.94,38.94 292.18,41.18 296.16,41.18 297.69,42.71 305.12,42.71 305.66,43.26 307.06,43.26 307.77,42.55 307.77,41.75 308.75,40.77 308.75,38.44 312.82,34.37 318.08,34.37 319.72,32.72 319.72,30.1 324.09,25.73 327.38,25.73 328.75,24.36 328.75,23.69 330.6,21.85 331.34,21.85 331.66,22.18 332.53,22.18 334.18,20.53 336.78,20.53 336.94,20.37 336.94,19.87 v2(337.29,19.52)
  IN4 w0.102: v2(104.95,27.06) 104.95,26.78 105.24,26.49 108.44,26.49 109.1,25.83 115.02,25.83 116.03,24.81 116.03,23.21 116.41,22.83 116.41,20.23 115.88,19.7 115.88,18.3 116.53,17.65 117.65,17.65 118.48,16.82 118.48,15.8 125.38,8.9 128.33,8.9 128.68,8.55 128.68,8.31 128.36,7.99 127.06,7.99 124.51,5.44 124.51,2.91 125.37,2.05 138.49,2.05 139.49,3.05 139.49,4.34 141.01,5.86 143.63,5.86 143.73,5.96 143.73,6.76 143.87,6.9 145.78,6.9 148.07,9.19 157.72,9.19 160.71,6.2 165.38,6.2 165.52,6.35 169.92,6.35 171.76,4.5 171.76,2.32 172.47,1.62 247.08,1.62 v2(248.13,2.67)
DMIC_CLK_CODEC: length 4.2
  TOP w0.109: UA1.5 341.78,23.83 341.62,23.68 341.62,23.27 341.25,22.9 340.72,22.9 340.2,22.38 RA14.2 339.74,22.38 v1(339.23,21.87)
DP1_GPU_SEL#: length 86.9
  TOP w0.109: UV66.9 68.06,36.96 v2(68.12,37.02)
  IN3 w0.081: v2(45.32,35.28) 45.32,34.78 45.47,34.64 46.15,34.64 46.46,34.95 47.43,34.95 47.86,35.37 47.86,36.85 48.08,37.07 49.67,37.07 50.14,37.54 51.36,37.54 51.55,37.35 54.81,37.35 55.99,36.17 59.33,36.17 59.92,36.76 60.77,36.76 61.77,37.76 65.81,37.76 66.6,36.96 68.06,36.96 v2(68.12,37.02) ; v2(38.33,32.37) 37.83,31.87 26.46,31.87 26.03,32.29 21.78,32.29 15.73,26.25 13.61,26.25 12.77,25.4 10.17,25.4 9.87,25.71 7.81,25.71 6.75,24.65 6.75,18.2 6.45,17.91 6.45,15.88 6.8,15.54 6.8,14.96 5.35,13.52 v2(5.35,13.08)
  BOTTOM w0.109: v2(5.35,13.08) 6.22,12.21 UE12.16 ; v1(45.76,35.69) 45.35,35.28 v2(45.32,35.28) 45,34.96 44.78,34.96 44.71,34.89 43.29,34.89 43.09,34.69 40.83,34.69 39.16,33.03 39.16,32.62 38.9,32.37 v2(38.33,32.37)
DP1_SW1_REXT: length 4.5
  TOP w0.109: UV66.31 61.29,32.71 60.84,32.25 60.84,31.84 60.66,31.66 60.66,30.74 v1(60.78,30.62) 61.14,30.62 61.8,29.95 RV861.2
DP1_SW2_CFG0: length 2.3
  TOP w0.109: RV125.2 193.25,111.17 v1(192.95,111.46) 192.95,111.82 192.64,112.13 UV8.59
DP1_SW2_PC10: length 6.9
  TOP w0.109: v1(191.09,108.55) 191.72,109.19 RV63.2 193.18,109.19 RV64.1 193.37,109.37 193.37,110.52 192.58,111.31 192.23,111.31 191.44,112.09 UV8.56
DP1_SW2_PC11: length 4.4
  TOP w0.109: v1(192.92,110.15) 192.92,110.38 192.28,111.01 RV62.1 191.66,111.01 191.65,111.02 RV61.2 190.75,111.29 191.04,111.58 UV8.55
DP1_SW2_PC20: length 6.1
  TOP w0.109: v1(187.68,108.77) 188.48,108.77 RV59.2 189.34,109.17 189.35,109.18 189.78,109.18 RV60.1 189.82,109.17 190.2,109.55 190.2,109.58 190.25,109.63 190.25,111.32 190.64,111.71 UV8.54
DP1_SW2_PC21: length 6.3
  TOP w0.109: v1(186.78,109.88) 187.26,109.4 188.1,109.4 188.33,109.63 189.54,109.63 189.78,109.87 RV57.2 RV58.1 189.78,111.23 190.24,111.7 UV8.53
DP1_SW2_PEQ: length 3.5
  TOP w0.203: UV8.8 v2(194.78,116.15)
  BOTTOM w0.109: v1(195.12,115.57) 195.12,115.81 v2(194.78,116.15) 194.28,116.15 RV55.2 193.55,116.88 RV56.1
DP1_SW2_PI0: length 3.8
  TOP w0.109: v1(195.94,110.94) 195.71,111.17 RV127.2 194.7,111.17 194.24,111.63 193.65,111.63 193.04,112.23 UV8.60
DP1_SW2_PI1: length 5.2
  TOP w0.109: UV8.1 194.69,113.35 195.01,113.03 RV66.1 RV65.2 196.17,112.55 v1(197.66,112.55)
DP1_SW2_SW: length 5.2
  TOP w0.109: RV126.2 195.03,122.4 194.81,122.18 v1(194.81,121.96) 194.81,121.31 195.1,121.02 195.42,121.02 195.65,120.79 195.65,120.41 195.39,120.15 UV8.18
DP2_GPU_SEL#: length 191.5
  TOP w0.109: UV67.9 v2(147.5,46.34)
  IN3 w0.081: v2(42.45,28.19) 42.05,28.19 41.75,28.49 41.26,28.49 41.03,28.26 41.03,26.96 39,24.93 37.83,24.93 34.16,21.26 31.88,21.26 30.84,20.21 30.04,20.21 29.34,19.51 29.34,16.88 27.41,14.95 27.41,12.04 26.23,10.86 26.23,7.37 22.22,3.35 19.8,3.35 18.77,4.39 18.77,4.64 18.15,5.26 16.55,5.26 14.05,7.75 12.35,7.75 9.02,11.08 8.42,11.08 v2(6.39,13.11) ; v2(48.55,39.76) 49.59,40.8 51.24,40.8 52,41.56 53.97,41.56 54.21,41.32 54.21,41.06 54.68,40.58 56.8,40.58 57.12,40.25 65.34,40.25 66.04,40.96 66.59,40.96 66.71,41.08 68.53,42.9 68.53,45.12 69.04,45.63 69.32,45.63 69.73,46.05 70.55,46.87 75.63,46.87 77.54,44.95 80.22,44.95 81.26,43.92 83.56,43.92 84.92,42.56 89.31,42.56 96.01,49.27 109.39,49.27 110.09,48.57 114.38,48.57 116.73,46.22 116.73,45.31 117.4,44.64 118.33,44.64 119.29,43.67 122.88,43.67 124.6,45.39 127.86,45.39 130.37,47.9 134.71,47.9 135.22,47.39 137.3,47.39 137.53,47.16 139.13,47.16 139.42,46.87 146.97,46.87 v2(147.5,46.34)
  BOTTOM w0.109: v2(48.55,39.76) 48.22,39.42 v1(48.22,38.94) 48.22,38.31 47.39,37.48 47.39,36.07 47.72,35.74 47.72,35.12 47.37,34.78 47.1,34.78 46.31,33.99 45.15,33.99 45.09,33.94 43.68,33.94 43.42,33.68 41.58,33.68 41.39,33.49 41.39,32.77 41.16,32.54 41.16,32.45 40.94,32.23 40.94,30.69 41.5,30.13 41.5,28.85 42.16,28.19 v2(42.45,28.19) ; UE12.18 v2(6.39,13.11)
DP2_SW1_REXT: length 18.3
  TOP w0.109: UV67.31 140.81,41.75 140.19,41.12 140.19,40.55 139.81,40.17 138.43,40.17 137.99,40.62 134.86,40.62 134.7,40.77 130.38,40.77 129.84,40.24 129.05,40.24 128.67,40.62 128.67,41.48 v1(129.72,42.53) 129.86,42.67 RV870.2
DPSRC_HPD: length 2.2
  TOP w0.109: v2(31.96,42.19) 31.96,42.6 31.95,42.61 31.95,43.1 32.22,43.37 RT184.1
  BOTTOM w0.109: UT1.R5 v2(31.96,42.19)
DRON: length 86.5
  TOP w0.127: v2(253.7,137.35) 253.62,137.43 253.62,138.9 PR1216.1
  TOP w0.203: v2(238.69,139.29) 238.88,139.09 238.88,138.02 238.47,137.61 PR1220.1 ; PU1100.17 262.18,140.15 262.4,139.93 263.06,139.93 263.29,139.7 263.29,138.73
  TOP w0.254: v2(246.36,137.01) 246.36,137.43 PR1218.1 ; v2(268.06,131.35) v3(264.96,134.45) 263.75,135.66 v2(263.75,137.88) 263.29,138.35 263.29,138.73 ; PR1222.1 230.56,135.28 231.02,135.74 231.02,136.59 230.63,136.97 v2(230.41,136.97) ; PU1800.16 218.93,131.17 v2(219.09,131.32)
  IN2 w0.254: v2(219.09,131.32) 218.33,130.56 218.33,129.65 218.88,129.09 225.49,129.09 228.97,132.57 228.97,135.7 229.47,136.2 229.99,136.2 230.41,136.62 v2(230.41,136.97) 230.19,137.19 230.19,138.61 230.75,139.17 238.57,139.17 v2(238.69,139.29) 238.69,139.59 239.63,140.53 241.01,140.53 241.33,140.21 241.33,139.74 242.51,138.55 243.91,138.55 245.25,137.22 246.15,137.22 v2(246.36,137.01) 246.92,137.01 248.99,139.08 253.39,139.08 253.7,138.78 v2(253.7,137.35) 253.88,137.17 261.43,137.17 262.14,137.88 v2(263.75,137.88)
  BOTTOM w0.254: PR1223.1 230.57,136.81 v2(230.41,136.97) ; v2(246.36,137.01) 245.75,137.01 PR1219.1 ; PR1217.1 253.6,138.76 253.6,137.91 253.7,137.81 v2(253.7,137.35) ; PU1700.16 268.01,131.29 v2(268.06,131.35) ; v2(238.69,139.29) 238.13,138.73 PR1221.1
EC_FPM_EN: length 12.3
  TOP w0.109: JUSH1.22 186.6,2.55 186.67,2.62 186.67,4.23 190.13,7.69 191.9,7.69 192.29,8.07 v1(192.51,8.07) 194.77,8.07 195,7.84 RZ1483.2
EDP_AUXN: length 178.1
  TOP w0.102: UC1.B26 219.48,106.08 219.55,106 219.55,105.87 219.46,105.78 217.7,105.78 217.55,105.92 217.29,105.92 v2(217,106.2)
  IN1 w0.102: v2(102.57,37.42) 102.51,37.42 102.26,37.18 102.26,35.99 100.63,34.36 100.63,31.15 101.69,30.09 111.61,30.09 112.03,29.67 112.77,29.67 113.27,29.17 116.54,29.17 120.49,33.12 120.49,33.49 120.93,33.93 120.93,34.83 121.72,35.62 121.72,37.35 122.33,37.96 125.2,37.96 126.22,38.98 126.8,38.98 129.32,41.51 130.81,41.51 131.14,41.84 135.69,41.84 136.19,41.34 137.12,41.34 137.92,40.55 140.05,40.55 140.21,40.7 141.14,40.7 141.72,40.12 147.9,40.12 149.72,38.3 152.31,38.3 152.39,38.37 153.54,38.37 154.39,39.22 154.39,40.13 157.16,42.9 158.05,42.9 159.81,44.66 160.78,44.66 168.89,52.77 168.89,54.32 169.93,55.36 170.75,55.36 173.1,57.72 175.82,57.72 185.32,67.21 185.32,69.56 190.53,74.77 190.53,78.29 200.16,87.92 204.07,87.92 206.47,90.32 206.47,99.09 212.6,105.22 212.6,105.76 213.49,106.64 214.05,106.64 214.96,105.73 216.53,105.73 v2(217,106.2)
  BOTTOM w0.102: v2(102.57,37.42) 102.28,37.7 102.28,37.79 103.06,38.56 103.37,38.56 103.58,38.56 103.73,38.56 103.85,38.44 CV838.1
EDP_AUXN_C: length 2.8
  BOTTOM w0.102: UV64.27 106.3,38.97 106.2,39.07 105.99,39.07 v4(105.62,38.7) 105.4,38.48 104.78,38.48 CV838.2
EDP_AUXP: length 178.1
  TOP w0.102: UC1.C26 219.74,105.99 219.74,105.79 219.54,105.59 217.62,105.59 217.48,105.73 217.18,105.73 v2(217,105.54)
  IN1 w0.102: v2(101.96,37.42) 102.08,37.3 102.08,36.07 100.45,34.44 100.45,31.07 101.61,29.9 111.53,29.9 111.95,29.48 112.69,29.48 113.2,28.98 116.61,28.98 120.67,33.04 120.67,33.42 121.11,33.86 121.11,34.76 121.9,35.55 121.9,37.27 122.41,37.77 125.28,37.77 126.3,38.8 126.87,38.8 129.4,41.32 130.89,41.32 131.22,41.65 135.62,41.65 136.11,41.15 137.05,41.15 137.84,40.36 140.13,40.36 140.29,40.52 141.06,40.52 141.65,39.93 147.82,39.93 149.64,38.11 152.39,38.11 152.46,38.18 153.61,38.18 154.58,39.15 154.58,40.06 157.24,42.72 158.13,42.72 159.89,44.47 160.86,44.47 169.08,52.69 169.08,54.25 170.01,55.18 170.83,55.18 173.18,57.53 175.9,57.53 185.51,67.13 185.51,69.48 190.72,74.69 190.72,78.21 200.24,87.73 204.15,87.73 206.66,90.25 206.66,99.01 212.79,105.14 212.79,105.68 213.57,106.46 213.97,106.46 214.88,105.54 v2(217,105.54)
  BOTTOM w0.102: v2(101.96,37.42) 102.09,37.55 102.09,37.87 102.98,38.75 103.37,38.75 103.58,38.75 CV837.1
EDP_AUXP_C: length 2.8
  BOTTOM w0.102: CV837.2 104.78,38.68 105.27,38.68 105.68,39.08 105.73,39.08 105.91,39.26 106.19,39.26 106.3,39.37 UV64.28
EDP_COMP: length 14.4
  TOP w0.127: UC1.D37 220.52,113.63 v2(220.45,113.69)
  BOTTOM w0.109: RC1.1 208.3,112.36 213.31,112.36 v1(213.78,112.83) 214.24,113.29 217.94,113.29 218.34,113.69 v2(220.45,113.69)
EDP_IN1_AEQ#: length 2.7
  BOTTOM w0.109: UV64.59 116.24,36.97 116.35,37.07 116.6,37.07 116.88,36.8 116.88,36.53 117.28,36.13 117.28,35.97 RV824.1
EDP_IN1_PEQ: length 5.8
  BOTTOM w0.109: UV64.52 116.34,39.77 116.95,40.37 RV833.1 117.71,40.58 117.71,41.8 v1(118.24,42.33) 118.34,42.43 118.34,42.91 RV826.1
EDP_IN2_AEQ#: length 12.5
  BOTTOM w0.109: RV825.1 117.69,30.18 118.07,30.18 v1(118.77,30.89) 119.15,31.27 119.15,31.73 119.71,32.29 119.71,35.95 119.36,36.3 117.44,36.3 117.11,36.63 117.11,36.9 116.64,37.37 UV64.58
EDP_IN2_PEQ: length 5
  BOTTOM w0.109: UV64.51 116.24,40.17 117.16,41.08 RV834.1 116.19,42.56 v1(116.19,42.66) 116.19,43 RV827.1
EDP_SW1_PC0: length 13.2
  TOP w0.109: v2(115.36,42.74) 114.78,42.74 113.77,41.74 v2(110.26,41.74) 109.18,40.66 v1(109.18,40.11)
  IN2 w0.081: v2(110.26,41.74) 110,41.74 109.36,42.37 108.22,42.37 v2(108.22,42.37)
  BOTTOM w0.109: RV830.1 107.54,43.05 v2(108.22,42.37) ; RV822.1 115.36,43.11 v2(115.36,42.74) ; UV64.38 v2(110.26,41.74)
EDP_SW1_PC1: length 13.2
  BOTTOM w0.109: UV64.55 116.19,38.57 116.83,37.93 RV831.1 117.55,38.08 118.2,38.73 118.2,41.39 119.06,42.24 119.06,44.68 117.79,45.94 RV823.1 117.16,46.31 v1(116.46,47.01)
EDP_SW1_PI0: length 13.4
  BOTTOM w0.109: RV828.1 117.9,29.5 119.39,31 119.39,31.63 119.97,32.21 119.97,35.33 v1(120.18,35.54) 120.18,36.47 119.18,37.46 118.03,37.46 RV829.1 117.25,37.29 117.12,37.29 116.24,38.17 UV64.56
EDP_TXN0: length 148.4
  TOP w0.076: v2(220.85,108.05) 220.85,108.16 UC1.E29
  IN1 w0.102: v2(220.85,108.05) 220.67,108.23 220.67,108.43 220.4,108.7 216.99,108.7 216.9,108.78 213.09,108.78 210.82,106.51 210.82,105.96 198.44,93.58 198.44,93.3 197.93,92.79 197.93,88.91 188.16,79.13 188.16,76.11 182.22,70.18 182.22,69.31 177.88,64.98 176.52,64.98 165.65,54.11 165.65,53.51 162.26,50.12 162.26,49.69 157.34,44.77 156.19,44.77 153.49,42.07 151.91,42.07 150.26,43.72 142.07,43.72 141.64,43.29 139.64,43.29 139.23,43.69 129.36,43.69 129.05,43.38 128.64,43.38 126.07,40.82 125.41,40.82 124.34,39.74 120.98,39.74 116.59,35.36 116.59,34.6 117.25,33.94 118.16,33.94 118.61,34.39 118.61,34.69 v2(118.84,34.92)
  BOTTOM w0.102: CV830.1 118.9,33.87 118.76,34.01 118.76,34.32 118.55,34.53 118.55,34.75 118.71,34.92 v2(118.84,34.92)
EDP_TXN0_C: length 7.8
  BOTTOM w0.102: CV830.2 118.94,33.12 118.94,32.32 118.62,31.99 117.82,31.99 117.49,32.32 117.49,32.84 v4(117.07,33.26) 116.17,34.17 116.11,34.17 115.69,34.59 115.69,34.64 115.39,34.94 114.97,34.94 114.76,35.16 114.76,35.35 114.66,35.45 UV64.2
EDP_TXN1: length 153.5
  TOP w0.076: UC1.E28 221.14,107.55 v2(221.44,107.24)
  IN1 w0.102: v2(115.29,30.81) 115.29,36.48 116.04,37.24 117.57,37.24 120.67,40.34 123.95,40.34 125.06,41.45 125.84,41.45 128.67,44.29 137.27,44.29 137.74,44.76 139.3,44.76 140.05,44.02 140.85,44.02 141.76,44.93 150.63,44.93 151.91,43.65 154.04,43.65 155.78,45.38 157.12,45.38 161.64,49.91 161.64,50.35 164.88,53.59 164.88,54.21 176.28,65.61 177.61,65.61 181.44,69.44 181.44,70.43 187.56,76.55 187.56,79.39 197.3,89.14 197.3,93.57 207.46,103.73 207.46,103.99 213.07,109.6 217.01,109.6 217.29,109.32 220.08,109.32 220.28,109.13 220.84,109.13 221.22,108.75 221.58,108.75 222.07,108.26 222.07,107.76 221.73,107.42 221.63,107.42 v2(221.44,107.24)
  BOTTOM w0.102: v2(115.29,30.81) 115.5,31.02 115.5,31.24 CV832.1
