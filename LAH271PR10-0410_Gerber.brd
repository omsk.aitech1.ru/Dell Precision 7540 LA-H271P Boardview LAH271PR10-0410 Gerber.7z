# Allegro board LAH271PR10-0410_Gerber.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on IN3 (solid shape): 370.82,10.97 370.94,10.9 370.92,10.76 370.79,10.55 370.75,10.3 370.75,4.4 368.89,4.4 367.39,2.9 368.89,1.4 370.75,1.4 370.75,0.2 364.45,0.2 364.45,5.56 364.2,6.09 363.64,6.25 363.62,6.25 363.34,6.13 363.14,5.91 363.03,5.8 362.88,5.76 344.42,5.76 344.34,5.77 344.27,5.8 344.24,5.82 344.24,5.92 346.29,5.92 346.71,6.34 347.35,6.34 347.77,5.92 362.55,5.92 362.55,5.92 362.84,5.92 363.63,6.71 363.63,6.71 364.12,6.65 364.55,6.4 366.39,6.4 370.29,10.3 370.34,10.65 370.5,10.97
GND on IN3 (solid shape): outline of 118 points within 215.71,23.09 372.05,154.3
GND on IN3 (solid shape): outline of 1006 points within 0.2,0.2 343.23,154.3
GND on IN3 (solid shape): outline of 1038 points within 219.35,127.28 247.15,138.21
GND on IN4 (solid shape): 172.37,13.55 172.37,12.03 172.35,12.01 168.6,12.01 167.76,12.86 167.72,12.86 167.45,13.12 167.45,13.65 167.69,13.88 172.04,13.88
GND on IN4 (solid shape): 193.08,53.53 193.08,51.06 192.41,50.38 190.55,50.38 190.01,50.93 188.63,50.93 188.48,51.08 188.48,54.04 188.64,54.2 192.41,54.2
GND on IN4 (solid shape): 217.67,130.72 217.67,128.28 216.62,127.23 209.58,127.23 208.63,128.18 208.63,128.9 209.23,129.51 213.14,129.51 214.96,131.33 217.06,131.33
GND on IN4 (solid shape): 370.82,10.97 370.94,10.9 370.92,10.76 370.79,10.55 370.75,10.3 370.75,4.4 368.89,4.4 367.39,2.9 368.89,1.4 370.75,1.4 370.75,0.2 364.45,0.2 364.45,5.56 364.2,6.09 363.64,6.25 363.62,6.25 363.34,6.13 363.14,5.91 363.03,5.8 362.88,5.76 344.42,5.76 344.34,5.77 344.27,5.8 344.24,5.82 344.24,5.92 346.25,5.92 346.65,6.31 347.71,6.31 348.11,5.92 362.86,5.92 363.66,6.72 363.73,6.72 364.21,6.62 364.61,6.34 365.58,6.34 366.55,7.31 366.55,8.48 367.9,9.83 369.62,9.83 370.31,10.52 370.38,10.76 370.5,10.97
GND on IN4 (solid shape): outline of 114 points within 215.71,23.03 372.05,154.3
GND on IN4 (solid shape): outline of 823 points within 0.2,0.2 343.53,154.3
GND on IN4 (solid shape): outline of 919 points within 27.59,25.97 38.1,32.08
GND on IN4 (solid shape): outline of 1713 points within 219.68,127.57 254.38,140.43
GND on TOP: 248.57,36.04 250.07,34.54 275.57,34.54 276.19,35.16 276.19,62.36 275.29,63.26 272.92,63.26 266.77,69.42 255,69.42 250.89,65.31 249.4,65.31 248.57,64.49 ; 1 cut-out
GND on TOP: 260.2,86.99 260.2,98.89 260.42,99.11 260.42,99.44 260.02,99.84 260.02,101.61 260.02,101.61 260.46,102.05 260.46,102.5 260.5,102.54 261.65,102.54 261.71,102.61 261.71,103.07 261.64,103.15 260.72,103.15 260.46,103.41 260.46,113.03 257.89,115.59 218.65,115.59 217.58,114.53 217.58,89.09 220.23,86.44 259.66,86.44 ; 1 cut-out
GND on TOP: 355.26,15.43 356.69,15.43 356.82,15.29 356.82,13.82 356.75,13.75 355.2,13.75 354.95,14.01 354.95,15.11
GND on TOP: 210.5,61.05 210.5,36.13 212.13,34.51 231.09,34.51 232.15,35.57 232.15,53.2 231.96,53.4 231.96,56.28 232.14,56.46 232.14,63.06 232.67,63.59 236.32,63.59 237.08,64.35 237.08,65.98 234.61,68.44 217.01,68.44 212.31,63.74 212.31,62.61 210.75,61.05 ; 1 cut-out
GND on TOP: 177.48,42.26 192.8,42.26 195,40.06 195,31.63 195.11,31.51 195.37,31.51 195.44,31.44 195.44,31.35 195.42,31.32 195.25,31.32 194.76,30.83 194.76,30.54 194.87,30.42 194.87,30.2 195.03,30.05 195.73,30.05 195.92,30.24 197.21,30.24 197.35,30.1 197.35,29.95 197.14,29.75 197,29.75 196.92,29.66 195.34,29.66 195.21,29.53 195.21,29.06 194.86,28.71 194.86,27.16 194.82,27.12 194.82,22.07 193.82,21.06 193.02,21.06 191.98,20.03 189.48,20.03 188.9,19.45 188.72,19.45 188.57,19.61 188.57,20.09 187.82,20.83 183.24,20.83 183.03,21.04 177.14,21.04 176.75,21.43 175.01,21.43 174.41,22.03 174.41,22.87 174.71,23.16 174.71,39.49 ; 1 cut-out
GND on BOTTOM: 358.38,13.73 356.5,13.73 356.27,13.96 356.27,15.3 356.41,15.44 358.24,15.44 358.79,14.89 358.79,14.14
GND on BOTTOM: 248.77,61.79 248.77,36.29 249.75,35.31 249.75,35.3 252.12,35.3 253.01,34.41 253.29,34.41 254.18,35.3 255.64,35.3 255.88,35.54 258.1,35.54 258.1,35.53 258.33,35.3 268.38,35.3 268.65,35.56 270.1,35.56 270.36,35.3 276.33,35.3 276.7,35.67 276.7,63.66 275.91,64.44 273.89,64.44 273.16,65.18 256.79,65.18 256.33,64.72 256.33,64.65 256.1,64.42 256.09,64.42 253.79,62.12 249.1,62.12 ; 4 cut-outs
GND on BOTTOM: 231.61,62.37 231.61,62.36 232.29,61.69 232.29,36.68 230.88,35.27 226.32,35.27 225.81,34.76 225.81,32.83 225.74,32.77 225.39,32.77 225.36,32.8 225.36,35.18 225.27,35.27 209.99,35.27 208.05,37.21 208.05,60.31 210.12,62.37 222.35,62.37 222.71,62.73 223.04,62.73 223.4,62.37 ; 7 cut-outs
GND on GND1: outline of 294 points within 0.2,0.2 372.05,154.3 ; 7 cut-outs
GND on IN1: outline of 106 points within 4.23,32.25 26.23,68.42
GND on GND2: outline of 290 points within 0.2,0.2 372.05,154.3 ; 6 cut-outs
GND on GND3: outline of 297 points within 0.2,0.2 372.05,154.3 ; 6 cut-outs
GND on VCC: outline of 396 points within 0.2,0.2 342.85,154.3
GND on VCC: outline of 182 points within 215.73,18.61 372.05,154.3
GND on VCC: 271.9,129.39 272.25,129.04 272.25,120.31 276.44,116.12 276.44,100.75 272.76,97.07 272.76,96.35 272.76,94.3 272.63,94.17 270.72,96.08 270.72,108.77 267.88,111.62 260.88,111.62 260.83,111.66 260.83,125.79 258.99,127.62 247.88,127.62 247.38,128.11 230.55,128.11 230.21,128.45 230.21,135.66 231.18,136.63 259.74,136.63 266.98,129.39 271.57,129.39 271.57,129.39
GND on VCC: 365.38,0.2 364.45,0.2 364.45,5.56 363.93,6.24 363.14,5.91 363.03,5.8 362.88,5.76 344.42,5.76 344.27,5.8 344.16,5.91 344.12,5.96 344.08,6.01 344.08,7.76 348.23,11.9 349.66,11.9 351.28,13.52 351.28,15.33 353.19,15.33 353.63,14.89 354.95,14.89 355.46,15.4 359.05,15.4 359.09,15.36 359.09,13.82 359.52,13.4 359.52,12.74 359.56,12.69 359.5,12.63 359.46,12.65 359.04,12.58 358.99,12.15 359.4,11.99 359.65,12.35 359.71,12.45 359.83,12.43 360.22,12.04 362.54,12.04 363.29,11.28 366.67,11.28 366.97,11.59 368.54,11.59 369.05,11.08 369.76,11.08 369.76,11.07 370.52,11.07 370.59,11.01 370.92,11.01 371.01,10.94 370.99,10.83 370.81,10.59 370.75,10.3 370.75,0.2 ; 1 cut-out
GND on GND4: outline of 283 points within 0.2,0.2 372.05,154.3 ; 6 cut-outs
GND on IN4: 16.89,38.61 16.89,39.1 16.46,39.53 15.7,39.53 14.84,38.67 8.86,38.67 5.76,41.78 4.16,43.37 4.16,52.61 5.25,53.71 5.25,56.91 3.86,58.3 3.86,67.33 5.03,68.5 8.33,68.5 10.43,66.4 13.26,66.4 16.91,62.76 16.91,58.69 17.41,58.18 17.41,57.61 17.3,57.5 17.3,53.54 21.28,49.55 21.28,47.76 21.74,47.3 21.74,46.09 24.4,43.44 24.4,43.43 24.49,43.28 24.64,43.19 24.65,43.18 24.78,43.06 24.78,42.49 25.62,41.65 26.45,41.65 26.96,41.13 26.96,33.75 25.76,32.55 24.12,32.55 23.48,33.19 22.64,33.19 19.48,36.34 19.16,36.34
GND on GND5: outline of 280 points within 0.2,0.2 372.05,154.3 ; 6 cut-outs
GND_CHASSIS on TOP (solid shape): 176.87,150.36 176.87,147.39 176.81,147.32 173.28,147.32 173.22,147.38 173.22,150.32 173.34,150.43 176.8,150.43
GNDA on TOP (solid shape): 352.85,19.77 353.97,19.77 354.19,19.55 354.19,19.22 354.01,19.04 352.98,19.04 352.69,18.76 351.7,18.76 351.65,18.81 351.65,19.74 351.7,19.8 352.82,19.8
GNDA on TOP (solid shape): 355.41,23.8 355.41,23.3 355.42,23.28 356.65,23.28 356.65,22.7 357.15,22.7 357.15,23.24 357.15,23.25 357.4,23.25 357.45,23.2 357.45,22.49 357.52,22.43 361.03,22.43 361.26,22.2 361.26,21.79 360.98,21.51 356.94,21.51 356.79,21.65 356.79,21.68 356.4,21.99 356.08,21.61 356.05,21.54 355.98,21.51 354.68,21.51 354.5,21.68 354.5,21.82 354.48,21.83 354.48,22.12 354.61,22.24 354.64,22.23 354.69,22.23 354.74,22.23 354.98,22.3 355.12,22.53 355.11,22.67 355.05,22.8 355.02,22.88 355.05,22.96 355.12,23.29 354.89,23.53 354.87,23.55 354.87,23.67 355.06,23.87 355.33,23.87
GNDA on BOTTOM (solid shape): 349.59,29.46 349.59,28.46 349.55,28.42 349.08,28.42 348.61,28.89 346.78,28.89 346.7,28.97 346.7,29.76 347.14,30.21 348.84,30.21
GNDA on TOP: 348.85,26.01 349.21,26.01 349.4,26.2 349.4,27.02 349.3,27.12 348.77,27.12 348.39,26.73 347.52,26.73 347.46,26.68 347.44,26.65 347.44,25.87 347.51,25.8 348.63,25.8
GNDA on GND1: 369.26,11.59 368.75,12.09 366.76,12.09 366.46,11.79 363.5,11.79 362.76,12.53 360.44,12.53 360.02,12.95 360.02,13.61 359.6,14.03 359.6,15.56 359.26,15.9 355.25,15.9 354.74,15.4 353.84,15.4 353.4,15.84 350.31,15.84 350.12,15.65 349.22,15.65 349.03,15.84 346.54,15.84 346.48,15.86 346.44,15.84 346.39,15.84 346.39,15.83 346.02,16.2 346.02,18.74 346.02,18.74 346.02,20.48 346.03,20.49 347.77,20.49 348.1,20.82 348.1,25.64 347.75,25.98 346.59,25.98 346.59,28.56 346.59,28.56 346.59,28.87 346.21,29.25 346.21,30.19 346.29,30.26 348.8,30.26 349.53,29.53 349.53,27.32 350.3,26.55 354.76,26.55 355.12,26.18 355.12,24.21 355.44,23.89 355.44,23.11 356.1,22.44 371.45,22.44 371.45,20.1 370.95,19.9 370.75,19.4 370.75,14.4 370.95,13.9 371.45,13.7 371.45,11.59
GNDA on GND2: 369.26,11.59 368.75,12.09 366.76,12.09 366.46,11.79 363.5,11.79 362.76,12.53 360.44,12.53 360.02,12.95 360.02,13.61 359.6,14.03 359.6,15.56 359.26,15.9 355.25,15.9 354.74,15.4 353.84,15.4 353.4,15.84 350.31,15.84 350.12,15.65 349.22,15.65 349.03,15.84 346.54,15.84 346.48,15.86 346.44,15.84 346.39,15.84 346.39,15.83 346.02,16.2 346.02,18.73 346.02,18.73 346.02,20.48 346.03,20.49 347.77,20.49 348.1,20.82 348.1,25.64 347.75,25.98 346.59,25.98 346.59,28.87 346.21,29.25 346.21,30.19 346.29,30.26 348.8,30.26 349.53,29.53 349.53,27.32 350.3,26.55 354.76,26.55 355.12,26.18 355.12,24.21 355.44,23.89 355.44,23.11 356.1,22.44 371.45,22.44 371.45,20.1 370.95,19.9 370.75,19.4 370.75,14.4 370.95,13.9 371.45,13.7 371.45,11.59
GNDA on GND3: 369.26,11.59 368.75,12.09 366.76,12.09 366.46,11.79 363.5,11.79 362.76,12.53 360.44,12.53 360.02,12.95 360.02,13.61 359.6,14.03 359.6,15.57 359.26,15.9 355.25,15.9 354.74,15.4 353.84,15.4 353.4,15.84 350.31,15.84 350.12,15.65 349.22,15.65 349.03,15.84 346.54,15.84 346.48,15.86 346.44,15.84 346.39,15.84 346.39,15.83 346.02,16.2 346.02,18.73 346.02,18.73 346.02,20.49 346.02,20.49 347.77,20.49 348.1,20.82 348.1,25.64 347.75,25.98 346.59,25.98 346.59,28.56 346.59,28.87 346.21,29.25 346.21,30.19 346.29,30.26 348.8,30.26 349.53,29.53 349.53,27.32 350.3,26.55 354.76,26.55 355.12,26.18 355.12,24.21 355.44,23.89 355.44,23.11 356.1,22.44 371.45,22.44 371.45,20.1 370.95,19.9 370.75,19.4 370.75,14.4 370.95,13.9 371.45,13.7 371.45,11.59
GNDA on VCC: outline of 89 points within 346.02,11.79 370.43,30.26
GNDA on GND4: 369.26,11.59 368.75,12.09 366.76,12.09 366.46,11.79 363.5,11.79 362.76,12.53 360.44,12.53 360.02,12.95 360.02,13.61 359.6,14.03 359.6,15.57 359.27,15.9 355.25,15.9 354.74,15.4 353.84,15.4 353.4,15.84 350.31,15.84 350.12,15.65 349.22,15.65 349.03,15.84 346.54,15.84 346.48,15.86 346.44,15.84 346.39,15.84 346.39,15.83 346.02,16.2 346.02,18.72 346.02,18.73 346.02,20.49 346.02,20.49 347.77,20.49 348.1,20.82 348.1,25.64 347.75,25.98 346.59,25.98 346.59,28.87 346.21,29.25 346.21,30.19 346.29,30.26 348.8,30.26 349.53,29.53 349.53,27.32 350.3,26.55 354.76,26.55 355.12,26.18 355.12,24.21 355.44,23.89 355.44,23.11 356.1,22.44 371.45,22.44 371.45,20.1 370.95,19.9 370.75,19.4 370.75,14.4 370.95,13.9 371.45,13.7 371.45,11.59
GNDA on GND5: 369.26,11.59 368.75,12.09 366.76,12.09 366.46,11.79 363.5,11.79 362.76,12.53 360.44,12.53 360.02,12.95 360.02,13.61 359.6,14.03 359.6,15.57 359.26,15.9 355.25,15.9 354.74,15.4 353.84,15.4 353.4,15.84 350.31,15.84 350.12,15.65 349.22,15.65 349.03,15.84 346.54,15.84 346.48,15.86 346.44,15.84 346.39,15.84 346.39,15.83 346.02,16.2 346.02,18.54 346.02,20.49 346.02,20.49 347.77,20.49 348.1,20.82 348.1,25.64 347.75,25.98 346.59,25.98 346.59,28.87 346.21,29.25 346.21,30.19 346.29,30.26 348.8,30.26 349.53,29.53 349.53,27.32 350.3,26.55 354.76,26.55 355.12,26.18 355.12,24.21 355.44,23.89 355.44,23.11 356.1,22.44 371.45,22.44 371.45,20.1 370.95,19.9 370.75,19.4 370.75,14.4 370.95,13.9 371.45,13.7 371.45,11.59
GNDA_CHG on TOP (solid shape): 284.36,36.17 284.36,35.6 284.32,35.56 283.74,35.56 283.62,35.43 283.62,33.8 283.53,33.71 283.25,33.71 283.11,33.57 283.11,32.97 283.03,32.89 282.15,32.89 282.01,32.74 282.01,32.03 281.92,31.95 281.46,31.95 281.33,32.08 281.33,34.08 281.4,34.14 282.13,34.14 282.24,34.25 282.24,34.59 282.26,34.61 282.81,34.61 282.82,34.62 282.82,35.09 282.81,35.1 282.28,35.1 282.26,35.11 282.26,35.66 282.86,36.26 284.27,36.26
GNDA_CHG on BOTTOM (solid shape): outline of 272 points within 281.44,25.87 290.49,36.28
VDD12_A on TOP (solid shape): 71.51,31.69 71.56,31.68 71.79,31.68 71.85,31.66 71.91,31.65 72.36,31.65 72.45,31.57 72.45,31.33 72.34,31.22 72.28,31.19 72.23,31.16 72.09,31.16 72.04,31.2 71.59,31.2 71.39,31 71.39,30.78 71.33,30.72 71.15,30.72 71.13,30.74 71.13,31.58 71.26,31.71 71.46,31.71
VDD12_A on BOTTOM (solid shape): 62.54,31.79 62.68,31.79 62.69,31.79 62.78,31.78 62.87,31.79 62.88,31.79 62.94,31.79 62.97,31.82 62.98,31.82 63.13,31.97 63.62,31.97 63.65,31.93 63.65,31.31 63.57,31.22 62.8,31.22 62.28,30.7 62.28,29.43 62.17,29.32 61.55,29.32 61.48,29.38 61.48,30.17 61.17,30.48 61.17,31.04 60.97,31.23 60.97,32.02 61.14,32.19 62.14,32.19
VDD12_A on IN4 (solid shape): 71.98,30.99 71.98,30.72 71.9,30.63 71.88,30.63 71.8,30.59 71.72,30.54 71.56,30.54 71.25,30.7 70.95,30.54 69.77,30.54 69.76,30.54 69.66,30.55 69.55,30.54 69.54,30.54 68.64,30.54 68.63,30.54 68.46,30.58 68.29,30.54 68.28,30.54 67.43,30.54 67.42,30.54 67.26,30.58 67.1,30.54 67.08,30.54 66.14,30.54 66.13,30.54 66.04,30.55 65.94,30.54 65.93,30.54 64.02,30.54 63.75,30.66 63.48,30.54 61.75,30.54 61.46,30.83 61.46,31.32 61.63,31.49 71.49,31.49
VDD12_B on TOP (solid shape): 141.52,39.7 141.52,37.94 141.29,37.72 139.49,37.72 139.37,37.84 139.37,38.48 139.42,38.49 139.49,38.5 139.55,38.53 139.6,38.56 139.64,38.59 140.35,38.59 140.51,38.75 140.51,39 140.35,39.16 139.85,39.16 139.79,39.22 139.79,39.77 139.85,39.84 140.34,39.84 140.48,39.98 141.23,39.98
VDD12_B on BOTTOM (solid shape): 141.53,39.92 141.53,38.93 141.25,38.65 140.38,38.65 140.26,38.76 140.26,39.91 140.44,40.09 141.37,40.09
VDD33_A on TOP (solid shape): 71.97,38.73 72.19,38.67 72.41,38.73 73.49,38.73 73.6,38.61 73.61,38.61 73.84,38.38 73.84,37.72 73.71,37.6 73.04,37.6 72.99,37.64 72.99,38.11 72.95,38.16 71.92,38.16 71.74,37.98 71.74,37.62 71.66,37.52 71.63,37.39 71.63,37.34 71.22,37.34 71.11,37.45 71.11,38.17 71.64,38.7 71.69,38.73
VDD_1.2V on TOP (solid shape): 202.89,10.39 202.89,9.59 202.05,8.75 201.47,8.75 201.21,8.49 201.21,7.68 201.1,7.57 199.04,7.57 198.83,7.78 198.83,8.67 199.15,8.98 200.74,8.98 202.21,10.45 202.82,10.45
VDDA12_A on BOTTOM (solid shape): 66.17,30.49 66.25,30.42 66.25,30.03 66.18,29.96 65.83,29.96 65.81,29.94 65.81,29.94 65.64,29.78 65.64,29.25 65.87,29.02 65.87,27.13 65.72,26.98 64.76,26.98 64.64,27.1 64.64,29.1 64.87,29.34 64.87,30.14 64.73,30.28 64.23,30.28 64.17,30.33 64.17,30.86 64.21,30.9 65.77,30.9
VDDA12_B on TOP (solid shape): 146.53,37.91 146.52,37.82 146.52,37.38 146.52,37.38 146.52,36.34 146.15,35.97 146.15,35.17 146.07,35.09 145.57,35.09 145.47,35.19 145.47,35.94 145.47,35.94 145.47,37.49 145.35,37.62 145.35,38.01 146.44,38.01
VDDA12_B on BOTTOM (solid shape): 145.23,38.66 145.23,38.25 145.56,37.93 146.44,37.93 146.53,37.84 146.53,37.32 146.01,36.81 143.85,36.81 143.74,36.92 143.74,38.72 143.79,38.78 145.11,38.78
VDDP_1.2V on TOP (solid shape): 203.29,10.37 203.29,8.84 203.62,8.51 203.62,8.51 203.78,8.35 203.78,6.09 203.7,6.01 202.67,6.01 202.53,6.15 202.53,7.52 202.4,7.65 201.48,7.65 201.36,7.77 201.36,8.46 201.49,8.58 202.19,8.58 203.06,9.46 203.06,10.36 203.13,10.43 203.22,10.43
VDDRX12_A on TOP (solid shape): 61.98,36.41 61.98,35.94 61.98,35.94 61.98,35.85 62.26,35.57 62.26,35.47 62.2,35.41 61.4,35.41 61.17,35.64 61.17,36.67 61.31,36.81 61.59,36.81
VDDRX12_A on BOTTOM (solid shape): 62.56,39.5 62.56,35.75 62.47,35.65 61.34,35.65 61.17,35.82 61.17,36.67 61.53,37.03 61.53,39.43 61.75,39.65 62.41,39.65
VDDRX12_A on BOTTOM (solid shape): outline of 91 points within 66.62,35.98 71.01,37.9
VDDRX12_A on IN1 (solid shape): 67.36,37.63 67.36,36.48 67.12,36.24 62.35,36.24 61.76,35.65 61.31,35.65 61.15,35.81 61.15,36.65 61.41,36.91 63.73,36.91 63.74,36.88 64.06,36.69 64.37,36.88 64.39,36.91 64.94,36.91 65.25,36.71 65.57,36.89 65.59,36.92 66.01,36.92 66.88,37.8 67.18,37.8
VDDRX12_B on TOP (solid shape): 139.94,46.84 139.94,45.89 139.99,45.84 141.03,45.84 141.27,45.59 141.27,45.39 141.09,45.2 140.34,45.2 140.01,44.87 139.31,44.87 139.26,44.92 139.26,45.52 139.22,45.56 139.22,46.83 139.28,46.88 139.9,46.88
VDDRX12_B on BOTTOM (solid shape): 142.09,46.23 142.09,44.85 141.98,44.75 141.98,44.75 141.74,44.51 140.74,44.51 140.67,44.44 140.3,44.44 140.16,44.58 140.16,45.22 141.43,46.49 141.83,46.49
VDDTX12_A on BOTTOM (solid shape): outline of 184 points within 65.78,28.98 73.31,31.09
VDDTX12_B on TOP (solid shape): 152.07,38.22 152.07,37.29 151.77,36.99 151.4,36.99 151.23,37.16 151.23,37.44 151.17,37.5 149.96,37.5 149.91,37.55 149.91,38.14 149.97,38.19 151.05,38.19 151.11,38.25 152.04,38.25
VDDTX12_B on BOTTOM (solid shape): 149.49,40 151.37,40 151.51,39.85 152.07,39.3 152.07,38.61 151.97,38.52 151.72,38.52 151.46,38.77 151.45,38.79 151.36,38.95 151.2,39.05 151.18,39.05 150.98,39.25 149.7,39.25 149.66,39.21 149.65,39.21 149.51,39.11 149.42,38.97 148.4,38.97 148.31,39.02 148.21,39.04 148.13,39.08 148.09,39.16 147.83,39.51 147.39,39.45 147.31,39.42 147.22,39.45 146.76,39.5 146.52,39.1 146.51,39.04 146.47,39 146.4,38.93 143.63,38.93 143.47,39.08 143.47,39.95 143.62,40.09 145.48,40.09 145.9,40.51 148.97,40.51
+BL_PWR_SRC on TOP (solid shape): outline of 197 points within 89.09,36.28 96.15,44.04
+BL_PWR_SRC_F on TOP (solid shape): 88.94,43.74 88.94,42.88 88.89,42.83 88.89,40.08 89.02,39.95 89.06,39.82 88.96,39.73 88.71,39.23 89.26,39.11 89.36,39.14 89.45,39.09 89.51,39.03 89.6,38.98 89.64,38.96 89.64,38.08 89.62,38.03 89.58,38.01 89.25,37.73 89.45,37.34 89.45,36.51 89.06,36.12 87.74,36.12 87.58,36.28 87.58,37.16 87.62,37.2 87.63,37.2 87.75,37.31 87.75,38.04 86.72,39.07 86.72,42.67 86.48,42.91 86.48,43.79 86.62,43.93 88.75,43.93
+CAMERA_VDD on TOP (solid shape): 98.67,44.03 98.67,42.03 98.66,42.02 98.66,41.01 98.17,40.52 98.15,40.52 97.93,40.41 97.83,40.2 97.83,40.17 96.98,39.32 96.32,39.32 96.19,39.45 96.19,40.01 98,41.81 98,42.26 98.26,42.52 98.26,42.52 98.33,42.59 98.33,44 98.41,44.08 98.62,44.08
+CAMERA_VDD on BOTTOM (solid shape): 81.54,58.63 81.54,58.07 81.31,57.84 79.68,57.84 79.58,57.94 79.58,58.69 79.76,58.87 81.29,58.87
+CAMERA_VDD on BOTTOM (solid shape): outline of 101 points within 90.83,41.74 98.83,50.43
+DCIN on TOP (solid shape): 292.16,33.16 292.16,32.55 292.02,32.41 291.91,32.41 291.87,32.46 290.3,32.46 290.08,32.23 290.08,31.57 289.9,31.39 289.11,31.39 289.04,31.46 289.04,32.15 290.2,33.31 290.97,33.31 290.98,33.32 291.07,33.32 291.16,33.41 291.91,33.41
+DGFF_PWR on TOP (solid shape): 102.3,15.29 102.3,12.91 102.51,12.7 102.54,12.7 103.31,12.7 103.33,12.72 103.33,13.27 103.77,13.27 103.77,12.74 103.78,12.73 103.78,12.72 104.53,12.72 104.53,13.26 104.54,13.27 104.95,13.27 104.98,13.24 104.98,12.82 104.98,12.74 105.02,12.7 105.39,12.7 105.79,12.7 105.94,12.55 105.94,10.63 105.38,10.08 100.31,10.08 99.3,11.09 99.3,15.24 99.57,15.51 102.08,15.51
+DGFF_PWR_SRC on TOP (solid shape): 107.04,16.88 107.04,15.77 107.69,15.12 107.69,11.41 107.51,11.23 106.3,11.23 106.17,11.36 106.17,12.61 105.93,12.85 105.35,12.85 105.35,12.85 105.14,12.85 105.12,12.86 105.12,13.41 104.38,13.41 104.38,12.85 103.93,12.85 103.93,13.41 103.16,13.41 103.16,12.83 102.57,12.83 102.43,12.96 102.43,15.72 103.84,17.13 106.41,17.13 106.42,17.14 106.78,17.14
+EDP_VDD on TOP (solid shape): 98.52,23.14 98.52,21.33 97.6,20.41 95.43,20.41 95.26,20.58 95.26,21.17 95.79,21.69 97.11,21.69 97.52,22.1 97.52,22.65 97.51,22.67 96.97,22.67 96.95,22.68 96.95,22.84 96.97,22.86 97.33,22.86 97.33,22.86 97.43,22.86 97.45,22.87 97.5,22.87 97.5,22.92 97.51,22.94 97.51,23.26 97.54,23.29 98.37,23.29
+IR_F on TOP (solid shape): 71.93,48.67 71.93,47.18 71.58,46.83 70.67,46.83 70.4,47.1 70.4,47.92 70.4,47.93 70.4,48.22 70.29,48.33 70.29,48.81 70.29,48.82 70.29,49.14 70.48,49.32 71.28,49.32
+IR_F on BOTTOM (solid shape): 76.48,53.4 76.48,52.24 76.33,52.09 74.94,52.09 74.85,52.18 74.85,53.43 75,53.57 76.31,53.57
+IR_F on IN1 (solid shape): 75.97,53.55 75.97,52.29 75.48,51.8 74.4,51.8 73.23,50.63 73.09,50.54 73,50.4 72.13,49.53 71.59,49.59 71.64,49.04 71.32,48.72 70.34,48.72 70.26,48.79 70.26,50.33 73.69,53.76 75.76,53.76
+LCDVDD on TOP (solid shape): 98.13,44.69 98.13,42.57 97.82,42.26 97.82,41.89 96.06,40.14 96.06,39.39 95.96,39.29 95.39,39.29 95.21,39.46 95.21,41.35 96.43,42.57 96.7,42.57 96.85,42.72 96.85,44.69 96.97,44.8 98.02,44.8
+LCDVDD on TOP (solid shape): 97.38,23.42 97.38,23 97.38,23 96.84,23 96.82,22.98 96.82,22.55 96.85,22.53 97.37,22.53 97.39,22.51 97.39,22.26 97.37,22.24 96.15,22.24 95.9,21.99 94.68,21.99 94.43,21.73 94.43,21.29 94.74,20.98 94.74,19.59 94.64,19.49 93.94,19.49 93.79,19.64 93.79,20.22 93.54,20.48 93.54,22.33 94.74,23.53 97.27,23.53
+LCDVDD on BOTTOM: 94.14,21.23 93.97,21.39 93.97,23.73 94.01,23.77 94.39,23.77 94.4,23.77 94.5,23.75 94.6,23.77 94.61,23.77 94.76,23.77 94.91,23.92 94.91,28.79 94.11,29.59 94.11,32.54 93.41,33.24 93.41,35.37 93.41,37.53 93.54,37.8 93.41,38.07 93.41,38.8 94.2,39.59 94.2,41.1 94.53,41.43 96.05,41.43 96.43,41.05 96.43,38.6 95.54,37.7 95.54,36.24 95.3,36.01 95.3,34.17 95.98,33.49 95.98,31.23 97.2,30.01 97.2,30 97.35,29.86 97.35,26.26 97.67,25.94 97.67,21.59 97.3,21.23
+REGCTL_PNP10 on BOTTOM (solid shape): 187.16,127.77 187.16,127.68 187.11,127.64 186.3,127.64 186.19,127.52 185.74,127.52 185.43,127.22 185.41,127.22 185.09,127.05 185.08,126.7 185.08,126.55 184.93,126.39 184.57,126.39 184.24,126.06 183.58,126.06 183.5,126.14 183.5,127.56 183.55,127.61 184.79,127.61 184.97,127.79 185.92,127.79 185.93,127.8 186,127.82 186.07,127.84 187.09,127.84
+TBT_SVR_IND on BOTTOM (solid shape): 26.03,53.08 26.03,51.9 26.35,51.58 27.78,51.58 28.8,50.57 28.8,50.56 29.07,50.29 29.07,49.16 30.11,48.12 30.11,44.72 30.66,44.18 30.66,43.16 30.64,43.14 30.53,43.12 30.44,43.06 30.23,43.06 30.09,43.13 29.94,43.14 29.9,43.13 29.86,43.18 29.85,43.25 29.84,43.3 29.84,43.82 29.58,44.08 29.58,44.21 29.58,44.43 29.43,44.58 29.21,44.58 29.02,44.77 29.02,44.78 29.01,44.93 28.94,45.07 28.94,45.24 29.01,45.57 28.71,45.73 28.66,45.78 28.64,45.85 28.64,46.94 27.14,48.45 27.14,48.89 27.15,49.01 27.14,49.1 27.14,49.11 27.14,49.21 26.99,49.36 26.8,49.36 26.75,49.36 24.04,49.36 23.87,49.53 23.87,53.19 23.92,53.25 25.86,53.25
+UZ12_VHIO on TOP (solid shape): 120.75,21.51 120.75,20.7 120.96,20.48 123.05,20.48 123.46,20.07 123.46,19.45 123.4,19.38 122.39,19.38 122.15,19.14 122.15,18.94 122.09,18.88 121.56,18.88 121.55,18.91 121.27,19.1 120.96,18.97 120.92,18.94 120.88,18.93 120.74,19.01 120.58,19.02 120.55,19.02 120.44,19.13 120.44,21.52 120.53,21.61 120.65,21.61
+UZ12_VHIO on BOTTOM (solid shape): 122.21,20.07 122.21,19.12 121.8,18.72 121.67,18.69 121.59,18.79 121.33,19.08 120.96,18.97 120.92,18.94 120.88,18.93 120.48,18.99 120.28,18.64 120.31,18.53 120.36,18.42 120.4,18.38 120.04,18.02 120.03,18.01 119.41,17.51 118.91,16.89 118.91,16.89 118.31,16.29 118.15,16.29 118.15,16.37 118.16,16.38 117.88,16.9 117.5,16.45 117.48,16.34 117.38,16.29 117.01,16.29 116.87,16.43 116.87,17.72 116.98,17.83 117.5,17.83 118.37,18.71 119,18.71 119.8,19.51 120.19,19.51 120.59,19.91 120.59,20.06 120.82,20.29 121.99,20.29
+UZ12_VHIO on IN4 (solid shape): outline of 169 points within 119.63,19.79 123.61,24.64
+VR_CAP on TOP (solid shape): 130.18,22.97 130.18,22.83 129.91,22.56 129.64,22.56 129.62,22.54 129.6,22.54 129.58,22.53 128.5,21.45 127.97,21.45 127.7,21.72 127.42,21.72 127.32,21.82 127.32,22.33 127.37,22.38 127.87,22.38 128.18,22.08 128.54,22.08 129.53,23.07 130.08,23.07
+VR_CAP on IN1 (solid shape): outline of 650 points within 130.46,26.44 137.89,29.01
BATDRV_GATE on TOP (solid shape): 311.45,12.84 311.45,11.46 311.13,11.13 310.52,11.13 310.22,11.43 310.22,12.96 310.36,13.1 311.19,13.1
BATDRV_GATE on TOP (solid shape): 285.02,25.06 285.02,24.41 285.14,24.29 285.53,24.29 285.88,23.93 285.88,23.4 285.75,23.27 284.8,23.27 284.33,23.74 284.29,23.79 284.24,23.83 284.05,24.02 284.05,25.11 284.15,25.21 284.88,25.21
BATDRV_GATE on IN3 (solid shape): 287.15,23.85 287.15,23.14 287.05,23.04 285.37,23.04 285.05,23.36 285.05,24.16 285.14,24.25 286.74,24.25
BATDRV_GATE on IN3 (solid shape): 310.77,13.19 310.77,12.76 310.54,12.53 310.05,12.53 309.44,13.14 309.44,13.52 309.77,13.85 310.11,13.85
BL_PWR_SRC_ON on TOP (solid shape): outline of 161 points within 80.97,35.05 86.57,43.26
BST_1.2V on TOP (solid shape): 205.96,11.57 207.33,11.57 207.47,11.43 207.47,11.21 207.35,11.09 206.96,11.09 206.89,11.15 206.88,11.15 206.85,11.18 206.66,11.18 205.92,11.18 205.7,11.4 204.73,11.4 204.66,11.47 204.66,11.61 204.72,11.66 205.87,11.66
BST_3V on TOP (solid shape): 111.72,6.2 111.72,5.39 112.46,4.65 112.46,4.09 112.44,4.07 111.5,4.07 111.44,4.12 111.44,6.2 111.5,6.25 111.67,6.25
BST_3VR on TOP (solid shape): 310.19,27.81 310.19,27.03 310.41,26.81 311.25,26.81 311.76,26.29 311.76,25.84 311.69,25.77 310.04,25.77 310,25.81 310,26.54 309.77,26.77 309.77,27.77 309.89,27.9 310.11,27.9
BST_5V on BOTTOM (solid shape): 72.01,14.69 72.01,13.58 71.97,13.54 71.22,13.54 71.07,13.68 71.07,13.94 70.69,14.32 69.87,14.32 69.77,14.43 69.77,14.54 69.96,14.73 71.97,14.73
BST_5VR on TOP (solid shape): 308.89,37.7 308.89,36.94 309.13,36.7 309.47,36.7 309.66,36.51 309.66,35.56 309.56,35.46 308.59,35.46 308.48,35.57 308.48,37.59 308.67,37.79 308.8,37.79
BST_+1VSP on TOP (solid shape): 152.21,11.59 152.21,10.75 152.19,10.72 152.19,10.3 151.75,9.87 149.84,9.87 149.58,10.13 149.58,11.33 149.65,11.4 150.29,11.4 150.41,11.28 150.41,11.01 150.7,10.72 151.13,10.72 151.35,10.94 151.35,11.59 151.45,11.69 152.11,11.69
BST_IO on BOTTOM (solid shape): 277.08,101.02 277.08,100.23 277.03,100.18 274.04,100.18 273.62,99.75 273.62,99.4 273.51,99.3 273.4,99.3 273.3,99.39 273.3,100.91 273.52,101.13 276.96,101.13
CORE_SW1 on TOP (solid shape): 253.18,136.16 253.18,132.91 252.87,132.61 252.87,131.51 251.79,130.43 249.6,130.43 249.52,130.51 249.52,131.49 249.49,131.51 248.73,131.51 248.71,131.49 248.71,130.52 248.56,130.37 247.53,130.37 247.35,130.55 247.35,134.08 248.07,134.8 251.87,134.8 252.01,134.94 252.01,136.24 252.07,136.3 253.04,136.3
CORE_SW1 on BOTTOM (solid shape): 252.85,133.3 252.85,132.39 252.23,131.76 251.67,131.76 251.47,131.97 251.47,132.42 251.7,132.66 251.7,133.3 251.83,133.42 252.73,133.42
CORE_SW2 on TOP (solid shape): 245.19,130.55 244.93,130.29 241.98,130.29 241.85,130.42 241.85,131.43 241.82,131.46 240.98,131.46 240.98,131.45 240.98,130.47 240.75,130.23 239.84,130.23 239.6,130.47 239.6,133.81 240.48,134.69 244.14,134.69 244.34,134.89 244.34,136.08 244.43,136.17 245.19,136.17
CORE_SW2 on BOTTOM (solid shape): 245.23,133.32 245.23,132.23 245.08,132.08 244.16,132.08 244.04,132.2 244.04,133.15 244.13,133.23 244.13,133.37 244.2,133.44 245.11,133.44
CORE_SW3 on TOP (solid shape): 237.5,136.12 237.5,131.08 236.75,130.33 234.19,130.33 234.05,130.48 234.05,131.43 234.02,131.46 233.26,131.46 233.23,131.44 233.23,130.52 233.09,130.37 231.98,130.37 231.89,130.46 231.89,132.92 232,133.02 232,133.89 232.81,134.7 236.64,134.7 236.71,134.77 236.71,136.12 236.77,136.18 237.44,136.18
CORE_SW3 on BOTTOM (solid shape): 237.47,133.39 237.47,132.61 237.53,132.55 237.53,132.25 237.44,132.17 236.5,132.17 236.43,132.24 236.43,133.33 236.52,133.43 237.43,133.43
CORE_SW4 on TOP (solid shape): 229.61,128.02 229.42,127.83 226.43,127.83 226.3,127.96 226.3,128.94 226.29,128.95 225.49,128.95 225.47,128.93 225.47,127.97 225.36,127.86 224.23,127.86 224.12,127.96 224.12,131.83 224.24,131.95 224.24,131.96 224.55,132.28 228.67,132.28 228.81,132.42 228.81,133.7 228.84,133.72 229.61,133.72
CORE_SW4 on BOTTOM (solid shape): 229.7,130.87 229.7,129.82 228.95,129.07 228.36,129.07 228.26,129.17 228.26,130.1 228.59,130.43 228.59,130.89 228.67,130.97 229.59,130.97
EN_1.8V on TOP (solid shape): 131.01,7.55 131.01,7.03 130.59,6.6 130.59,6.24 130.1,5.75 129.16,5.75 129.09,5.82 129.09,6.03 129.15,6.09 129.91,6.09 130.08,6.27 130.08,6.6 129.91,6.78 128.79,6.78 128.52,7.05 128.52,7.48 128.61,7.57 129.25,7.57 129.32,7.64 130.92,7.64
FB_1.8V on TOP (solid shape): 127.7,7.56 127.7,6.8 127.8,6.7 127.8,6.32 127.72,6.25 126.62,6.25 125.87,7 125.36,7 125.26,7.09 125.26,7.48 125.47,7.68 127.58,7.68
GT_SW1 on BOTTOM (solid shape): 266.18,131.08 266.18,130.27 266.12,130.21 264.87,130.21 264.68,130.03 264.68,125.59 264.57,125.48 261.45,125.48 259.94,126.98 259.94,128.41 260.14,128.6 261.23,128.6 261.28,128.66 261.28,129.37 261.25,129.39 259.98,129.39 259.94,129.43 259.94,130.83 260.35,131.23 266.03,131.23
INT_SPK_L+ on TOP (solid shape): 321.38,8.47 322.47,8.47 322.6,8.6 323.13,8.6 323.27,8.46 323.27,7.77 322.97,7.47 321.23,7.47 321.22,7.5 320.89,7.73 320.56,7.5 320.55,7.47 319.79,7.47 319.65,7.61 319.65,8.86 319.81,9.02 320.83,9.02
INT_SPK_L+ on IN2 (solid shape): 321.42,9.56 321.42,9.06 321.01,8.66 320.6,8.25 319.9,8.25 319.64,8.51 319.64,8.7 320.87,9.92 321.05,9.92
INT_SPK_L+ on IN2 (solid shape): 346.03,27.78 346.03,25.73 345.91,25.61 345.38,25.61 345.2,25.79 345.2,26.64 345.33,26.76 345.33,26.99 345.32,27 345.32,27.12 345.35,27.19 345.39,27.23 345.39,27.43 345.3,27.52 345.3,27.72 345.33,27.79 345.41,27.86 345.94,27.86
INT_SPK_L- on TOP (solid shape): 322.42,11.23 322.42,11.01 322.24,10.83 322.24,9.85 322.25,9.84 322.25,9.32 322.21,9.29 321.57,9.29 321.35,9.52 321.35,11.26 321.47,11.39 322.27,11.39
INT_SPK_L- on TOP (solid shape): 345.25,27.99 345.25,27.88 345.18,27.81 345.17,27.8 345.17,27.49 345.18,27.49 345.18,27.44 345.21,27.41 345.21,27.26 345.19,27.24 345.19,27.23 345.19,26.89 345.28,26.8 345.28,25.9 345.22,25.85 345.11,25.85 345.04,25.91 345.04,26.89 344.77,27.16 344.77,28.04 344.86,28.13 345.1,28.13
INT_SPK_L- on IN2 (solid shape): 323.59,11.23 323.59,10.67 323.32,10.4 321.52,10.4 321.33,10.59 321.33,11.28 321.49,11.44 323.38,11.44
INT_SPK_L- on IN2 (solid shape): 344.99,28.13 345.07,28.14 345.08,28.14 345.23,28 345.23,27.86 345.17,27.81 345.17,27.47 345.23,27.41 345.23,27.25 345.2,27.21 345.2,27.13 345.19,27.05 345.19,26.99 345.2,26.96 345.09,26.85 343.55,26.85 343.39,27.02 343.39,28.04 343.49,28.14 344.9,28.14
INT_SPK_R+ on TOP (solid shape): 344.06,29.58 344.06,27.62 344.07,27.61 344.07,27.59 344.22,27.45 344.22,27.04 344.22,27.03 344.49,26.77 344.49,25.87 344.43,25.81 344.3,25.81 344.23,25.88 344.23,26.72 343.39,27.57 343.39,29.5 343.61,29.72 343.92,29.72
INT_SPK_R+ on TOP (solid shape): 321.43,13.82 322.11,13.82 322.27,13.66 322.27,11.78 322.16,11.67 321.69,11.67 321.51,11.85 321.51,12.64 320.79,13.36 320.82,13.39 320.88,13.66 320.74,13.89 320.74,13.99 320.88,14.12 321.12,14.12
INT_SPK_R+ on IN2 (solid shape): 344.14,29.49 344.14,28.67 344,28.54 343.43,28.54 343.18,28.8 342.25,28.8 342.16,28.89 342.16,29.5 342.41,29.75 343.88,29.75
INT_SPK_R+ on IN2 (solid shape): 322.49,14.05 322.49,13.97 321.52,13 321.18,13 320.92,13.26 320.92,13.71 320.88,13.75 320.88,13.98 321.04,14.14 321.22,14.14 321.52,14.45 322.1,14.45
INT_SPK_R- on TOP (solid shape): 322.18,15.57 322.18,14.11 322.12,14.05 321.64,14.05 321.42,14.27 321.33,14.27 321.32,14.27 321.21,14.27 320.9,14.58 320.9,15.5 321.06,15.66 322.09,15.66
INT_SPK_R- on TOP (solid shape): 344.91,30.07 344.91,28.94 344.64,28.67 344.64,28.57 344.63,28.49 344.64,28.41 344.64,27.09 344.88,26.85 344.88,25.9 344.83,25.85 344.68,25.85 344.64,25.88 344.64,26.79 344.35,27.09 344.35,27.5 344.2,27.65 344.2,30.05 344.37,30.22 344.76,30.22
INT_SPK_R- on IN2 (solid shape): 322.16,15.87 322.16,15.31 321.3,14.46 320.94,14.46 320.81,14.59 320.81,15.51 321.41,16.11 321.91,16.11
INT_SPK_R- on IN2 (solid shape): 345,30.4 345,29.16 344.87,29.04 344.37,29.04 344.26,29.15 344.26,29.54 344.24,29.57 344.24,29.62 343.93,29.93 342.55,29.93 342.41,30.07 342.41,30.84 342.54,30.98 344.42,30.98
INT_SPKR_L+ on TOP (solid shape): 326,9.79 331.01,9.79 331.13,9.67 331.13,8.8 330.92,8.59 326.51,8.59 326.15,8.73 325.79,8.59 325.26,8.59 324.8,8.72 324.43,8.43 324.43,8.42 323.99,7.99 323.48,7.99 323.42,8.06 323.42,9.72 324.05,10.36 325.44,10.36
INT_SPKR_L- on TOP (solid shape): 328.75,11.3 328.75,10.97 328.97,10.76 331,10.76 331.13,10.63 331.13,10.07 330.98,9.92 328.18,9.92 327.54,10.56 327.54,11.05 327.13,11.46 327.13,11.56 327.14,11.66 327.13,11.76 327.13,11.86 326.96,12.03 325.82,12.03 324.47,10.68 324.35,10.56 323.97,10.56 323.57,10.15 322.64,10.15 322.57,10.23 322.57,10.89 324.73,13.05 327,13.05
INT_SPKR_R+ on TOP (solid shape): 325.25,14.06 327.64,14.06 329.52,12.18 330.76,12.18 331.07,11.88 331.07,11.44 330.96,11.32 330.92,11.17 330.92,11.15 330.86,11.1 329.51,11.1 329.51,11.15 329.29,11.47 328.91,11.4 328.88,11.37 327.13,13.12 327.12,13.12 327.06,13.18 324.67,13.18 324.61,13.12 322.6,13.12 322.55,13.16 322.55,13.76 322.67,13.88 323.62,13.88 324.05,14.3 325,14.3
INT_SPKR_R- on TOP (solid shape): 329.43,15.79 329.43,15.67 329.42,15.66 329.33,15.35 329.43,15.05 329.43,14.42 329.39,13.87 329.85,13.59 330.66,13.59 330.72,13.59 330.81,13.61 331.12,13.3 331.12,12.67 330.88,12.43 329.45,12.43 328.07,13.81 328.07,14.3 328.27,14.67 328.07,15.04 328.07,15.37 327.63,15.81 325.67,15.81 325,15.14 324.87,15.14 324.81,15.14 323.12,15.14 323.02,15.04 322.54,15.04 322.44,15.14 322.44,15.63 323.67,16.86 328.36,16.86
LG_1.2V on TOP (solid shape): 223.15,9.14 223.15,7.99 223,7.84 221.84,7.84 221.69,7.99 221.69,9.12 221.87,9.3 222.99,9.3
LG_1.2V on TOP (solid shape): 205.55,9.46 205.55,8.96 205.44,8.85 205.16,8.85 204.51,9.49 204.43,9.49 204.39,9.51 204.34,9.53 204.27,9.6 204.27,10.38 204.33,10.44 204.58,10.44
LG_1.2V on BOTTOM (solid shape): 222.55,8.66 222.55,6.92 222.3,6.67 221.65,6.67 221.27,7.05 221.27,8.82 221.5,9.05 222.16,9.05
LG_1.2V on BOTTOM (solid shape): 205.51,9.61 205.51,8.69 204.68,7.85 203.66,7.85 203.57,7.94 203.57,8.44 203.77,8.64 204.32,8.64 204.63,8.96 204.63,9.33 204.58,9.38 204.58,9.73 204.75,9.89 205.23,9.89
LG_+1VSP on TOP (solid shape): 152.24,14.56 152.24,13.51 152.13,13.4 151.42,13.4 151.21,13.61 151.21,14.42 151.46,14.66 152.14,14.66
LG_+1VSP on TOP (solid shape): 145.78,7.45 145.78,6.38 145.61,6.22 144.5,6.22 144.35,6.36 144.35,7.19 144.72,7.56 145.67,7.56
LG_+1VSP on BOTTOM (solid shape): 145.63,7.13 145.63,6.33 145.5,6.2 144.56,6.2 144.34,6.42 144.34,7.19 144.49,7.33 145.43,7.33
LG_+1VSP on BOTTOM (solid shape): 152.43,14.43 152.43,13.82 152.05,13.44 151.32,13.44 151.31,13.43 150.32,13.43 150.04,13.71 150.04,14.37 150.28,14.61 151.74,14.61 151.84,14.72 152.14,14.72
LGATE_CHG on TOP (solid shape): 302.13,18.38 302.13,17.7 301.97,17.54 300.52,17.54 300.29,17.77 300.29,18.54 300.46,18.7 301.8,18.7
LGATE_CHG on TOP (solid shape): 289.83,29.6 290.53,29.6 291.08,29.05 291.08,28.71 290.94,28.57 290.76,28.57 289.97,29.36 289.12,29.36 289.05,29.43 289.05,29.59 289.09,29.62 289.8,29.62
LGATE_CHG on IN3 (solid shape): 300.81,18.57 300.81,17.68 300.72,17.59 299.31,17.59 298.9,18.01 298.9,18.74 299.03,18.87 300.51,18.87
LGATE_CHG on IN3 (solid shape): 290.5,29.61 291.09,29.02 291.09,28.09 290.94,27.94 290.19,27.94 290.03,28.09 290,28.18 290.06,28.26 290.23,28.65 289.9,28.92 289.83,28.96 289.8,29.03 289.8,29.39 290.05,29.64 290.5,29.64
LP#_VCCIO on BOTTOM (solid shape): 270.47,99.64 271.76,99.64 271.85,99.54 271.85,99.39 271.78,99.32 270.43,99.32 270.24,99.13 269.7,99.13 269.7,99.72 269.71,99.74 270.37,99.74
LX_1.2V on TOP (solid shape): 230.16,11.18 230.16,8.74 231.13,7.78 231.13,4.22 228.28,1.38 216.55,1.38 216.19,1.73 216.19,3.99 216.6,4.4 218.97,4.4 219.7,3.67 219.7,2.6 219.98,2.32 221.32,2.32 221.52,2.52 221.52,4.25 222.11,4.84 222.11,7.12 222.24,7.24 227.01,7.24 228.81,9.03 228.81,11.32 228.91,11.42 229.92,11.42
LX_1.2V on TOP (solid shape): 205.84,10.52 205.84,10.37 205.97,10.23 205.98,10.22 206.04,10.13 206.13,10.07 206.15,10.06 206.22,10.05 206.27,10.05 206.31,10.06 206.78,9.58 206.78,9.46 206.95,9.29 207.64,9.29 207.69,9.24 207.69,8.34 207.56,8.2 206.5,8.2 206.14,8.56 206.14,9.2 204.68,10.66 204.68,10.79 204.74,10.85 205.51,10.85
LX_1.2V on BOTTOM (solid shape): 207.2,9.54 207.2,7.91 206.82,7.53 206.34,7.53 206.07,7.81 206.07,9.47 206.28,9.68 207.06,9.68
LX_1.2V on BOTTOM (solid shape): 217.83,4.38 217.83,3.58 217.65,3.41 215.95,3.41 215.79,3.56 215.79,4.46 215.93,4.61 217.6,4.61
LX_1.8V on TOP (solid shape): 132.32,7.78 132.32,3.08 132.14,2.89 130.29,2.89 130.16,3.02 130.16,4.99 129.93,5.22 129.17,5.22 129.09,5.31 129.09,5.49 129.18,5.59 130.31,5.59 130.76,6.04 130.76,6.55 131.29,7.08 131.29,7.9 131.3,7.9 132.2,7.9
LX_2.5V on TOP (solid shape): 289.12,49.83 289.12,48.09 288.84,47.82 285.18,47.82 284.99,47.62 284.99,46.87 284.93,46.8 284.79,46.8 284.71,46.88 284.71,47.82 284.17,48.36 284.17,49.84 284.28,49.96 288.99,49.96
LX_3V on TOP (solid shape): 109.44,9.05 109.44,7.17 109.67,6.94 110.42,6.94 110.47,6.99 110.51,6.99 110.56,7.04 111.34,7.04 111.7,6.68 113.55,6.68 113.6,6.63 114.42,6.63 114.52,6.53 114.52,6.35 114.47,6.3 113.63,6.3 113.53,6.41 111.5,6.41 111.47,6.38 111.44,6.38 111.32,6.25 111.32,6.23 111.24,6.15 111.24,4.09 110.99,3.84 109.87,3.84 109.62,3.59 109.62,2.03 109.14,1.55 107.43,1.55 107.05,1.93 107.05,9.07 107.15,9.17 109.31,9.17
LX_3VR on TOP (solid shape): 313.53,28.07 313.53,27.65 313.25,27.37 312.7,27.37 312.04,28.03 312.04,28.17 312.09,28.23 313.37,28.23
LX_3VR on TOP (solid shape): 306.67,34.4 306.67,33 307.77,31.9 307.77,28.99 308.08,28.68 309.77,28.68 309.85,28.6 309.85,28.04 309.64,27.83 309.64,26.63 309.85,26.42 309.85,25.58 309.77,25.5 305.06,25.5 304.3,26.26 304.3,34.36 304.53,34.6 306.47,34.6
LX_3VR on BOTTOM (solid shape): 313.58,28.07 313.58,27.47 312.76,26.64 308.54,26.64 308.42,26.76 308.42,27.77 308.57,27.91 312.37,27.91 312.69,28.23 313.42,28.23
LX_5V on TOP (solid shape): 72.74,22.28 72.74,20.37 72.99,20.13 72.99,15.04 72.63,14.69 68.64,14.69 67.59,15.73 67.59,19.95 68.17,20.53 70.77,20.53 71.1,20.86 71.1,22.1 71.32,22.32 72.7,22.32
LX_5V on BOTTOM (solid shape): 73.02,20.43 73.02,16.87 72.13,15.98 72.13,14.96 72.02,14.86 69.89,14.86 69.64,14.61 69.64,12.48 69.71,12.41 69.71,11.62 69.63,11.54 69.49,11.54 69.4,11.63 69.4,14.19 69.1,14.49 69.1,14.66 68.98,14.79 68.98,16.38 67.91,17.44 67.91,20.35 68.2,20.64 72.81,20.64
LX_5VR on TOP (solid shape): 312.29,37.97 312.29,37.72 311.83,37.27 311.36,37.27 310.74,37.88 310.74,38.04 310.81,38.11 312.15,38.11
LX_5VR on TOP (solid shape): 303.27,43.81 303.27,42.89 303.6,42.55 304.4,42.55 305.94,41.01 306.54,41.01 306.71,40.83 306.71,38.76 306.97,38.51 307.63,38.51 307.69,38.56 308.48,38.56 308.56,38.48 308.56,37.91 308.24,37.58 308.24,36.19 308.31,36.11 308.31,35.48 308.22,35.39 307.38,35.39 306.07,36.7 303.39,36.7 301.64,38.45 301.64,44.17 301.8,44.33 302.75,44.33
LX_5VR on BOTTOM (solid shape): 312.33,37.98 312.33,37.56 311.42,36.65 307.3,36.65 307.19,36.77 307.19,37.62 307.3,37.73 311.06,37.73 311.49,38.16 312.15,38.16
LX_+1VSP on TOP (solid shape): 151.24,12.73 152.09,12.73 152.19,12.63 152.19,12.46 152.1,12.37 151.32,12.37 151.32,12.37 151.13,12.37 150.44,11.68 149.63,11.68 149.59,11.71 149.59,12.61 149.67,12.69 150.35,12.69 150.62,12.97 151,12.97
LX_+1VSP on TOP (solid shape): 147.15,11.73 147.15,10.56 148,9.71 151.99,9.71 153.07,8.63 153.07,3.22 152.6,2.76 147.9,2.76 147.6,3.05 147.6,4.58 147.76,4.74 148.93,4.74 149.31,5.12 149.31,6.19 149.03,6.46 147.6,6.46 147.16,6.02 146.33,6.02 146.01,6.34 146.01,9.55 145.34,10.23 145.34,11.9 145.58,12.14 146.73,12.14
LX_+1VSP on BOTTOM (solid shape): 147.28,6.91 147.28,6.12 147.15,5.99 146.29,5.99 146.16,6.11 146.16,6.92 146.31,7.06 147.13,7.06
LX_+1VSP on BOTTOM (solid shape): 151.33,12.78 151.33,12.55 150.8,12.03 150.75,11.99 150.71,11.93 150.46,11.69 150.46,11.03 150.29,10.87 149.88,10.87 149.48,11.26 149.48,11.73 150.69,12.93 151.18,12.93
LX_CHG on TOP (solid shape): 291.86,32.28 292.15,31.99 292.15,31.16 292.08,31.09 291.41,31.09 291.13,31.38 290.46,31.38 290.03,30.95 289.1,30.95 289.04,31.01 289.04,31.21 289.09,31.26 289.96,31.26 290.21,31.52 290.21,32.18 290.36,32.33 291.81,32.33
LX_CHG on TOP (solid shape): 296.9,24.26 296.9,21.21 296.6,20.91 295.77,20.91 295.35,20.49 295.35,19.94 296.68,18.61 300.07,18.61 300.12,18.56 300.12,11.48 300.03,11.38 299.01,11.38 299.01,11.39 299.01,13.82 298.86,13.97 295.6,13.97 295.18,14.39 295.18,16.19 292.11,19.26 290.43,19.26 289.63,20.05 289.63,23.57 289.75,23.69 291.34,23.69 292.02,24.37 292.03,24.37 292.09,24.44 296.73,24.44
LX_CHG on IN3 (solid shape): 292.36,32.67 292.36,31.91 292.27,31.82 290.35,31.82 290.22,31.95 290.22,32.41 290.45,32.64 291.18,32.64 291.34,32.8 292.23,32.8
LX_CHG on IN3 (solid shape): 295.58,25.14 295.58,23.07 295.47,22.96 294.52,22.96 294.41,23.07 294.41,25.09 294.63,25.31 295.41,25.31
LX_IO on BOTTOM (solid shape): 275.39,104.6 277.98,104.6 278.24,104.35 278.24,102.72 278.03,102.52 277.48,102.52 277.22,102.25 277.22,101.6 277.03,101.41 273.36,101.41 273.08,101.13 273.08,98.57 273,98.49 272.89,98.49 272.81,98.57 272.81,101.12 272.52,101.41 271.86,101.41 271.28,102 271.28,104.39 271.77,104.88 275.11,104.88
MODE_IO on BOTTOM (solid shape): 271.54,100.75 272.4,100.75 272.58,100.58 272.58,99.36 272.52,99.29 272.25,99.29 272.19,99.36 272.19,99.8 272.07,99.92 269.79,99.92 269.68,100.02 269.68,100.68 269.83,100.83 270.69,100.83 270.9,101.04 271.25,101.04
Net_541 on TOP (solid shape): 252.8,16.1 244.8,16.1 244.8,24.1 252.8,24.1
Net_986 on BOTTOM (solid shape): outline of 196 points within 172,129.1 176.5,133.6
Net_987 on BOTTOM (solid shape): outline of 198 points within 171.98,113.38 176.52,117.92
Net_988 on BOTTOM (solid shape): outline of 196 points within 172,97.7 176.5,102.2
Net_989 on BOTTOM (solid shape): outline of 196 points within 172,82 176.5,86.5
REG_OUT on BOTTOM (solid shape): 31.1,18.86 31.1,16.64 31.05,16.58 29.98,16.58 29.81,16.75 29.81,18.1 29.33,18.58 26.69,18.58 26.69,18.58 26.18,18.58 25.87,18.26 25.87,16.98 25.79,16.91 24.84,16.91 24.83,16.92 24.76,16.92 24.69,16.98 24.69,18.83 25.4,19.54 27.75,19.54 30.43,19.54
RING2 on TOP (solid shape): 352.52,18.34 352.52,17.68 352.39,17.56 352.03,17.56 351.75,17.28 351.45,17.28 351.33,17.4 351.33,18.03 351.36,18.16 351.33,18.29 351.33,18.3 351.33,18.35 351.42,18.44 352.41,18.44
RING2 on BOTTOM (solid shape): 351.98,18.27 351.98,16.18 351.98,16.13 351.98,16.09 351.98,15.87 351.96,15.85 351.35,15.85 351.32,15.89 351.32,18.24 351.45,18.37 351.88,18.37
RING2 on IN1 (solid shape): 352.82,18.11 352.82,17.48 352.62,17.28 351.45,17.28 351.32,17.4 351.32,18.29 351.4,18.37 352.57,18.37
RING2 on IN1 (solid shape): 352.85,22.1 352.85,21.26 352.69,21.11 351.86,21.11 351.81,21.16 351.81,21.59 351.8,21.62 351.8,22.15 351.91,22.25 352.69,22.25
RING2_R on TOP (solid shape): 355.18,18.55 355.5,18.55 355.72,18.77 355.72,18.77 355.85,18.9 358.08,18.9 358.45,18.52 358.45,16.62 358.18,16.35 358.18,15.84 358.12,15.78 356.05,15.78 355.88,15.95 355.88,16.72 357.15,16.72 357.15,16.67 357.17,16.61 357.19,16.56 357.21,16.52 357.25,16.48 357.28,16.44 357.33,16.41 357.38,16.39 357.43,16.37 357.48,16.36 357.53,16.36 357.59,16.37 357.64,16.39 357.69,16.41 357.73,16.44 357.77,16.48 357.8,16.52 357.83,16.56 357.85,16.61 357.86,16.67 357.86,16.72 357.86,16.77 357.85,16.82 357.83,16.87 357.8,16.92 357.77,16.96 357.73,17 357.69,17.03 357.64,17.05 357.59,17.07 357.53,17.07 357.48,17.07 357.43,17.07 357.38,17.05 357.33,17.03 357.28,17 357.25,16.96 357.21,16.92 357.19,16.87 357.17,16.82 357.15,16.77 357.15,16.72 355.88,16.72 355.88,17.22 355.39,17.71 354,17.71 353.94,17.77 353.4,17.77 353.33,17.69 352.85,17.69 352.78,17.76 352.78,18.62 352.95,18.79 353.87,18.79 353.99,18.9 354.83,18.9
RING2_R on IN2 (solid shape): 359.7,19.3 359.7,18.56 359.5,18.37 357.19,18.37 357.08,18.48 357.08,19.22 357.1,19.25 357.3,19.34 357.4,19.54 357.41,19.55 357.51,19.66 359.34,19.66
SA_SW on TOP (solid shape): 219.5,129.12 219.5,128.82 219.72,128.59 221.55,128.59 222.06,128.08 222.06,123.45 221.14,122.52 218.01,122.52 218.01,123.54 218.89,123.54 218.89,124.3 218.01,124.3 218.01,124.35 216.45,125.91 214.2,125.91 213.86,126.25 213.86,127.82 213.88,127.84 217.67,127.84 217.9,128.07 217.9,129.32 217.92,129.34 219.27,129.34
SA_SW on BOTTOM (solid shape): 219.6,128.68 219.6,127.74 219.45,127.59 218.07,127.59 217.85,127.82 217.85,128.58 218.07,128.81 219.47,128.81
SDVDD1 on TOP (solid shape): 30.39,25.06 30.39,24.86 30.18,24.86 29.61,24.29 30.41,24.34 30.43,24.34 30.8,23.97 31.61,23.97 33.68,21.91 34.52,21.91 34.78,21.65 34.78,20.48 34.5,20.2 34.5,20.18 34.43,20.11 34.43,19.37 34.39,19.33 33.89,19.33 33.86,19.36 33.86,20.09 33.68,20.27 33.68,20.27 33.02,20.93 31.47,20.93 30.84,21.55 30.84,21.57 30.74,21.74 30.57,21.84 30.55,21.84 30.47,21.92 30.13,21.92 28.95,23.11 28.95,24.6 29.69,25.35 30.09,25.35
SDVDD1 on IN3 (solid shape): outline of 450 points within 16.78,13.96 30.26,25.55
SDVDD2 on TOP (solid shape): outline of 215 points within 10.27,15.14 17.32,23.12
SDVDD2 on BOTTOM (solid shape): 11.95,21.63 11.95,19.74 11.7,19.49 10.56,19.49 10.46,19.59 10.46,21.15 10.4,21.21 10.4,21.76 10.5,21.86 11.73,21.86
SLEEVE on TOP (solid shape): 351.14,17.65 351.14,17.38 351.4,17.12 351.86,17.12 352.03,17.3 352.44,17.3 352.51,17.23 352.51,16.71 352.41,16.62 350.78,16.62 350.55,16.85 350.55,17.71 350.72,17.89 350.9,17.89
SLEEVE on BOTTOM (solid shape): 351.12,18.27 351.12,15.93 351.07,15.88 350.47,15.88 350.46,15.89 350.46,18.25 350.59,18.38 351.01,18.38
SLEEVE on IN1 (solid shape): 351.14,18.62 351.14,16.84 351.02,16.72 350.03,16.72 349.75,17 349.75,18.44 350.03,18.72 351.04,18.72
SLEEVE on IN1 (solid shape): 351.91,22.71 351.91,22.53 351.68,22.31 351.68,22.19 351.67,22.17 351.63,22 351.67,21.83 351.68,21.82 351.68,21.37 351.53,21.21 350.92,21.21 350.7,21.43 350.7,22.67 350.89,22.86 351.75,22.86
SLEEVE_R on TOP (solid shape): 353.79,17.55 354.79,17.55 355.06,17.28 355.06,16.01 354.87,15.81 352.8,15.81 352.76,15.86 352.76,17.19 353.05,17.47 353.39,17.47 353.49,17.57 353.76,17.57
SLEEVE_R on IN2 (solid shape): 354.91,17.31 354.91,16.15 354.83,16.07 353.71,16.07 353.43,16.34 353.43,17.5 353.62,17.68 354.53,17.68
SNUB_1.2V on TOP (solid shape): 233.6,10.85 233.6,9.63 233.5,9.53 231.51,9.53 231.41,9.63 231.41,11.36 231.46,11.41 233.03,11.41
SNUB_1V on TOP (solid shape): 144.1,12.11 144.1,10.44 143.97,10.32 142.83,10.32 142.74,10.42 142.08,10.42 141.95,10.55 141.95,11.2 142.09,11.35 142.5,11.35 142.77,11.62 142.77,11.94 143,12.17 144.03,12.17
SNUB_3V on TOP (solid shape): 106.1,3.37 106.1,1.74 105.89,1.53 104.35,1.53 103.68,2.21 103.68,3.35 103.82,3.49 105.98,3.49
SNUB_CHG on TOP (solid shape): 303.54,12.55 303.54,11.99 303.27,11.72 303.11,11.63 303.02,11.47 302.85,11.29 301.69,11.29 301.68,11.31 301.68,13.03 303.06,13.03
SNUB_IO on BOTTOM (solid shape): 278.19,107.01 278.19,105.38 277.99,105.19 276.3,105.19 276.24,105.24 276.24,107.21 276.45,107.42 277.78,107.42
UG_1.2V on TOP (solid shape): 221.23,4.09 221.23,2.74 220.95,2.46 220.33,2.46 219.98,2.8 219.98,4.13 220.12,4.26 221.06,4.26
UG_1.2V on TOP (solid shape): 205.87,11.05 206.8,11.05 206.93,10.92 206.93,10.69 206.42,10.19 206.2,10.19 205.96,10.42 205.96,10.58 205.56,10.98 204.73,10.98 204.67,11.04 204.67,11.19 204.73,11.24 205.68,11.24
UG_1.2V on BOTTOM (solid shape): 208.13,10.95 208.13,10.31 207.96,10.15 205.94,10.15 205.75,10.34 205.75,10.93 205.93,11.11 207.97,11.11
UG_1.2V on BOTTOM (solid shape): 221.29,4.79 221.29,3.78 220.93,3.43 219.99,3.43 219.23,4.19 219.23,4.84 219.66,5.28 220.8,5.28
UG_+1VSP on TOP (solid shape): 148.92,6.15 148.92,5.24 148.58,4.9 147.82,4.9 147.65,5.07 147.65,6.05 147.84,6.24 148.84,6.24
UG_+1VSP on TOP (solid shape): 152.21,12.11 152.21,11.98 152.1,11.87 151.43,11.87 151.21,11.65 151.21,11.02 151.07,10.88 150.72,10.88 150.58,11.02 150.58,11.63 150.85,11.91 150.9,11.95 150.94,12 151.15,12.2 152.11,12.2
UG_+1VSP on BOTTOM (solid shape): 152.03,11.82 152.03,10.82 151.86,10.64 151.01,10.64 150.63,11.02 150.63,11.68 150.91,11.96 151.89,11.96
UG_+1VSP on BOTTOM (solid shape): 149.29,7.01 149.29,6.01 149.02,5.74 147.96,5.74 147.83,5.87 147.83,6.08 147.84,6.13 148.34,6.63 148.34,6.99 148.41,7.07 149.24,7.07
UGATE_CHG on TOP (solid shape): 297.5,20.73 297.5,20.51 297.5,20.51 297.5,19.85 297.38,19.73 295.92,19.73 295.6,20.05 295.6,20.44 295.8,20.63 296.75,20.63 296.95,20.83 297.4,20.83
UGATE_CHG on TOP (solid shape): 291.09,31.14 291.09,31.08 291.1,31.08 291.1,30.89 290.78,30.58 290.53,30.58 290.44,30.49 290.03,30.49 289.96,30.57 289.11,30.57 289.07,30.62 289.07,30.78 289.1,30.82 290.09,30.82 290.5,31.23 291,31.23
UGATE_CHG on IN3 (solid shape): 297.41,20.72 297.41,19.74 297.28,19.61 295.66,19.61 295.4,19.87 295.4,20.45 295.8,20.85 297.28,20.85
UGATE_CHG on IN3 (solid shape): 292.84,29.61 292.84,29.21 292.61,28.98 292.19,28.98 291.11,30.06 291.1,30.06 290.71,30.45 290.22,30.45 290.03,30.64 290.03,31.01 290.25,31.23 291.23,31.23
N20816750 on BOTTOM (solid shape): 269.73,127.99 270.03,127.99 270.39,127.63 271.12,127.63 271.2,127.55 271.2,126.72 271.16,126.67 270.41,126.67 269.88,127.2 269.83,127.2 269.74,127.29 269.74,127.53 269.53,127.74 268.97,127.74 268.87,127.84 268.87,128.01 268.94,128.09 269.63,128.09
N20816752 on BOTTOM (solid shape): 270.46,126.44 271.15,126.44 271.23,126.36 271.23,125.52 271.13,125.43 270.13,125.43 269.86,125.7 269.86,126.41 269.53,126.74 268.94,126.74 268.87,126.82 268.87,126.97 268.97,127.07 269.83,127.07
N20816771 on BOTTOM (solid shape): 272.71,127.55 272.71,125.51 272.62,125.42 271.88,125.42 271.75,125.54 271.75,127.56 271.85,127.66 272.6,127.66
N20816775 on BOTTOM (solid shape): 270.51,128.97 272.47,128.97 272.64,128.8 272.64,128.07 272.48,127.91 270.37,127.91 270.3,127.98 270.3,128.3 270.3,128.36 270.3,128.43 270.3,128.57 270.15,128.73 268.97,128.73 268.84,128.85 268.84,128.98 268.94,129.08 270.4,129.08
N20816800 on BOTTOM (solid shape): 264.19,124.28 264.19,122.93 264.13,122.87 262.46,122.87 262.42,122.91 262.42,124.87 262.55,125 263.47,125
N20816832 on BOTTOM (solid shape): 217.04,134.39 217.04,133.32 217.03,133.31 217,133.16 217.03,133 217.04,132.99 217.04,131.93 216.88,131.77 216.3,131.77 216.19,131.89 216.19,132.81 216.36,133.11 216.19,133.42 216.19,134.41 216.24,134.46 216.97,134.46
N20816888 on BOTTOM (solid shape): 217.57,127.72 217.57,127.54 217.82,127.28 218.91,127.28 219.09,127.11 219.09,126.32 218.81,126.04 216.24,126.04 216.17,126.12 216.17,127.87 216.22,127.92 217.36,127.92
