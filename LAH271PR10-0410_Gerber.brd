# Allegro board LAH271PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
WWAN_RADIO_DIS#: length 204.7
  TOP w0.102: UE1.F12 v2(139.13,25.65)
  TOP w0.109: v1(208.04,6.23) 208.04,6.03 v2(208.32,5.75)
  IN2 w0.081: v2(282.84,5.49) 282.36,5.96 277.8,5.96 273.6,10.16 271.15,10.16 270.17,11.14 269.81,11.14 267.78,13.16 267.78,13.87 265.34,16.31 251.62,16.31 250.2,14.89 240.94,14.89 240.35,15.49 220.54,15.49 219.29,14.24 212.9,14.24 209.73,11.07 209.73,7.16 v2(208.32,5.75)
  IN4 w0.102: v2(139.13,25.65) 139.01,25.65 138.63,26.04 131.71,26.04 131.54,25.87 131.54,25.45 131.34,25.25 128.61,25.25 128.09,24.72 128.09,23.15 127.46,22.52 127.46,20.66 128.25,19.87 128.25,19.04 128.87,18.43 129.79,18.43 130.87,17.36 130.88,17.36 130.9,17.34 130.97,17.34 131.59,16.71 131.59,15.91 130.52,14.84 130.52,14.36 130.73,14.15 131.47,14.15 132.15,14.83 134.67,14.83 135.61,15.76 137.96,15.76 139.07,14.65 140.68,14.65 141.39,13.94 142.17,13.94 142.44,13.67 144.2,13.67 147.77,17.24 152.36,17.24 154.22,15.37 155.59,15.37 157.09,13.87 158.32,13.87 159.51,12.69 159.81,12.69 162.21,10.29 165.88,10.29 166.98,9.2 173.91,9.2 174.98,8.13 175.71,8.13 177.67,6.17 180.38,6.17 180.79,5.75 186.57,5.75 186.98,5.34 191.94,5.34 192.44,5.84 193.83,5.84 194.79,4.88 205.89,4.88 206.07,4.7 207.28,4.7 v2(208.32,5.75)
  BOTTOM w0.102: RE10.1 140.92,25.94 139.43,25.94 v2(139.13,25.65)
  BOTTOM w0.109: v2(282.84,5.49) 283.25,5.89 283.25,7.21 DZ5.1
WWAN_RADIO_DIS#_R: length 19.2
  BOTTOM w0.109: DZ5.2 282.78,8.44 282.78,6.58 v1(282.54,6.33) 282.43,6.23 282.43,5.28 282.68,5.04 283.9,5.04 285.7,6.84 285.98,6.84 286.32,7.18 286.32,7.6 285.59,8.34 285.59,9.84 285.98,10.24 288.13,10.24 289.07,11.17 290.81,11.17 291.25,10.72 JNGFF2.8
WWAN_WAKE#: length 183.1
  TOP w0.109: v1(149.58,16.2) v2(148.57,15.19) 148.13,15.63 146.45,15.63 146.02,15.2 144.27,15.2 143.68,15.78 143.68,16.37 142.53,17.52 142.18,17.52 141.93,17.77 141.68,17.77 141.4,18.06 141.4,18.44 RE38.1 141.84,19.07 140.46,20.45 UE1.M13
  IN1 w0.102: v2(292.67,2.8) 291.62,1.75 286.19,1.75 285.16,2.78 281.97,2.78 280.94,1.76 274.25,1.76 273.66,2.35 261.45,2.35 257.13,6.66 256.08,6.66 254.98,7.75 254.98,10.55 255.67,11.23 255.67,12.87 254,14.53 248.34,14.53 247.97,14.17 243.74,14.17 243.09,14.82 231.18,14.82 230.67,15.32 219.28,15.32 218.08,14.13 211.32,14.13 210.63,14.82 200.81,14.82 199.17,13.17 199.17,11.53 198.44,10.8 196.64,10.8 196.18,10.34 189.87,10.34 186.73,7.21 179.36,7.21 178.39,8.18 177.13,8.18 175.48,9.83 173.17,9.83 172.18,10.81 168.21,10.81 166.48,12.54 164.25,12.54 163.63,11.92 162.41,11.92 160.67,13.66 159.37,13.66 159.15,13.88 157.24,13.88 156.81,14.31 156.47,14.31 155.11,15.67 154.13,15.67 153.93,15.87 150.3,15.87 150.03,15.61 148.98,15.61 v2(148.57,15.19)
  BOTTOM w0.109: v2(292.67,2.8) 292.67,3.03 293.38,3.73 294.71,3.73 295,3.45 JNGFF2.15
XCLK_RBIAS: length 24.6
  TOP w0.089: v2(188.97,44.72) 188.61,44.37 188.61,43.78 189.26,43.14
  TOP w0.102: 189.26,43.14 189.26,42.59 189.05,42.38 UH1.T3
  TOP w0.109: v2(195.57,53.89) 196.56,52.9 v1(196.6,52.9) 196.68,52.82 RH435.2 197.56,52.81 RH171.2
  IN2 w0.081: v2(188.97,44.72) 188.97,45.3 187.75,46.51 187.75,53.81 188.51,54.57 195.27,54.57 195.57,54.27 v2(195.57,53.89)
XDP_DBRESET#: length 158.3
  TOP w0.102: UC3.1 170.76,50.52 171.19,50.08 171.19,48.66 RH66.2
  TOP w0.109: v2(267.17,92.52) 266.95,92.52 266.56,92.14 266.56,83.97 258.46,75.87 215.94,75.87 206.69,85.13 200.51,85.13 200.28,85.36 200.28,85.61 199.88,86.01 v1(199.24,86.01) 198.56,86.01 194.23,81.68 191.33,78.78 189.44,78.78 188.11,77.45 188.11,73.55 187.82,73.27 187.82,68.74 184.71,65.63 182.81,65.63 177.56,60.38 177.56,58.77 169.66,50.86 169.66,50.64 169.78,50.52 UC3.1 ; RC137.1 277.48,94.4 CC32.1 278.67,93.22 279.53,93.22 279.9,93.59 v2(280.5,93.59) 281.07,93.59 281.31,93.35 JXDP1.48
  IN2 w0.081: v2(270.23,94.53) 270.45,94.75 276.88,94.75 278.05,93.59 v2(280.5,93.59)
  BOTTOM w0.109: v2(267.17,92.52) 268.22,92.52 v2(270.23,94.53)
XDP_OBS0: length 5.7
  TOP w0.076: RC239.1 261.9,106.61 261.9,107.28 261.34,107.84 260.76,107.84 259.23,106.31 258.84,106.31 UC1.BR27
XDP_OBS0_R: length 35.2
  TOP w0.109: v2(263.87,106.07) 263.76,106.18 RC239.2 ; JXDP1.21 283.75,85.25 v2(283.04,85.96)
  IN1 w0.102: v2(263.87,106.07) 264.08,106.07 264.89,105.26 265.79,105.26 266.87,104.18 267.48,104.18 267.91,103.75 267.91,100.79 268.4,100.3 268.4,99.69 267.98,99.27 267.98,98.69 267.98,98.35 269.61,96.73 274.09,96.73 276.14,94.68 277.33,94.68 281.82,90.19 281.82,87.74 282.28,87.28 282.28,86.72 v2(283.04,85.96)
XDP_OBS1: length 4.1
  TOP w0.076: UC1.BT27 260.54,108.02 261.39,108.02 262.33,107.08 RC240.1
XDP_OBS1_R: length 37.2
  TOP w0.109: RC240.2 263.44,107.07 v2(263.84,106.67) ; v2(283.78,85.83) 283.79,85.85 JXDP1.23
  IN1 w0.102: v2(283.78,85.83) 284.53,86.58 284.53,88.82 281.22,92.12 280.48,92.12 277.41,95.19 276.2,95.19 274.26,97.13 269.78,97.13 268.39,98.52 268.39,99.1 268.81,99.52 268.81,100.46 268.33,100.95 268.33,103.94 267.68,104.59 267.03,104.59 265.85,105.77 265.01,105.77 264.11,106.67 v2(263.84,106.67)
  BOTTOM w0.109: v1(284.08,85.13) 283.78,85.43 v2(283.78,85.83)
XDP_PRSNT_PIN1: length 6
  TOP w0.109: v1(287.31,75.56) 287.24,75.63 RC122.1 RC121.1 286.04,76.86 285.57,77.34 285.57,78.95 285.27,79.25 JXDP1.1
XTAL24_IN_R: length 5.1
  TOP w0.109: RH436.2 191.98,48.42 RH153.1 191.52,49.52 191.5,49.52 CH13.1 190.75,50.27 190.75,51.86 YH2.3
XTAL24_IN_R1: length 14.2
  TOP w0.102: UH1.U10 v2(188.76,38.58)
  TOP w0.109: RH436.1 191.15,48.18 v2(190.61,48.18)
  BOTTOM w0.109: v2(188.76,38.58) 188.76,38.7 188.47,38.98 188.47,41.17 189.39,42.08 189.39,44.28 189.38,44.28 189.38,45.03 189.7,45.34 189.7,45.54 189.53,45.72 189.22,45.72 189.02,45.91 189.02,46.16 189.19,46.33 189.53,46.33 189.71,46.51 v1(189.71,46.64) 189.71,46.86 189.53,47.04 189.18,47.04 189,47.22 189,47.47 189.18,47.65 190.08,47.65 v2(190.61,48.18)
XTAL24_OUT: length 4.5
  TOP w0.109: YH2.1 190.04,49.7 CH14.1 190.55,49.58 RH153.2 190.59,48.59 190.13,48.59 RH152.2
XTAL24_OUT_R1: length 13.9
  TOP w0.102: UH1.U9 v2(188.99,39.31)
  TOP w0.109: RH152.1 v2(189.33,48.15)
  BOTTOM w0.109: v2(189.33,48.15) 189.98,48.8 190.91,48.8 191.3,48.41 v1(191.3,48.18) 191.3,47.81 190.36,46.87 190.36,45.13 190,44.77 190,42.24 188.76,40.99 188.76,39.69 188.99,39.46 v2(188.99,39.31)
XTAL_25_IN: length 6.3
  BOTTOM w0.089: UT1.D22 27.53,33.78 27.53,33.33
  BOTTOM w0.109: RT394.1 24.36,30.17 24.8,30.61 24.8,31.7 25.98,32.88 27.25,32.88 27.53,33.16 27.53,33.33
XTAL_25_OUT: length 8.3
  BOTTOM w0.109: RT40.1 21.3,30.48 21.45,30.64 24.28,30.64 24.57,30.92 24.57,31.8 25.88,33.11 27.16,33.11 27.3,33.26 UT1.D23
XTAL_25_OUT_R: length 2.7
  BOTTOM w0.109: YT1.3 22.21,28.02 CT20.1 RT40.2
XTALI: length 5.9
  BOTTOM w0.109: Y1.1 183.41,131.24 CL14.1 184.11,130.78 185.23,130.78 185.41,130.6 185.41,129.37 185.84,128.94 UL1.10
XTALO: length 2.4
  BOTTOM w0.109: RL34.2 184.88,129.26 185.6,128.54 UL1.9
XTALO_R: length 4.6
  BOTTOM w0.109: RL34.1 184.7,130.36 184.14,129.8 CL13.1 183.86,129.93 183.47,129.93 183.35,130.05 182.02,130.05 Y1.3
Z2805: length 7.9
  TOP w0.508: TL1.22 182.17,152.2 181.69,152.68 177.63,152.68 v1(177.19,152.24) 176.53,151.57 RL18.1
Z2806: length 19.7
  TOP w0.109: v1(174.32,153.15) 174.32,152.81 v2(174.67,152.46)
  TOP w0.508: TL1.16 v2(189.79,152.63) ; RL17.1 v2(174.67,152.46)
  IN2 w0.508: v2(189.79,152.63) 184.66,152.63 183.54,151.51 175.62,151.51 v2(174.67,152.46)
Z2807: length 11.6
  TOP w0.109: v1(176,153.14) 176,152.88 v2(175.61,152.49)
  TOP w0.508: RL16.1 v2(175.61,152.49) ; TL1.21 v2(183.44,152.57)
  IN2 w0.508: v2(175.61,152.49) 183.36,152.49 v2(183.44,152.57)
Z2808: length 22.8
  TOP w0.109: v1(172.77,152.68) 173.03,152.42 v2(173.63,152.42)
  TOP w0.508: RL15.1 v2(173.63,152.42) ; TL1.15 v2(191.06,152.63)
  IN2 w0.508: v2(191.06,152.63) 189.1,150.68 175.37,150.68 v2(173.63,152.42)
Z4012: length 215
  TOP w0.109: v2(152.52,20.85) 152.9,21.23 152.9,22.67 151.71,23.85 PR64.1 150.7,23.79 PQ26.2
  IN2 w0.081: v2(234.89,9.15) 236.77,9.15 237.18,8.73 250.9,8.73 252.76,6.88 264.66,6.88 265.16,6.37 265.16,5.26 266.43,3.99 271.33,3.99 274.02,1.3 313.48,1.3 313.63,1.15 326.34,1.15 330.74,5.55 333.96,5.55 334.66,4.86 336.31,4.86 338.11,6.66 338.11,7.38 v2(338.36,7.62)
  IN4 w0.102: v2(152.52,20.85) 153.49,20.85 156.04,18.29 157.62,18.29 158.07,17.85 160.36,17.85 161.26,16.94 162.42,16.94 163,16.36 163.73,16.36 164.24,15.85 165.07,15.85 166.36,14.56 170.43,14.56 170.7,14.29 172.37,14.29 174.05,12.6 175.41,12.6 178.38,9.63 179.95,9.63 181.14,8.44 187.24,8.44 187.9,9.11 195.76,9.11 196.74,8.13 200.38,8.13 201.65,6.87 203.55,6.87 204.86,5.55 207.41,5.55 208.04,6.19 209.02,6.19 209.53,6.69 209.53,7.73 210.89,9.09 219.39,9.09 221.21,10.91 228.22,10.91 228.95,10.18 234.5,10.18 234.89,9.8 v2(234.89,9.15)
  BOTTOM w0.109: v1(339.71,10.74) 339.71,10.31 PD8.2
  BOTTOM w0.254: v2(338.36,7.62) 338.36,8.13 338.7,8.48 338.7,9.44 PR61.2 339.03,9.97 PD8.2
Z4304: length 11.8
  TOP w0.109: v3(259,5.99) 259.86,5.13 262.64,5.13 v2(263.51,6) 263.51,6.87 PR65.1
  BOTTOM w0.109: v2(263.51,6) 263.51,9.12 264.7,10.31 PBATT1.4
Z4305: length 6.4
  TOP w0.109: v2(262.46,5.99) PR66.1
  BOTTOM w0.109: PBATT1.5 263.2,9.7 262.6,9.1 262.6,6.12 v2(262.46,5.99)
Z4306: length 10.6
  TOP w0.109: PR67.1 261.59,6.64 261.88,6.35 v2(261.88,6) 260.85,6 260.07,6.77 258.79,6.77 v3(258.14,7.42)
  BOTTOM w0.109: PBATT1.6 261.7,6.52 261.88,6.34 v2(261.88,6)
N17828613: length 18.6
  TOP w0.254: PQ17.4 40.6,23.3 41.33,24.03 v3(41.77,24.03) 42.02,24.03 42.67,23.39 44.75,23.39 45.2,22.93 46.41,22.93 46.89,22.45 48,22.45 48.16,22.28 49.2,22.28 49.89,22.97 50.13,22.97 PQ19.1
  TOP w0.305: PQ19.1 51.7,24.02 52.57,23.16 PR33.1 53.66,22.36 PC11.2 54.17,22.18 54.46,22.47 54.66,22.47 PR28.2
N17829900: length 4.7
  TOP w0.109: PQ19.2 49.84,21.82 49.7,21.96 48.77,21.96 v1(48.64,21.84) 48.64,21.58 49.01,21.21 49.01,20.29 PR25.2 49.32,19.98 49.3,19.97 PR31.1
N17880182: length 22.7
  TOP w0.254: PR34.1 58.7,19.8 58.17,19.27 56.12,19.27 55.78,19.61 54.87,19.61 54.57,19.32 PC12.2 PR29.2 52.01,18.7 v1(51.6,18.7) 51.11,18.7 50.51,19.3 49.15,19.3 47.69,17.84 PQ20.1 47.37,17.25 47.37,15.75 v2(47.37,15.74)
  TOP w0.508: PQ18.4 v2(44.45,10.84)
  IN1 w0.254: v2(44.45,10.84) 44.45,12.83 47.36,15.74 v2(47.37,15.74)
N17880186: length 3.8
  TOP w0.109: PR32.1 52.65,16.63 PR26.2 52.52,16.77 v1(51.61,16.77) 51.09,16.77 50.94,16.62 PQ20.2
N17880313: length 1.4
  TOP w0.109: PR32.2 54.25,16.84 PQ5.3
N17883210: length 5.3
  TOP w0.109: PQ6.3 57.37,24.12 57.13,23.88 57.13,22.56 PR34.2 59.16,20.98 59.21,20.93 v1(59.68,20.93)
N17883346: length 4.3
  TOP w0.109: v1(57.53,16.12) 57.74,16.32 57.74,16.78 57.99,17.04 57.99,17.81 PR71.2 57.36,18.14 PQ5.6 PQ5.5
N17883375: length 4.8
  TOP w0.109: v1(54.94,23.83) 55.3,23.47 PQ6.5 56.48,23.47 56.75,23.21 56.75,22.33 57.83,21.25 PR38.1
N20816750: length 1.5
  TOP w0.109: v2(269.94,127.72) 269.53,128.12 v1(268.65,128.12)
N20816752: length 1.2
  TOP w0.109: v2(269.89,126.66) v1(268.66,126.66)
N20816771: length 1.3
  BOTTOM w0.109: v1(273.41,125.71) 273.16,125.95 PC1706.1
N20816775: length 3
  BOTTOM w0.109: v1(272.79,131.04) 272.79,129.06 PC1707.2
N20816793: length 3
  TOP w0.109: v2(257.1,129.01) v1(257.1,128.17)
  TOP w0.254: v2(257.1,129.01) 257.62,129.52 PR1703.1
  BOTTOM w0.254: PL1700.3 v2(257.1,129.01)
N20816800: length 0.6
  BOTTOM w0.109: v1(264.2,124.82) 263.98,124.6 263.72,124.6
N20816821: length 1.5
  TOP w0.109: v2(214.26,133.09) 214.11,133.09 v1(213.62,133.58)
  BOTTOM w0.508: PC1806.2 v2(214.26,133.09)
N20816822: length 1.4
  TOP w0.109: v1(215.01,133.58) 215.3,133.3 v2(215.3,133.07)
  BOTTOM w0.508: PR1800.1 215.3,132.58 v2(215.3,133.07)
N20816832: length 0.6
  TOP w0.109: v2(216.63,133.15) v1(216.63,133.78)
N20816859: length 2.5
  BOTTOM w0.109: v1(213.01,133.8) PC1806.1
  BOTTOM w0.508: PC1806.1 214.27,133.8 PR1800.2
N20816888: length 2.3
  BOTTOM w0.109: PC1809.2 220.36,126.83 v1(220.59,126.6)
N20820556: length 2.5
  TOP w0.254: PL1202.3 v2(249.14,127.25)
  BOTTOM w0.109: v2(249.14,127.25) v1(248.47,127.25)
  BOTTOM w0.254: v2(249.14,127.25) 249.36,127.48 PR1203.1
N20820665: length 4.5
  TOP w0.254: PL1203.3 241.39,126.98 241.9,127.49 243.03,127.49 v2(243.15,127.37)
  BOTTOM w0.109: PR1207.1 243.89,127.74 v1(244.48,128.33)
  BOTTOM w0.254: v2(243.15,127.37) 243.2,127.33 PR1207.1
N23832668: length 23.2
  IN1 w0.254: v2(50.91,16.07) 50.74,15.9 48.56,15.9 48.24,16.23 46.56,16.23 41.08,10.75 v2(40.64,10.75)
  BOTTOM w0.109: v2(40.64,10.75) 39.36,10.75 v1(39.26,10.65)
  BOTTOM w0.254: v2(50.91,16.07) 50.91,16.23 51.36,16.68 PC19.2 PR47.2 52.89,16.11 PQ25.1 57.84,16.11 PR52.1
  BOTTOM w0.508: v2(40.64,10.75) PQ23.4
N23832751: length 6.9
  BOTTOM w0.109: PR44.2 49.74,16.76 v1(49.33,16.35)
  BOTTOM w0.254: PR44.2 50.42,16.72 50.42,15.64 51.25,14.81 51.73,14.81 PR50.1 52.99,14.24 PQ25.2
N23832775: length 2.6
  BOTTOM w0.109: v1(51.07,12.58) 51.65,12.58 PQ8.3 52,13.63 PR50.2
N23832788:
  vias: v1(46.47,23.64)
N23832850: length 4.4
  BOTTOM w0.109: v1(50.78,20.25) 50.78,20.98 PR48.1 50.26,21.48 49.46,21.48 PR43.2 49.44,22.02 PQ24.2
N23833318: length 8
  BOTTOM w0.109: PR52.2 57.86,17.82 58.03,17.99 v1(58.03,18.33) 58.03,19.08 57.47,19.64 57.47,21.13 56.26,22.34 55.4,23.2 PQ9.3
N23833326: length 1.7
  BOTTOM w0.109: PR53.1 52.8,23.92 53.45,24.58 PQ9.5
N23900457: length 3.1
  TOP w0.203: PR707.2 289.57,34.02 289.05,33.5 288.54,33.5 287.87,32.83 PU700.3
N24451540: length 18.4
  TOP w0.109: PR35.2 46.04,26.24 46.96,26.24 v2(47.1,26.1) ; v2(52.7,24.62) 52.7,25.1 52.82,25.21 v3(53.1,25.21) 53.46,25.21 53.79,24.88 58.15,24.88 58.7,24.33 59.3,24.33 59.67,23.96 PR42.2 58.79,23.55 PC13.1 58.71,23.47 PQ6.2
  IN3 w0.081: v2(52.7,24.62) 50.27,24.62 49.49,25.39 47.81,25.39 v2(47.1,26.1)
N24455122: length 3.5
  TOP w0.109: PQ4.3 46.02,24.33 PR35.1 45.48,24.87 PR39.2 43.89,24.87 43.59,24.57 v1(43.51,24.57)
N24455126: length 3.3
  TOP w0.109: PQ4.4 46.02,21.35 45.84,21.16 45.84,20.93 PR36.2 45.89,20.92 46.71,20.1 PR40.1 46.71,19.13 v1(46.79,19.05)
N24455128: length 0.9
  TOP w0.109: PR41.2 46.67,20.95 PQ4.5
N24468445: length 6.9
  BOTTOM w0.109: PQ9.2 55.36,24.58 55,24.21 55,24.21 54.88,24.09 54.88,22.98 55.04,22.82 PC20.1 PR58.2 55.57,21.98 56.29,21.98 56.78,21.48 v1(56.78,21.15) 56.78,20.3 PR55.2
N24468529: length 2
  BOTTOM w0.109: PR55.1 56.91,19.26 PR57.2 56.61,18.44 56.28,18.77 PQ7.3
N24468533: length 4.6
  BOTTOM w0.109: PQ7.4 53.78,18.77 53.14,19.41 PR59.1 53.03,19.39 52.65,19 52.56,19 52.12,18.57 PR54.2 50.51,18.52 50.43,18.61 v1(50.09,18.61)
N24468535: length 1.3
  BOTTOM w0.109: PR60.2 53.91,19.42 PQ7.5
N24695047: length 3.4
  BOTTOM w0.109: PQ8.5 PQ8.6 54.53,11.62 54.72,11.43 PR72.2 55.18,11.24 v1(54.33,10.39)
N24831965: length 2
  TOP w0.203: PR207.2 200.64,10.32 201.45,11.13 PU200.9
N25195948: length 0.9
  BOTTOM w0.102: v2(307.61,40.28) v3(307.61,41.17)
N25195958: length 3.2
  TOP w0.109: PC513.1 308.58,42.65 308.33,42.65 v1(308.02,42.97)
  TOP w0.254: PC513.1 309.07,41.76 308.74,41.44 PU500.15
N25196046: length 0.9
  TOP w0.508: PC514.2 310.19,43.59 PR506.1
N25196480: length 2.6
  TOP w0.109: v1(310.29,34.16) 310.03,34.42 PR501.2
  TOP w0.508: PC501.1 PR501.2
N26820574: length 5.6
  TOP w0.508: PD701.1 284.6,39.8 v1(284.6,39.77) PR705.1 284.6,37.79 283.57,36.75 PD700.1
N26820774: length 3.5
  TOP w0.203: PR706.1 285.84,34.98 PC709.1 286.72,34.95 PR709.1 286.67,34.08 PU700.6
N26821236: length 6.5
  TOP w0.109: v1(288.63,37.84) 288.46,37.66 PR712.2
  TOP w0.203: PR716.1 288.52,34.98 288.2,34.66 288.05,34.66 287.66,34.27 PR713.2 287.07,33.53 PU700.5
  TOP w0.254: PR716.1 288.16,35.42 288.16,36.49 PR712.2
N26821586: length 5
  TOP w0.203: PR717.2 PC711.2 284.13,34.11 v1(284.67,33.58) 284.88,33.37 285.87,33.37 286.27,32.96 PU700.7
N26821595: length 2.9
  TOP w0.203: PC712.2 283.97,32.89 PR719.2 283.97,32.33 284.8,31.5 PU700.8
N26822390:
  vias: v1(290.65,30.22)
N26822393: length 2.5
  TOP w0.109: PR708.2 293.75,30.36 v1(294.25,29.86)
  TOP w0.508: PC708.2 PR708.2
N26949736: length 2
  TOP w0.203: PR710.2 284.24,29.81 284.73,30.3 PU700.11
N26949739: length 2.2
  TOP w0.203: PR711.2 283.9,28.95 284.85,29.9 PU700.12
N27028301: length 1.2
  TOP w0.109: RZ120.2 277.22,78.76 v1(277.76,78.22)
N27121902: length 25.9
  IN3 w0.081: v2(116.05,41.8) 115.64,41.39 112.3,41.39 110.49,43.2 102.6,43.2 101.33,41.94 100.87,41.94 100.4,41.48 100.4,40.17 100.19,39.96 v2(99.99,39.96)
  BOTTOM w0.109: UV64.48 114.26,41.38 114.71,41.84 116.01,41.84 v2(116.05,41.8) ; v2(99.99,39.96) 99.99,39.43 v1(99.9,39.34) 98.97,38.41 98.97,38.05 99.29,37.74 99.29,36.9 RV832.1
N27182711: length 2.5
  TOP w0.109: v1(272.65,143.81) 272.65,144.42 PR1137.2
  TOP w0.203: PR1137.2 PC1119.1
N28152235: length 4
  TOP w0.109: v1(272.15,148.35) 271.58,147.78 PR1128.1
  TOP w0.203: PR1127.2 PC1112.2 270.15,147.8 PC1111.2 PR1128.1
N28152401: length 3.3
  TOP w0.203: PU1100.15 v1(261.38,140.72) v2(261.38,140.15) 261.38,139.59 PR1150.2
  BOTTOM w0.254: v2(261.38,140.15) 260.95,139.72 PC1128.2
N28152437: length 3.4
  TOP w0.203: PU1100.3 259.63,146.53 v2(259.52,146.63)
  BOTTOM w0.109: v1(258.82,146.85) 259.04,146.63 v2(259.52,146.63)
  BOTTOM w0.203: PR1132.2 PC1118.2 259.62,146.54 v2(259.52,146.63)
N28152465: length 4.4
  TOP w0.203: PU1100.36 267.36,146.13 v2(267.74,146.51)
  BOTTOM w0.109: v1(268.25,147.07) 267.74,146.56 v2(267.74,146.51)
  BOTTOM w0.203: v2(267.74,146.51) 267.74,146.06 267.49,145.82 PC1120.1 PR1135.1
N28152580: length 3.9
  TOP w0.109: PC1140.1 255.43,152.46 v1(255.23,152.66)
  TOP w0.203: PC1140.1 PR1107.1 255.51,151.57 PC1103.2 254.63,151.59 PR1106.2
N28152729: length 3.7
  TOP w0.109: PR1108.2 v1(254.62,149.62)
  TOP w0.203: PC1105.1 PR1109.1 255.51,150.68 PC1103.1 254.63,150.67 PR1108.2
N28152784: length 6.4
  TOP w0.203: PR1151.2 261.85,140.01 261.85,140.86 261.78,140.93 PU1100.16
  TOP w0.254: v2(262.55,138.65) 262.55,139.3 PR1151.2
  BOTTOM w0.109: v2(262.55,138.65) 263.73,138.65 v1(263.82,138.56)
  BOTTOM w0.254: v2(262.55,138.65) 262.55,139.25 262.3,139.51 PC1130.1
N28152844: length 8.7
  TOP w0.254: v2(267.01,135.41) 265.8,136.62 v3(265.8,136.83) PR1166.2
  BOTTOM w0.254: PR1168.1 265.05,132.03 PH1104.1 265.97,134.37 v2(267.01,135.41)
N28152958: length 20.3
  TOP w0.203: PR1144.1 271.2,144.2 270.95,144.45 v2(270.88,144.45) 270.84,144.45 270.59,144.2 PR1141.2
  BOTTOM w0.254: v2(270.88,144.45) 270.32,143.9 270.32,143.32 271.46,142.19 271.46,138.31 270.41,137.27 266.72,137.27 v3(265.17,135.72) 264.24,134.79 263.42,134.79 262.6,133.97 262.6,133.51 PH1102.2
N28153073: length 88.5
  TOP w0.254: v2(217.16,121.29) 217.17,121.28 PH1100.2
  IN1 w0.254: v2(217.16,121.29) 216.89,121.02 216.89,120.39 216.23,119.73 212.53,119.73 211.34,120.92 211.34,122.59 210.34,123.59 209.06,123.59 208.5,124.15 208.5,125.35 207.76,126.09 207.76,132.14 209.18,133.56 213.5,133.56 214.27,134.32 216.48,134.32 222.93,140.77 226.92,140.77 235.13,148.97 239.61,148.97 242.67,152.03 v2(242.67,152.92)
  IN4 w0.254: v2(242.67,152.92) 242.67,152.73 244.09,151.31 262.47,151.31 262.84,151.68 v2(262.84,151.87)
  BOTTOM w0.109: v2(262.84,151.87) 262.84,152.22 v1(263.26,152.65)
  BOTTOM w0.203: PR1101.1 263.02,151.69 v2(262.84,151.87)
N28153459: length 9.3
  TOP w0.254: PR1165.2 260.6,138.57 PR1167.1 259.16,135.73 v1(257.1,135.73) 255.17,135.73 254.28,134.84 PH1103.1
N28153589: length 6.1
  TOP w0.109: PR1198.1 263.44,152.46 v1(263.2,152.71)
  TOP w0.203: PU1100.43 264.58,148.69 264.79,148.91 264.79,150.45 264.45,150.79 264.45,152.43 PR1198.1
N28153954: length 2
  TOP w0.109: v1(254.87,146.07) 255,145.93 PC1115.1
  TOP w0.203: PC1115.1 255.9,145.94 PR1133.2
N28154016: length 3.9
  BOTTOM w0.109: PR1122.2 v1(256.4,146.85)
  BOTTOM w0.203: PR1122.2 256.4,148.06 PC1109.1 PR1123.1 PC1110.1
N28154283: length 18.7
  TOP w0.109: v2(254.11,132.11) 254.73,132.11 v1(255.11,132.49)
  TOP w0.203: PR1140.2 254.97,144.18 PR1142.1
  TOP w0.254: PH1101.2 v2(254.11,132.11) ; v2(254.21,144.18) PR1140.2
  IN4 w0.254: v2(254.11,132.11) 254.11,133.11 256.72,135.71 256.72,143.41 255.95,144.18 v2(254.21,144.18)
N28180064: length 0.9
  TOP w0.203: PR1118.2 258.48,150.13 PC1107.1
N28185893: length 2
  TOP w0.109: v1(272.12,147.03) 272.01,146.92 PC1116.1
  TOP w0.203: PC1116.1 271.04,146.91 PR1134.2
N28185971: length 2.3
  TOP w0.109: PC1114.1 254.98,148.61 v1(254.65,148.28)
  TOP w0.203: PC1114.1 PR1130.2
N31547518: length 70.6
  IN1 w0.102: v2(79.67,62.01) 80.95,62.01 82.04,60.91 82.04,54.11 82.71,53.45 82.71,52.71 83.63,51.79 83.63,51.41 84.56,50.48 84.56,49.71 84.29,49.44 84.29,46.58 86.39,44.48 92.01,44.48 98.15,50.62 112.88,50.62 117.65,45.85 v2(117.65,45.24)
  BOTTOM w0.109: RV900.2 79.15,63.07 QV43.1 79.14,62.54 v2(79.67,62.01) ; v2(117.65,45.24) 117.95,45.24 118.72,44.47 v1(118.72,44.09) 118.72,42.29 117.96,41.53 117.96,38.82 117.55,38.41 116.86,38.41 116.31,38.97 UV64.54
N42077965: length 0.9
  BOTTOM w0.109: v2(248.5,140) 249,139.5 v1(249,139.29)
N42077969: length 0.7
  BOTTOM w0.109: v2(249.65,140.03) 249.65,140.5 v1(249.48,140.67)
N42077993: length 0.6
  BOTTOM w0.109: v1(250.87,140.68) v2(250.87,140.03)
N42078041: length 0.7
  BOTTOM w0.109: v1(239.89,140) v2(240.59,140)
N42078055: length 0.6
  BOTTOM w0.109: v1(241.28,139.91) v2(241.89,139.91)
N42078543: length 1.6
  BOTTOM w0.109: PC1216.2 v1(253.86,134.45)
N42078671: length 0.9
  BOTTOM w0.109: v2(243.18,139.95) 243.18,140.3 v1(242.83,140.66)
N42078715: length 1.1
  BOTTOM w0.109: PC1226.2 v1(244.63,135.58)
N43928883: length 2.7
  TOP w0.109: PQ704.6 284.76,21.61 285.14,21.61 v1(285.71,21.04)
  TOP w0.203: PR721.2 284.93,22.47 284.57,22.11 PQ704.6
N50626069: length 4.3
  TOP w0.109: PR2134.2 33.5,10.51 33.3,10.3 v1(33.3,9.92) 33.3,9.31 33.53,9.08 33.53,8.23 33.7,8.07 PQ2102.6
N50626073: length 4.5
  TOP w0.109: PQ2101.2 33.99,12.09 v3(33.59,12.49)
  TOP w0.381: PR2100.2 35.75,10.51 PR2134.1 35.75,10.92 35.31,11.35 PQ2101.2
N50626131: length 10.5
  TOP w0.381: v2(39.56,15.28) 39.38,15.28 39,14.9 v1(39,14.34) 38.72,14.06 36.49,14.06 PQ2101.1 36.26,14.95 PR2108.1
  BOTTOM w0.381: PR2101.2 PC2100.2 38.32,17.33 38.45,17.19 PQ2100.4 38.45,16.06 38.63,15.88 38.97,15.88 v2(39.56,15.28)
N50626325: length 3.4
  TOP w0.109: PQ2106.6 35.93,16.18 35.33,16.78 v1(35.33,17.33) 35.33,18.01 PR2142.2
N50626329: length 2.7
  TOP w0.109: PQ2105.2 36.34,19.15 PR2142.1 37.72,18.62 PR2104.2
N50626379: length 8.6
  TOP w0.381: PR2109.1 38.09,24.32 v1(37.2,24.32) 37.1,24.22 37.1,23.54 37.29,23.34 PQ2105.1 37.29,20.14 v2(37.24,20.08)
  BOTTOM w0.381: 38.32,20.48 PC2102.2 37.8,20.48 37.54,20.74 PQ2104.4 36.83,20.49 v2(37.24,20.08)
  BOTTOM w0.508: PR2105.2 38.32,20.48
N50692210: length 2
  TOP w0.203: PU700.9 284.03,31.1 PR714.2
N50714647: length 2.7
  TOP w0.109: PQ2102.2 36.77,8.72 v1(37.24,9.19) 37.49,9.44 PR2150.2
N50715082: length 3.3
  TOP w0.109: v1(37.85,15.09) 37.59,15.35 37.59,16.5 37.92,16.83 PQ2106.2 39.16,16.83 PR2106.2
N51087553: length 1.1
  BOTTOM w0.109: v3(309.34,30.45) 308.89,30.89 v2(308.46,30.89)
N51087711: length 0.9
  TOP w0.508: PC526.2 PR513.1
N51088117: length 1.3
  TOP w0.109: PC531.1 v1(308.06,24.72)
N51093717:
  vias: v3(67.05,16.49)
N51093758: length 1.9
  BOTTOM w0.109: v1(62.64,13.39) PR114.1
  BOTTOM w0.254: PR114.1 63.69,13.34 PC128.2
N51093811: length 1.7
  BOTTOM w0.109: v1(73.41,16.87) 73.07,16.54 PC115.1
N51093813: length 1.4
  TOP w0.109: 110.81,10.85 110.81,11.73 v1(110.43,12.11)
  vias: v2(110.1,10)
N51093882: length 3.3
  TOP w0.109: PR106.1 111.23,11.78 111.23,12.76 v1(111.65,13.17)
  TOP w0.254: PC112.2 PR106.1
N51093922: length 1.4
  TOP w0.109: v1(111.47,1.8) 111.92,2.25 PR101.2
N51431640: length 7.9
  TOP w0.381: PQ700.4 57.09,12.61 v2(57.09,13.49)
  BOTTOM w0.109: PQ705.1 60.18,16.17 v1(60.68,16.67)
  BOTTOM w0.381: PQ705.1 59.78,14.36 58.58,14.36 58.24,14.01 57.82,13.59 PR732.1 57.19,13.59 v2(57.09,13.49) 57.09,13.07 57.41,12.76 PR731.2
N52218840: length 3.5
  TOP w0.203: PU1100.27 266.99,142.53 267.23,142.29 v1(267.23,140.81) PR1170.2
N54556584: length 16.4
  TOP w0.109: v2(50.84,19.71) 51.26,20.13 v1(51.76,20.13) 54.25,20.13 55.02,20.91 55.02,21.12 55.37,21.47 55.37,23.05 55.16,23.27 54.79,23.27 53.99,24.07 PR33.2 ; v2(51.89,15.93) 52.13,16.17 54.08,16.17 PD12.2
  IN3 w0.081: v2(51.89,15.93) 51.89,17.68 50.84,18.72 v2(50.84,19.71)
N54556800: length 19.2
  TOP w0.109: PQ6.6 55.61,22.56 55.61,21.37 55.26,21.02 55.26,20.47 v1(55.09,20.31) 54.59,19.8 52.2,19.8 52.11,19.71 v2(51.42,19.71) ; PD12.1 56.55,13.69 56.2,13.34 52.78,13.34 v2(52.61,13.52)
  IN3 w0.081: v2(51.42,19.71) 51.42,19.22 52.96,17.69 52.96,13.87 v2(52.61,13.52)
N54556836: length 16.3
  TOP w0.109: v2(52.56,14.88) 53.14,14.3 PD13.2
  IN3 w0.081: v2(52.56,14.88) 52.42,14.74 51.23,14.74 50.51,15.46 50.51,18.46 49.91,19.06 49.91,19.8 51.58,21.47 51.58,22.47 v2(51.39,22.66)
  BOTTOM w0.109: v2(51.39,22.66) 51.39,24.38 51.77,24.76 PR51.2 52.77,25.46 52.77,25.85 v1(53.29,26.36)
N61680769: length 14.2
  TOP w0.109: PD13.1 51.46,15.56 v2(51.35,15.68)
  IN3 w0.081: v2(54.29,23.11) 52.48,23.11 51.91,22.53 51.91,21.47 50.14,19.7 50.14,19.13 51.41,17.86 51.41,15.74 v2(51.35,15.68)
  BOTTOM w0.109: v2(54.29,23.11) 54.29,23.84 54.1,24.03 54.1,25 53.87,25.23 PQ9.6
N61687377: length 2.6
  TOP w0.109: v1(290.08,50.63) 290.04,50.67 PR403.2
  TOP w0.508: PC405.1 288.48,51.61 PR403.2
N61688443: length 5.6
  TOP w0.229: PR807.2 157.29,12.91 156.42,13.77 PR809.2
  TOP w0.254: v2(157.92,11.73) 157.93,11.73 158.04,11.85 158.04,12.45 157.58,12.91 PR807.2
  BOTTOM w0.109: v1(155.98,12.73) 156.73,11.98 PR810.1
  BOTTOM w0.254: v2(157.92,11.73) 157.92,11.72 157.85,11.65 PR810.1
N61688512: length 0.6
  TOP w0.109: 148.05,12.13 v1(147.49,12.13)
N61690744: length 0.7
  TOP w0.109: 133.95,7.92 134.28,7.92 v1(134.57,8.21)
N61692023: length 0.7
  BOTTOM w0.109: v2(224.78,137.52) v1(224.09,137.52)
N61692025: length 0.6
  BOTTOM w0.109: v2(226.35,137.49) v1(225.73,137.49)
N61692045: length 0.6
  BOTTOM w0.109: v2(227.57,137.75) v1(228.18,137.75)
N61692067: length 4.4
  TOP w0.254: v2(227.44,124.97) 226.4,124.97 225.9,124.47 PL1205.3
  BOTTOM w0.109: v1(228.48,126.04) 228.3,125.87 PR1215.1
  BOTTOM w0.254: PR1215.1 227.51,124.9 v2(227.44,124.97)
N61692131: length 1.1
  BOTTOM w0.109: PC1246.2 v1(229.11,133.07)
N61692583: length 4.9
  TOP w0.254: PL1204.3 233.64,127.07 234.05,127.48 235.61,127.48 v2(235.7,127.39)
  BOTTOM w0.109: v1(236.92,128.21) 236.4,127.69 PR1214.1
  BOTTOM w0.254: PR1214.1 235.87,127.21 v2(235.7,127.39)
N61692600: length 0.8
  BOTTOM w0.109: v2(234.02,139.91) 234.55,139.39 v1(234.55,139.29)
N61692604: length 1.2
  BOTTOM w0.109: v2(233.17,139.86) v1(233.17,138.62)
N61692634: length 0.7
  BOTTOM w0.109: v1(235.41,140.58) v2(235.41,139.92)
N61692676: length 1.1
  BOTTOM w0.109: PC1236.2 v1(236.96,135.57)
N61733264: length 1.8
  TOP w0.109: PD14.1 46.67,25.44 PQ4.2
N61733291: length 21.2
  IN3 w0.081: v2(55.67,20.85) 55.52,20.85 54.49,19.82 54.49,19.81 53.64,18.97 53.64,12.91 51.07,10.34 v2(51.07,8.12)
  BOTTOM w0.109: PQ7.2 55.41,19.42 55.21,19.62 55.21,20.62 55.44,20.85 v2(55.67,20.85) ; PD15.1 51.03,9.41 v1(50.99,9.36) 50.99,8.2 v2(51.07,8.12)
N61859075: length 4.9
  TOP w0.203: PU700.15 286.27,28.12 286.1,27.95 285.23,27.95 v1(284.5,27.22) 283.97,26.7 283.73,26.7 283.51,26.48 282.82,26.48 282.59,26.25 PR724.2
N63173356: length 27
  TOP w0.102: v2(233.84,48.04) 232.87,48.04 232.43,47.6 JDIMM2.165
  IN1 w0.102: v2(233.84,48.04) 233.84,48 238.08,43.76 238.08,32.08 236.74,30.74 v2(236.74,30.1)
  BOTTOM w0.109: v2(236.74,30.1) 236.74,30.02 235.84,29.11 234.28,29.11 233.89,28.72 T49.1
N63173755: length 3.2
  TOP w0.102: JDIMM2.162 233.18,36.8 234.15,35.83 T48.1
N63181367: length 3.5
  TOP w0.102: v2(233.71,62.14) T50.1
  BOTTOM w0.102: JDIMM3.162 233.18,61.83 233.49,62.14 v2(233.71,62.14)
N63181369: length 28.5
  IN1 w0.102: v2(238.02,29.45) 238.52,29.45 238.83,29.76 238.83,47.06 235.5,50.39 234.43,50.39 233.83,49.79 v2(233.61,49.79)
  BOTTOM w0.102: JDIMM3.165 232.43,50.5 233.13,49.79 v2(233.61,49.79)
  BOTTOM w0.109: T51.1 238.02,28.86 v2(238.02,29.45)
N63187763: length 28.6
  TOP w0.102: JDIMM4.162 233.18,49.63 v2(233.62,49.19)
  IN1 w0.102: v2(238.25,30) 238.25,31.32 238.6,31.67 238.6,46.97 235.41,50.16 234.7,50.16 233.72,49.19 v2(233.62,49.19)
  BOTTOM w0.109: v2(238.25,30) 237.93,30 236.8,28.87 T52.1
N63187777: length 2.6
  TOP w0.102: JDIMM4.165 232.43,61.51 232.42,61.51 T53.1
N63205753: length 1.6
  BOTTOM w0.109: UR3.3 14.06,18.72 13.76,18.42 RR237.1
N63206214: length 1.1
  BOTTOM w0.109: v1(5.67,24.3) 6.16,23.8 6.58,23.8
N63206790: length 8.5
  BOTTOM w0.109: 15.33,26.78 15.33,27.61 15.12,27.82 11.77,27.82 10.71,26.77 10.71,26.64 RR238.1 8.73,26.23 v1(8.52,26.43)
N63261697: length 2.3
  TOP w0.109: QE12.1 150.83,33.63 RE94.1 148.88,33.63 v1(148.66,33.41)
N63261780: length 6.3
  TOP w0.109: UE1.M12 v2(139.11,20.07)
  BOTTOM w0.109: v2(139.11,20.07) 139.33,20.3 141.12,20.3 141.21,20.39 141.21,21.07 141.57,21.43 v1(141.57,22.34) 141.57,22.86 RE703.2
N63261829: length 0.8
  BOTTOM w0.109: CE57.1 135.19,22.89 135.19,22.89 RE350.2
N63264088: length 5.8
  TOP w0.109: v2(129.26,29.52) 129.26,29.17 129.93,28.5 UE1.B1
  BOTTOM w0.109: v1(129.33,28.78) 129.33,29.45 v2(129.26,29.52) 128.6,29.52 128.22,29.9 128.22,30.41 127.59,31.04 127.59,31.27 ; 127.59,31.27 RE57.1 ; 127.59,31.27 RE58.1
N63264181: length 3.6
  TOP w0.109: UE1.G2 130.5,24.45 130.17,24.11 129.41,24.11 128.47,25.06 RE318.2
N63264846: length 3.8
  TOP w0.109: RE546.2 153.13,28 152.48,27.35 QE17.1 152.48,25.28 v1(152.25,25.05)
N63282244: length 6.1
  TOP w0.203: v2(349.34,24.27) 349.29,24.23 348.32,24.23 UA1.33
  BOTTOM w0.254: RA213.1 RA214.1 352.68,26.04 351.74,25.1 v1(351.42,25.1) 350.36,25.1 349.53,24.27 v2(349.34,24.27)
N63282319: length 6.1
  TOP w0.203: CA25.2 353.33,24.37 352.55,23.6 352.55,23.39 352.31,23.14 352.31,23.14 352.26,23.09 349.61,23.09 348.87,23.83 UA1.32
N63282335: length 4.9
  TOP w0.109: v1(351.07,18.15) 350.59,18.63 CA232.1
  TOP w0.203: 347.99,19.8 347.67,19.8 347.56,19.9 UA1.24
  TOP w0.381: 347.99,19.8 348.88,19.8 349.62,19.05 CA29.1 350.2,18.63 CA232.1
N63282517: length 3.3
  TOP w0.203: UA1.38 347.16,26.18 347.16,26.66 347.42,26.92 v2(347.42,27.06)
  BOTTOM w0.109: v1(348.48,25.38) CA35.2
  BOTTOM w0.254: v2(347.42,27.06) 348.09,26.39 CA35.2
N63282540: length 4.2
  TOP w0.203: UA1.39 346.76,27 v2(346.83,27.06)
  BOTTOM w0.109: v1(346.83,26.04) v2(346.83,27.06)
  BOTTOM w0.254: v2(346.83,27.06) 346.83,27.38 CA51.2 347.82,28.36 RA44.2
N63282645: length 16
  IN1 w0.508: JHP1.5 360.85,14.7 359.14,16.41 357.82,16.41 v2(357.51,16.72)
  BOTTOM w0.508: RA219.2 350.03,15.96 350.03,17.04 v1(349.76,17.31) 349.76,18.44 350.11,18.79 352.05,18.79 352.85,17.99 354.02,17.99 355.29,16.72 DA2.2 v2(357.51,16.72)
N63282767: length 3.1
  TOP w0.203: CA52.2 347.73,18.63 347.48,18.88 346.73,18.88 346.36,19.24 UA1.21
N63282827: length 5.7
  TOP w0.109: v1(349.79,17.17) 350.2,17.59 CA232.2
  TOP w0.203: 347.66,19.28 347.16,19.77 UA1.23
  TOP w0.381: 347.66,19.28 348.73,19.28 349.04,18.97 349.04,18.32 349.31,18.04 CA29.2 349.62,18.04 CA232.2
N63282834: length 2.7
  TOP w0.203: UA1.19 v1(345.56,19.04) 345.56,18.38 CA53.2
N63282842: length 1.2
  TOP w0.203: CA33.1 340.14,19.22 RA17.2
N63302772: length 2.3
  TOP w0.109: v1(328.61,33.3) CZ130.1
  TOP w0.254: CZ130.1 328.38,32.11 UZ23.6
N63303945: length 9.1
  IN2 w0.081: v2(82.9,51.6) 83.38,51.6 84.04,50.94 84.04,49.49 82.56,48.01 v2(82.56,47.66)
  BOTTOM w0.109: v2(82.9,51.6) 83.34,52.04 RN217.1 83.34,53.06 v1(83.61,53.33) ; JNGFF3.10 83.12,46.95 82.56,47.51 v2(82.56,47.66)
N63303993: length 7.5
  TOP w0.109: RN218.1 358.83,11.87 v2(359.3,12.33)
  IN2 w0.081: JNGFF4.10 360.65,7.99 360.15,8.5 360.15,11.49 v2(359.3,12.33)
N63304099: length 3.8
  TOP w0.109: UZ60.4 328.82,27.33 v1(329.92,28.42)
  TOP w0.254: UZ23.3 328.38,27.66 328.19,27.47 UZ60.4
N63307260: length 2.6
  BOTTOM w0.109: RN216.1 85.22,21.91 85.21,21.9 JNGFF5.10
N63354804: length 4.8
  BOTTOM w0.109: RT394.2 CT21.1 23.12,28.67 22.87,28.42 22.87,26.94 23.8,26 YT1.1
N63359901: length 6.1
  TOP w0.109: v1(37.95,27.87) 37.95,27.61 38.15,27.42 RT545.1 37.8,26.92 37.61,27.12 37.29,27.12 37.1,26.94 36.75,26.94 QT2.2 36.32,27.36 CT375.1 36.32,28.92 v2(35.92,29.32)
  BOTTOM w0.109: v2(35.92,29.32) 36.31,28.93 RT546.1
N63359905: length 2.5
  BOTTOM w0.109: QT4.6 36.86,28.26 37.51,28.91 RT546.2 37.51,28.93 37.64,29.07 v1(37.64,29.91)
N63359909: length 8.7
  TOP w0.109: v1(33.73,26.5) 34.36,27.13 QT2.3
  TOP w0.381: QT2.3 35.32,26.72 35.64,26.39 36.02,26.39 36.44,25.97 37.96,25.97
  TOP w0.508: QT2.3 35.32,27.66 35.41,27.75 CT375.2 ; 37.96,25.97 38.74,25.97
  BOTTOM w0.381: RT548.2 39.56,26.81 v2(39.71,26.66) 40.01,26.36 QT3.3
N63359919: length 6.5
  BOTTOM w0.109: v1(38.69,31.23) 38.47,31.02 CT376.1 38.47,28.47 38.15,28.14 RT550.2 37.83,27.37 37.26,27.37 37,27.11 36.44,27.11 36.21,27.35 QT4.5
N63359925: length 5.8
  BOTTOM w0.109: QT3.2 40.11,25.11 39.94,24.95 v1(39.37,24.95) 39.05,25.26 RT548.1 RT549.1 37.81,25.53 36.37,25.53 36.21,25.7 QT4.2
N63359927: length 3.4
  BOTTOM w0.109: RT549.2 37.86,27.12 37.34,27.12 37.1,26.88 35.79,26.88 35.56,26.65 QT4.3
N63361205: length 20.9
  TOP w0.109: v2(39.9,24.1) 39.9,24.04 v1(40.26,23.67)
  IN4 w0.508: v2(25.74,21.33) 26.8,22.39 27.24,22.39 28.51,23.65 28.51,24.71 29.14,25.35 29.32,25.35 29.81,25.83 31.82,25.83 32.51,26.52 35.53,26.52 36.29,25.76 38.23,25.76 v2(39.9,24.1)
  BOTTOM w0.508: RT542.1 38.34,24.6 38.52,24.41 39.58,24.41 v2(39.9,24.1)
N63361207: length 14.4
  BOTTOM w0.254: RT543.2 CT373.1 30.73,25.7 RT544.1 29.62,25.7 v1(27.72,23.8) 26.81,22.89 26.81,21.12 26.11,20.42 UT7.4 25.28,20.02 25.49,19.8 28.75,19.8 QT1.1
N63361304: length 44.4
  TOP w0.127: v1(33.72,28.12) 33.78,28.18 v2(34.52,28.18)
  IN3 w0.381: v2(34.52,28.18) 35.45,27.25 37.7,27.25 39.61,29.16 40.42,29.16 40.86,29.6 41.43,29.6 42.28,28.74 42.7,28.74 42.99,28.45 42.99,27.91 41.61,26.53 41.61,23.56 45.9,19.27 45.9,14.09 41.63,9.82 35.78,9.82 34.69,8.73 v2(34.69,8.08)
  BOTTOM w0.381: DT64.2 34.49,28.15 v2(34.52,28.18) ; QT10.1 35.1,7.68 v2(34.69,8.08)
N63894512: length 3.5
  TOP w0.381: 348.82,20.64 349.88,19.59 v1(350.2,19.59) CA233.2 CA49.2
N64344369: length 3.5
  TOP w0.254: RC114.1 261.79,104.68 v1(261.08,104.68) 259.55,104.68 UC1.BT25
N64351847: length 18.5
  TOP w0.109: v2(258.19,95.22) 257.86,95.55 UC1.BP13
  BOTTOM w0.109: T199.1 267.59,83.7 267.59,86.05 263.19,90.44 262.36,90.44 260.95,91.85 260.32,91.85 258.8,93.38 258.8,94.61 v2(258.19,95.22)
N64354433: length 3.7
  TOP w0.102: T194.1 215.8,111.29 218.49,111.29 UC1.A33
N64403776: length 4.5
  TOP w0.109: RH6.2 178.38,16.92 178.61,17.16 v1(178.61,17.49) 178.49,17.62 178.49,18.1 178.69,18.31 178.69,19.27 178.41,19.55 178.41,20.32 178.65,20.56 UH1.AU47
N64404191: length 1.6
  TOP w0.102: UH1.Y35 187.05,26.61 v2(187.47,26.19)
  BOTTOM w0.102: T34.1 187.88,25.78 187.88,25.78 v2(187.47,26.19)
N64404193: length 3
  TOP w0.102: UH1.Y36 187.26,25.84 v2(187.49,25.61)
  BOTTOM w0.109: T33.1 188.06,23.96 188.06,25.03 v2(187.49,25.61)
N64404195: length 9.6
  TOP w0.089: 170.1,45.67 170.76,45.67 171.32,45.11 172.18,45.11 172.9,44.39 173.26,44.39 173.74,43.9 174.23,43.9 174.62,43.51 175.11,43.51 175.41,43.21 UH1.BC1
  TOP w0.102: 170.1,45.67 169.07,45.67
  TOP w0.109: T36.1 167.84,46.9 169.07,45.67
N64404197: length 1.7
  TOP w0.102: UH1.AL35 v2(181.15,26.51)
  BOTTOM w0.102: 180.7,26.06 v2(181.15,26.51)
  BOTTOM w0.109: 180.7,26.06 180.58,25.94 T35.1
N64407208: length 2.6
  TOP w0.109: UH1.B25 195.76,31.4 196.03,31.67 197.78,31.67 197.88,31.58 T78.1
N64407218: length 1.6
  TOP w0.109: UH1.P24 190.01,31.55 v2(190.4,31.16)
  BOTTOM w0.109: v2(190.4,31.16) 190.8,31.16 T79.1
N64407220: length 3.4
  TOP w0.109: UH1.R24 v2(189.25,31.41)
  BOTTOM w0.109: T80.1 191.16,32.34 190.57,32.34 190.28,32.06 189.46,32.06 189.25,31.84 v2(189.25,31.41)
N64407222: length 6.2
  TOP w0.109: UH1.C26 195.01,30.78 195.37,31.14 197.47,31.14 197.59,31.03 200.53,31.03 T81.1
N64407224: length 6.8
  TOP w0.109: T82.1 202.11,30.79 197.44,30.79 197.33,30.9 195.59,30.9 UH1.B26
N64407234: length 1.5
  TOP w0.109: UH1.F26 193.82,31.12 v2(194.09,31.39)
  BOTTOM w0.109: T83.1 194.46,31.02 v2(194.09,31.39)
N64407236: length 1.2
  TOP w0.109: v2(193.39,31.39) 193.06,31.06 UH1.G26
  BOTTOM w0.109: v2(193.39,31.39) 193.39,30.88 T84.1
N64407238: length 2.6
  TOP w0.076: UH1.B27 195.84,30.41 197.2,30.41 197.5,30.1 197.94,30.1
  TOP w0.109: 197.94,30.1 T85.1
N64407240: length 6
  TOP w0.109: T86.1 200.11,30.59 197.29,30.59 197.22,30.66 195.8,30.66 195.7,30.57 195.51,30.57 195.15,30.21 UH1.C27
N64407242: length 1.2
  TOP w0.109: v2(191.84,30.29) 191.84,30.51 UH1.L26
  BOTTOM w0.109: v2(191.84,30.29) 191.84,30.47 192.11,30.74 T87.1
N64407244: length 1.4
  TOP w0.109: UH1.M26 v2(190.31,30.35)
  BOTTOM w0.109: T88.1 190.65,30.01 v2(190.31,30.35)
N64407246: length 2.9
  TOP w0.109: v2(193.06,30.3) 193.14,30.3 193.98,29.47 194.47,29.47 194.58,29.58 UH1.D29
  BOTTOM w0.109: v2(193.06,30.3) 193.06,30.1 192.81,29.86 T89.1
N64407248: length 1.4
  TOP w0.109: v2(193.82,30.3) 194.31,29.82 UH1.E28
  BOTTOM w0.109: v2(193.82,30.3) 194.26,29.87 T90.1
N64407250: length 1.6
  TOP w0.109: UH1.K29 191.8,29.22 191.8,28.99 v2(191.95,28.83)
  BOTTOM w0.109: v2(191.95,28.83) 191.95,28.66 T91.1
N64407252: length 1.2
  TOP w0.109: v2(190.97,28.85) 190.97,29.26 UH1.M29
  BOTTOM w0.109: v2(190.97,28.85) 190.97,28.57 T92.1
N64407590: length 12.3
  TOP w0.152: v2(188.75,37.21) 188.59,37.06 UH1.U13
  BOTTOM w0.109: v2(188.75,37.21) 188.27,37.21 188.01,37.47 187.35,37.47 187.07,37.75 187.07,42.89 186.12,43.84 186.12,44.67 187.01,45.56 T40.1
N64412898: length 2.4
  TOP w0.102: UH1.R15 v2(189.8,36.32)
  BOTTOM w0.109: v2(189.8,36.32) 189.84,36.32 190.39,36.87 190.39,37.1 T60.1
N64412900: length 6
  TOP w0.102: UH1.R13 v2(189.87,37.08)
  BOTTOM w0.109: T61.1 193.3,38.9 191.68,38.9 191.51,39.08 191.04,39.08 190.76,38.79 190.76,37.97 v2(189.87,37.08)
N64412902: length 1.3
  TOP w0.102: UH1.AN35 v2(180.13,26.48)
  BOTTOM w0.109: v2(180.13,26.48) 179.99,26.34 T62.1
N64412904: length 2.7
  TOP w0.102: UH1.AL37 v2(181.15,25.74)
  BOTTOM w0.102: T63.1 181.8,25.09 v2(181.15,25.74)
N64413001: length 1.9
  TOP w0.109: RH28.2 115.34,33.86 CH321.1 v1(115.33,34.88)
N64413003: length 2.9
  BOTTOM w0.109: RH29.2 137.44,44.32 137.94,44.82 CH322.1 138.71,44.61 v1(138.71,43.82)
N64416436: length 7.7
  TOP w0.109: RH101.2 v1(333.54,34.71) 334.13,34.13 334.13,32.1 335.57,30.65 SW1.2
N64422426: length 4.1
  TOP w0.102: UH1.BC22 175.31,33 175.24,32.93 174.9,32.93 174.82,32.85 174.06,32.85 173.81,32.6 172.24,32.6 172.09,32.76 T307.1
N64422428: length 4.1
  TOP w0.102: UH1.BF23 174.07,32.59 173.89,32.41 170.91,32.41 T306.1
N64429445: length 3.1
  BOTTOM w0.109: v1(104.13,25.9) CZ521.2 104.47,26.9 104.74,26.64 105.44,26.64 105.63,26.44 UZ42.6
N64429590: length 2.5
  BOTTOM w0.109: v1(106.21,21.56) RZ509.2
  BOTTOM w0.254: RZ509.2 106.21,22.79 105.63,23.37 UZ42.3
N64429642: length 4.3
  TOP w0.109: CZ523.2 339,46.91 v1(339,48.47)
  TOP w0.178: CZ523.2 339.54,46.38 UZ40.12
N64429659: length 2
  TOP w0.178: UZ40.10 v1(340.34,45.46) 340.34,46.36 CZ522.2
N64429688: length 4.9
  TOP w0.109: v1(93.22,6.56) 93.47,6.81 93.47,9.6 RZ514.2 92.42,9.91 QZ20.1
N64429766: length 2.8
  BOTTOM w0.109: v1(183.79,71.69) CZ515.2 182.35,71.75 UZ43.6
N64429852: length 3.6
  TOP w0.109: v2(180.96,86.88) 180.8,86.88 v1(180.37,86.44)
  TOP w0.254: RZ549.2 RZ548.2 181.72,86.88 v2(180.96,86.88)
  BOTTOM w0.203: UZ41.3 181.47,87.12 181.22,86.88 v2(180.96,86.88)
N64429908: length 2
  BOTTOM w0.109: CZ517.2 185.4,87.03 185.38,87.06 v1(184.9,87.06) 184.35,87.06 184.28,87.12 UZ41.12
N64429910: length 2.2
  BOTTOM w0.109: UZ41.10 184.25,87.92 184.67,88.34 v1(184.89,88.34) 184.94,88.38 CZ516.2
N64430360: length 2.8
  BOTTOM w0.109: v1(335.6,28.66) CZ121.1
  BOTTOM w0.254: CZ121.1 335.38,27.3 UZ45.6
N64433226: length 72.1
  TOP w0.109: UV24.4 98.19,18.81 98.05,18.67 98.05,18.45 v2(98.25,18.25) ; DV42.1 133.51,41.58 RV3.1 132.44,43.05 DV3.1 132.34,44.39 129.96,44.39 v1(128.52,45.84) 127.47,46.89 127.47,47.44 v2(127.59,47.57)
  BOTTOM w0.109: v2(127.59,47.57) 127.27,47.24 127.27,46.44 126.42,45.59 126.42,39.64 126.23,39.18 125.79,37.83 125.53,36.83 125.53,35.99 124.81,35.28 122.3,35.28 121.72,34.69 121.72,33.15 123.76,31.11 123.76,30.34 122.73,29.32 122.73,25.84 123.9,24.68 123.9,24.08 122.09,22.27 122.09,21.68 121.86,21.44 118.07,21.44 116.63,20.01 111.96,20.01 109.98,18.03 109.98,17.12 108.4,15.54 100.96,15.54 v2(98.25,18.25)
N64433264: length 2.2
  TOP w0.109: UV24.3 96.57,18.81 97,18.38 v1(97,17.5)
N64434267: length 7
  TOP w0.109: UV65.4 134.97,47.23 134.22,47.98 v1(133.72,47.98) 133.31,47.98 132.86,47.53 132.86,46.7 132.62,46.46 130.9,46.46 130.06,47.3 DV39.2
N64440122: length 2.5
  BOTTOM w0.109: v1(83.61,57.32) RV5.2
  BOTTOM w0.254: QV2.1 82.53,57.42 RV5.2
N64440771: length 2
  TOP w0.127: 75.95,24.97 75.95,24.16 76.52,23.59 v3(76.52,23.17)
N64440773: length 8.2
  TOP w0.356: QV7.1 75.17,25.91 RZ546.2 75.17,24.86
  TOP w0.508: 75.17,24.86 75.17,24.22 75.87,23.52 75.87,22.8 76.24,22.43 76.77,22.43 77.35,23 v1(78.31,23) RV6.1
N64476900: length 4.9
  TOP w0.109: v1(348.75,45.1) RI14.2
  TOP w0.254: RI14.2 348.01,47.03 348.01,48.78 348.24,49.01 UI1.16
N64477358: length 3.1
  TOP w0.254: RI71.2 347.4,36.76 v1(347.4,37.53) 347.4,37.88 348.11,38.59 UI2.16
N64495443: length 3.6
  TOP w0.109: v1(160.17,26.08) 159.99,26.26 RE70.1 158.83,25.38 RE90.1 158.4,25.37 158.06,25.03 QE11.3
N64495463: length 3.1
  TOP w0.109: RE70.2 158.61,27.4 QE4.2 158.61,28.55 v1(159.73,29.67)
N64496280: length 5.2
  BOTTOM w0.109: CE342.1 12.62,10.56 v1(12.62,12.25) 12.62,12.8 12.32,13.11 UE12.4
N64542251: length 9
  TOP w0.109: DV44.2 184.11,100.22 181.5,100.22 v1(181.03,99.75) 180.58,99.31 176.68,99.31 176.47,99.09 JDGFF2.E2
N64542506: length 3.8
  TOP w0.109: UV68.4 185.79,97.56 185.04,96.8 UV60.1 184.48,96.8 183.75,96.07 RV821.2
N64542541: length 6.8
  TOP w0.109: UV68.2 186.87,97.45 186.58,97.16 186.58,96.67 185.52,95.61 RV820.2 185.52,95 184.78,94.25 184.32,94.25 183.9,93.83 UV69.4
N64855800: length 12.6
  TOP w0.102: UH1.Y14 v2(187.52,36.96)
  BOTTOM w0.109: v2(187.52,36.96) 186.93,36.96 186.7,37.19 186.7,42.91 185.88,43.73 185.88,44.82 187.91,46.85 T288.1
N64855802: length 7.6
  TOP w0.102: UH1.Y15 v2(187.45,36.19)
  BOTTOM w0.109: T289.1 191.37,39.69 191.12,39.45 190.23,39.45 189.75,38.97 189.75,38.37 189.35,37.97 189.35,36.92 189.16,36.73 187.99,36.73 v2(187.45,36.19)
N64855804: length 5.3
  TOP w0.102: UH1.U37 188.5,25.74 v2(188.68,25.56)
  BOTTOM w0.102: v2(188.68,25.56) 188.38,25.26 188.38,24.21 188.74,23.85 188.74,21.53 T290.1
N64855809: length 1.9
  TOP w0.089: v2(188.73,26.26) 188.45,26.26 UH1.U35
  BOTTOM w0.109: T291.1 188.16,26.26 v2(188.73,26.26)
N64855811: length 1.1
  TOP w0.102: UH1.AH15 v2(182.41,36.19)
  BOTTOM w0.109: T294.1 182.38,36.21 v2(182.41,36.19)
N64855813: length 1.2
  TOP w0.102: UH1.AH14 v2(182.39,36.96)
  BOTTOM w0.109: T295.1 182.12,37.24 v2(182.39,36.96)
N64856540: length 6.6
  TOP w0.109: QH7.2 124.34,11.58 123.78,11.02 RH433.1 123.13,11.01 CH340.1 123.38,10.06 123.61,9.83 123.61,8.87 RH432.2 123.34,8.23 v1(122.73,7.62)
N64856544: length 3.7
  TOP w0.109: v1(119.65,11.36) 119.99,11.7 QH6.1 122.25,11.7 122.48,11.93 RH433.2
N64880560: length 1.2
  TOP w0.102: UH1.N32 v2(190.11,27.6)
  BOTTOM w0.102: T292.1 190.11,27.5 v2(190.11,27.6)
N64880580: length 1.4
  TOP w0.102: UH1.R32 189.86,28.66 v2(189.86,28.78)
  BOTTOM w0.109: T293.1 189.92,28.72 v2(189.86,28.78)
N64881659: length 12.8
  TOP w0.102: UE1.H9 v2(136.7,23.28)
  TOP w0.109: RE743.1 145.93,24.36 v2(146.25,24.04) v1(146.8,23.49)
  IN1 w0.102: v2(136.7,23.28) 136.7,23.35 137,23.65 139.11,23.65 139.62,24.16 141.24,24.16 142.24,23.16 144.53,23.16 145.41,24.04 v2(146.25,24.04)
N64883172: length 3.7
  TOP w0.109: RE745.2 141.62,22.55 141.15,22.08 140.63,22.08 140.17,21.62 139.34,21.62 138.91,22.05 UE1.K12
N64883286: length 3.8
  TOP w0.109: v2(137.89,18.45) 137.89,19.04 138.26,19.41 138.26,20.12 UE1.M11
  BOTTOM w0.109: RE746.1 138.19,18.15 v2(137.89,18.45) 137.89,18.96 v1(138.15,19.23)
N64968632: length 3.1
  TOP w0.109: RT456.2 39.41,45.44 RT445.2 39.42,45.84 39.26,46.01 UT32.1 38.5,46.66 v1(38.14,47.02)
N64968636: length 2.4
  TOP w0.109: v1(41.7,45) 41.25,45.45 RT448.2 40.56,45.65 UT32.3
N65166298: length 26.6
  IN1 w0.102: v2(237.38,30.08) 237.38,30.84 238.31,31.77 238.31,43.85 234.41,47.76 234.41,48.24 234.06,48.58 v2(233.62,48.58)
  BOTTOM w0.102: JDIMM1.162 233.18,48.42 233.33,48.58 v2(233.62,48.58)
  BOTTOM w0.109: v2(237.38,30.08) 237.38,30.01 236.04,28.67 T46.1
N65166304: length 2.5
  BOTTOM w0.102: T47.1 232.43,36.03 JDIMM1.165
N65178354: length 5
  TOP w0.109: v1(194.65,124.08) 194.91,124.08 RV50.1 195.42,123.04 195.11,123.04 194.35,122.28 194.35,121.01 194.29,120.95 UV8.20
N65178456: length 6
  TOP w0.109: v1(197.75,121.28) 197.49,121.01 196.23,121.01 195.73,121.51 CV75.1 195.68,121.1 195.89,120.89 195.89,120.32 195.49,119.92 194.39,119.92 194.22,119.75 UV8.17
N65183116: length 1.6
  TOP w0.109: T315.1 63.24,30.37 63.66,30.79 UV66.37
N65183120: length 1.6
  TOP w0.109: UV67.37 143.1,39.5 T316.1
N65189266: length 3.5
  TOP w0.109: v2(103.05,44.4) 103,44.35 JEDP1.18
  BOTTOM w0.109: v1(101.63,45.57) LV1.1 103.05,45.36 v2(103.05,44.4)
N65240098: length 1.6
  TOP w0.109: RZ62.1 120.59,26.68 UZ12.27
N65240286: length 2.1
  TOP w0.109: v1(126.23,23.84) 126.14,23.84 RZ63.1 124.95,22.65 CZ56.1
N65288200: length 9.8
  BOTTOM w0.109: v1(92.1,44.28) 91.52,44.86 RN219.1 91.05,44.94 86.51,44.94 84.9,46.55 84.9,47.13 84.59,47.45 JNGFF3.8
N65288306: length 7.4
  TOP w0.109: v2(359.3,12.95) 359.09,12.74 RN220.1
  IN2 w0.081: v2(359.3,12.95) 360.35,11.89 360.35,8.65 361.15,7.85 JNGFF4.8
N65288375: length 2.7
  BOTTOM w0.109: RN221.1 85.75,22.78 85.38,22.4 JNGFF5.8
N65845957: length 5.6
  BOTTOM w0.109: UL1.2 186.32,125.74 186.03,125.45 186.03,123.39 186.29,123.13 RL10.2 185.99,122.8 185.82,122.62 185.82,122.14 v1(185.19,121.52)
N65846745: length 7.9
  TOP w0.109: v1(219.66,141.88) 219.66,141.82 v2(220.03,141.46) RL19.2
  IN4 w0.102: JLOM1.B1 216.92,137.74 216.92,137.88 218.82,139.78 218.82,140.25 v2(220.03,141.46)
N65846769: length 10.5
  TOP w0.109: v1(219.69,140.43) 219.69,140.15 v2(219.93,139.91) 220.05,139.78 RL20.2
  IN4 w0.102: JLOM1.B3 214.46,136.08 214.62,136.08 214.95,135.75 216.82,135.75 219.93,138.86 v2(219.93,139.91)
N65846785: length 4.7
  TOP w0.109: RL14.2 202.34,133.99 v1(202.34,134.62) 202.28,134.69 JLOM1.A2
N65849361: length 2
  BOTTOM w0.102: RT608.2 51.58,34.38 51.58,34.21 52.01,33.77 52.13,33.77 52.56,33.35 UT5.K11
N65849379: length 2
  BOTTOM w0.102: RT609.2 51.32,34.19 51.93,33.58 52.05,33.58 52.37,33.27 UT5.L11
N65849441: length 3.2
  BOTTOM w0.102: UT5.A10 57.52,32.69 57.62,32.69 58.28,33.35 58.28,34.3 58.32,34.34 58.32,35.06 RT606.1
N65849459: length 2.9
  BOTTOM w0.102: RT607.1 58.09,35.02 58.09,33.43 57.54,32.88 57.52,32.88 UT5.A11
N65849624: length 22.8
  TOP w0.109: v1(65.67,22.28) 65.39,22.56 RT589.1 65.69,23.4 66.08,23.79 66.79,23.79 68.12,25.12 v2(68.12,25.38)
  IN3 w0.081: v2(68.12,25.38) 67.73,25.77 66.03,25.77 65.95,25.7 64.78,25.7 64.57,25.48 58.87,25.48 58.21,26.14 58.21,26.87 57.77,27.31 57.77,27.46 57.43,27.8 57.43,31.16 v2(57.95,31.68)
  BOTTOM w0.076: UT5.B8 57.12,31.29 57.52,31.29 57.65,31.42
  BOTTOM w0.109: v2(57.95,31.68) 57.91,31.68 57.65,31.42
N65849626: length 3.5
  BOTTOM w0.076: 58.24,32.9 58.1,32.9 57.48,32.29 57.12,32.29 UT5.B9
  BOTTOM w0.109: RT590.1 59.5,33.79 58.96,33.24 v1(58.78,33.24) 58.57,33.24 58.24,32.9
N65849665: length 21.9
  IN4 w0.102: v2(40.73,33.08) 40.73,31.91 41.19,31.45 43.37,31.45 44.13,32.21 47.73,32.21 v2(47.8,32.27)
  BOTTOM w0.109: v2(47.8,32.27) 47.8,31.71 47.54,31.45 UT9.2 ; UT10.4 43.37,25.35 42.51,24.49 41.86,24.49 41.62,24.73 41.62,26.69 41,27.32 v1(41,27.74) 41,28.26 40.47,28.8 40.47,32.43 40.63,32.59 40.63,32.99 v2(40.73,33.08)
N65849719: length 4
  BOTTOM w0.109: UT9.5 46.13,29.31 46.24,29.2 47.75,29.2 48.37,28.58 CT377.1 48.59,27.96 v1(48.9,27.65)
N65849795: length 2.3
  TOP w0.109: RT588.2 70.04,23.49 v1(69.47,23.49) 68.68,23.49 QT9.1
N65849809: length 3.1
  BOTTOM w0.109: QT8.1 70.27,22.67 RT586.2 69.45,22.24 v1(68.87,21.67)
N65849918: length 5.2
  BOTTOM w0.109: RT571.2 42.85,28.6 42.08,28.6 41.73,28.95 41.73,30.95 v1(41.84,31.06) 42.23,31.45 UT9.12
N65849972: length 2.3
  BOTTOM w0.109: CT378.2 43.93,28.76 43.65,29.04 43.65,29.79 43.21,30.23 UT9.10
N65850130: length 1.3
  BOTTOM w0.109: UT9.9 44.13,29.09 44.53,28.69 RT573.2
N65850368: length 4
  TOP w0.109: v3(72.87,27.33) 73.78,26.43 RT565.2
  TOP w0.381: QT6.1 71.89,25.93 RT565.2
N65850372: length 2.8
  TOP w0.109: QT7.1 45.34,39.87 45.09,40.12 RT566.2 v1(45.09,42.13)
N65850533: length 2.5
  BOTTOM w0.076: UT5.A8 57.37,31.6 57.89,32.12 57.89,32.2 58.2,32.51
  BOTTOM w0.109: RT580.1 58.97,32.25 58.71,32.51 58.2,32.51
N65850562: length 2.7
  BOTTOM w0.076: UT5.A9 57.47,32.04 58.13,32.69 58.36,32.69 58.42,32.76
  BOTTOM w0.109: RT579.1 59.36,32.92 58.58,32.92 58.42,32.76
N65850646: length 2.1
  BOTTOM w0.109: UT12.4 61.92,24.95 61.85,24.88 61.67,24.88 61.4,24.62 UT11.2
N65850648: length 5.2
  BOTTOM w0.109: UT11.5 60.06,22.69 60.5,22.25 60.5,21.82 60.17,21.48 60.17,20.82 CT379.1 60.48,20.81 60.66,20.99 60.66,21.43 60.89,21.66 60.89,22.12 61.19,22.42 v1(61.57,22.42)
N65850674: length 5.6
  BOTTOM w0.109: UT11.12 56.25,24.62 55.89,24.25 55.89,23.05 57.96,20.97 RT575.2
N65850690: length 3.8
  BOTTOM w0.109: UT11.10 56.69,22.91 58.82,20.78 CT380.2
N65850724: length 3
  BOTTOM w0.109: UT11.9 57.61,22.33 58.17,21.77 58.4,21.77 v1(58.52,21.65) 58.52,21.57 58.88,21.21 59.25,21.21 59.45,21.01 RT577.2
N65851353: length 2.5
  TOP w0.109: RT581.2 52.95,34.97 52.95,34.28 52.95,34.28 v2(52.95,34.26)
  BOTTOM w0.109: UT5.J11 53.37,33.23 52.74,33.85 52.74,34.05 v2(52.95,34.26)
N65851357: length 2.4
  TOP w0.109: RT582.2 53.22,35.01 53.22,34.68 v2(53.58,34.32)
  BOTTOM w0.109: v2(53.58,34.32) 53.87,34.03 UT5.H11
N65851472: length 10.7
  IN1 w0.102: v2(57.6,34.68) 58.35,35.42 58.35,37.44 58.66,37.76 v2(59.26,37.76)
  BOTTOM w0.076: v2(57.6,34.68) 57.6,33.9 57.11,33.42 57.11,32.78 UT5.B10
  BOTTOM w0.109: v2(59.26,37.76) v1(59.26,36.8) 59.26,35.96 58.86,35.56 58.86,35.19 59.07,34.98 59.77,34.98 59.77,34.98 CT348.2
