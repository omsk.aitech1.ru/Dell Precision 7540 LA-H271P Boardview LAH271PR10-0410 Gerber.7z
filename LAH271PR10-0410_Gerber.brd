# Allegro board LAH271PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SD_1_CMD_R: length 2.6
  BOTTOM w0.109: RR230.1 19.2,20.43 19.2,19.52 v1(19.32,19.39) 19.89,18.82 UR1.25
SD_1_D0: length 34.2
  TOP w0.109: JSD1.7 31.28,29.84 31.14,29.97 30.76,29.97 30.14,29.35 v2(30.1,29.35)
  IN4 w0.102: v2(11.66,19.03) 11.54,19.03 11.47,19.1 11.47,19.33 11.59,19.45 14.93,19.45 15.63,20.15 15.63,23.12 18.32,25.81 19.09,25.81 19.95,26.67 19.95,28.76 20.88,29.7 26.45,29.7 27.32,28.83 29.16,28.83 29.81,29.48 29.97,29.48 v2(30.1,29.35)
  BOTTOM w0.109: v2(11.66,19.03) 11.48,18.85 11.48,18.13 v1(11.85,17.76) 11.85,15.84 12.1,15.59 12.73,15.59 12.85,15.71 12.85,15.87 RR234.1
SD_1_D0_R: length 5.9
  BOTTOM w0.109: UR1.22 18.63,16.62 18.55,16.69 17.55,16.69 17.19,16.33 17.18,16.33 16.45,16.33 16.32,16.2 v1(15.62,16.2) 14.42,16.2 14.06,15.83 13.81,15.83 RR234.2
SD_1_D1: length 34.3
  TOP w0.109: JSD1.8 30.66,30.6 30.12,30.07 v2(30.1,30.07)
  IN4 w0.102: v2(10.91,19.02) 10.91,19.03 10.91,19.56 11.36,20.01 14.69,20.01 15.07,20.38 15.07,23.35 18.09,26.37 18.86,26.37 19.39,26.9 19.39,28.99 20.65,30.26 26.68,30.26 27.55,29.39 28.93,29.39 29.58,30.04 30.07,30.04 v2(30.1,30.07)
  BOTTOM w0.109: RR233.1 11.88,15.07 11.42,15.53 v1(11.42,16.48) 11.42,17.46 10.96,17.92 10.96,18.97 v2(10.91,19.02)
SD_1_D1_R: length 5.9
  BOTTOM w0.109: RR233.2 13.84,15.31 14.27,15.31 v1(14.51,15.56) 14.55,15.59 14.64,15.68 16.53,15.68 16.66,15.82 17.38,15.82 17.74,16.18 18.58,16.18 18.62,16.22 UR1.21
SD_1_D2: length 1.4
  TOP w0.109: v2(31.19,11.86) 31.28,11.94 JSD1.9
  BOTTOM w0.109: v2(31.19,11.86) 31.25,11.91 RR228.2
SD_1_D2_R: length 39
  IN1 w0.102: v2(30.19,13.61) 27.48,13.61 27.31,13.78 27.05,13.78 26.13,12.86 25.87,12.86 25.69,13.04 25.69,13.28 26.62,14.21 26.62,14.46 26.44,14.64 26.19,14.64 25.06,13.51 24.8,13.51 24.63,13.69 24.63,13.94 25.76,15.07 25.76,15.33 25.04,16.05 23.73,16.05 21.39,13.71 18.86,13.71 18.58,13.99 18.58,14.72 16.69,16.61 16.69,20.95 17.04,21.31 v2(17.04,22.94)
  BOTTOM w0.109: v2(17.04,22.94) 17.35,23.25 v1(18.04,23.25) 18.25,23.03 19.31,23.03 20.59,21.75 20.59,19.77 20.69,19.66 UR1.27 ; RR228.1 31.05,13.61 v2(30.19,13.61)
SD_1_D3: length 37.5
  TOP w0.109: v2(30.36,14.69) 30.36,14.33 30.59,14.1 JSD1.1
  IN1 w0.102: v2(30.36,14.69) 30.09,14.95 28.47,14.95 28.29,14.77 28.29,14.47 28.12,14.29 27.86,14.29 27.68,14.47 27.68,14.77 27.51,14.95 27,14.95 25.83,16.11 25.83,18.85 25.65,19.04 25.36,19.04 25.12,18.8 25.12,17.16 24.62,16.66 22.24,16.66 20.36,14.77 19.86,14.77 19.29,15.34 19.29,15.67 20.06,16.44 20.06,16.71 19.68,17.09 19.43,17.09 18.44,16.1 18.18,16.1 18,16.28 18,16.52 19.3,17.83 19.3,18.23 19.12,18.41 17.51,18.41 17.35,18.57 17.35,18.82 17.54,19.02 19.12,19.02 19.3,19.19 19.3,20.59 19.12,20.77 18.03,20.77 17.87,20.93 17.87,21.18 18.06,21.38 19.12,21.38 19.65,21.9 v2(19.65,22.15)
  BOTTOM w0.109: v2(19.65,22.15) 19.65,21.78 RR229.2
SD_1_D3_R: length 2.5
  BOTTOM w0.109: UR1.26 20.29,19.19 19.85,19.63 19.85,20.29 RR229.1
SD_1_N0: length 40.2
  TOP w0.109: v2(13.89,14.05) 13.75,14.2 13.75,16.45 12.78,17.42 11.09,17.42 10.91,17.59 10.91,17.89 JSD1.12
  IN4 w0.102: v2(13.89,14.05) 13.89,13.53 14.08,13.35 15.37,13.35 15.83,13.8 15.83,15.69 17.76,17.62 19.39,17.62 20.5,16.5 20.5,15.55 19.29,14.34 19.29,11.75 19.55,11.49 20.68,11.49 21.05,11.85 21.05,13.69 21.88,14.51 25.8,14.51 26.09,14.8 26.09,17.64 25.81,17.92 23.64,17.92 23.15,18.4 23.15,19.4 v2(23.1,19.45)
  BOTTOM w0.109: UR1.32 22.69,18.79 22.79,18.89 22.79,19.28 22.96,19.45 v2(23.1,19.45)
SD_1_N1: length 40.2
  TOP w0.109: v2(9.34,24.59) 9.55,24.81 11.04,24.81 11.2,24.65 JSD1.15
  IN4 w0.102: v2(21.67,19.46) 20.15,19.46 19.13,18.44 17.64,18.44 14.94,15.74 13.78,15.74 13.25,16.27 13.25,17.83 12.95,18.13 12.45,18.13 12.17,17.84 12.17,17.11 11.61,16.55 10.71,16.55 10.21,17.05 9.17,17.05 8.71,17.51 8.71,19.85 10.04,21.18 11.52,21.18 12.34,22 13.66,22 13.83,22.17 13.83,22.87 13.66,23.03 12.24,23.03 11.74,23.53 11.74,24.24 12.75,25.26 12.75,25.77 12.51,26.02 10.88,26.02 10.6,25.74 10.6,25.18 10.09,24.67 9.41,24.67 v2(9.34,24.59)
  BOTTOM w0.109: UR1.29 21.49,19.28 v2(21.67,19.46)
SD_1_P0: length 40.2
  TOP w0.109: JSD1.11 11.96,16.67 12.19,16.9 12.57,16.9 13.23,16.24 v2(13.23,14.05)
  IN4 w0.102: v2(23.71,19.45) 23.71,19.44 23.71,18.63 23.87,18.48 26.05,18.48 26.65,17.88 26.65,14.57 26.03,13.96 22.11,13.96 21.6,13.45 21.6,11.62 20.91,10.93 19.32,10.93 18.73,11.51 18.73,14.57 19.94,15.78 19.94,16.27 19.15,17.06 18,17.06 16.39,15.45 16.39,13.57 15.61,12.79 13.85,12.79 13.34,13.3 13.34,13.95 v2(13.23,14.05)
  BOTTOM w0.109: v2(23.71,19.45) 23.09,18.82 UR1.33
SD_1_P1: length 40.3
  TOP w0.109: v2(9.34,25.25) 9.4,25.32 10.84,25.32 JSD1.16
  IN4 w0.102: v2(9.34,25.25) 9.36,25.23 9.85,25.23 10.04,25.42 10.04,25.98 10.65,26.58 12.74,26.58 13.31,26 13.31,25.03 12.3,24.01 12.3,23.77 12.47,23.59 13.89,23.59 14.39,23.1 14.39,21.94 13.89,21.45 12.58,21.45 11.75,20.62 10.27,20.62 9.27,19.62 9.27,17.74 9.4,17.61 10.44,17.61 10.94,17.11 11.38,17.11 11.61,17.34 11.61,18.08 12.22,18.69 13.18,18.69 13.81,18.06 13.81,16.5 14.01,16.3 14.71,16.3 17.4,19 18.9,19 19.93,20.03 v2(21.5,20.03)
  BOTTOM w0.109: v2(21.5,20.03) 21.09,19.62 UR1.28
SD_RCOMP_1P8: length 7.4
  TOP w0.254: v2(175.01,40.81) 174.74,41.08 UH1.BE5
  BOTTOM w0.254: v2(175.01,40.81) 175.01,41.3 174.11,42.2 174.11,43.5 173.15,44.45 172.81,44.45 v1(172.63,44.64) 172,45.26 RH611.2
SD_RCOMP_3P3: length 5.8
  TOP w0.254: UH1.BE4 174.46,41.63 v2(174.14,41.31)
  BOTTOM w0.254: RH610.2 172.2,44.39 172.52,44.07 172.99,44.07 173.65,43.41 v1(173.65,42.84) 173.65,41.96 174.14,41.47 v2(174.14,41.31)
SDVDD1: length 2.2
  BOTTOM w0.203: v2(17.07,14.81) 17.54,14.81 18.15,15.42 UR1.19
  vias: v1(33.11,21.65) v2(29.46,24.7) v2(29.95,25.09)
SDVDD2: length 2.1
  BOTTOM w0.203: UR1.20 17.95,15.82 v1(17.7,15.57) 17.53,15.4 v2(17.08,15.4)
  vias: v2(10.64,21.62) v2(11.31,21.62)
SDWP: length 12.8
  TOP w0.109: v2(31.76,10.82) 31.36,11.23 30.62,11.23 30.16,11.68 30.16,13.03 29.49,13.7 v2(29.49,14.3)
  BOTTOM w0.109: v2(31.76,10.82) 31.63,10.69 QR1.1 31.63,9.15 31.03,8.55 v1(31.03,7.94) ; v2(29.49,14.3) 29.49,14.48 29.29,14.69 26.63,14.69 26.3,15.02 UR1.43
SDWP_Q: length 34.4
  TOP w0.109: JSD1.18 30.65,32.1 27.99,29.44 27.99,26.24 27.68,25.93 27.68,20.91 28.99,19.6 28.99,16.31 28.03,15.35 28.03,14.48 27.55,13.99 26.8,13.99 26.06,13.26 26.06,12.63 26.84,11.85 29.12,11.85 30.36,10.61 31.1,10.61 31.5,10.22 32.43,10.22 32.6,10.04 32.6,8.84 v2(33.06,8.39)
  BOTTOM w0.109: v1(33.06,7.87) v2(33.06,8.39) 33.06,8.64 QR1.3
SIM_DET: length 89.1
  TOP w0.109: v2(329.95,7.89) 329.95,7.35 329.43,6.83 327.42,6.83 326.68,6.09 326.21,6.09 325.96,6.34 323.74,6.34 323.47,6.61 321.34,6.61 320.89,7.06 v2(320.89,7.37)
  IN2 w0.081: v2(329.95,7.89) 329.98,7.86 335.31,7.86 335.97,8.51 v2(337.11,8.51)
  IN3 w0.081: v2(351.64,48.13) 350.58,47.07 345.61,47.07 344.77,46.23 344.77,41.88 345.51,41.14 345.51,40.31 342.19,37 342.19,31.06 341.39,30.26 341.39,20.17 341.21,19.99 341.21,12.61 v2(337.11,8.51) ; v2(320.89,7.37) 320.04,6.52 315.57,6.52 314.12,7.96 313.81,7.96 312.77,9.01 309.83,9.01 308.56,10.28 307.6,10.28 307.32,10.56 306.51,10.56 v2(305.7,11.37)
  BOTTOM w0.109: v1(353.02,48.4) 352.75,48.13 v2(351.64,48.13) 351.64,48.47 352.06,48.88 RZ522.2 ; v2(305.7,11.37) 305.75,11.32 JNGFF2.58
SIM_DET_R: length 4
  BOTTOM w0.109: JSIM1.2 349.75,47.72 RZ522.1 351.14,49.24 351.53,49.62 v1(351.53,50.27)
SIO_EXT_SCI#: length 28.4
  TOP w0.089: v2(178.06,30.25) 178.06,30.51 UH1.AU26
  IN2 w0.081: v2(178.06,30.25) 178.45,30.64 178.45,31.89 177.07,33.28 176.21,33.28 174.55,34.94 171.51,34.94 170.95,34.38 169.51,34.38 167.96,32.84 167.47,32.84 167.2,32.56 167.2,31.78 166.79,31.38 165.27,31.38 164.84,30.94 164.84,30.41 162.81,28.39 v2(162.71,28.39)
  BOTTOM w0.102: v2(178.06,30.25) 178.06,30.38 v1(177.7,30.73) 177.3,30.73 177.15,30.88 175.06,30.88 174.67,31.27 RH339.2
  BOTTOM w0.109: v2(162.71,28.39) 162.38,28.72 RC561.1
SIO_EXT_SMI#: length 4.6
  TOP w0.102: UH1.AL47 181.56,20.6 181.8,20.36 181.8,20.07 181.8,20.06 181.8,18.1 v1(182.36,17.55) 182.66,17.24
  TOP w0.109: RH310.2 182.73,17.18 182.66,17.24
SIO_EXT_WAKE#: length 51.8
  TOP w0.102: UH1.AU24 v2(178.36,32.52)
  IN1 w0.102: v2(144.65,26.86) 145.33,27.54 147.6,27.54 148.92,28.86 154.58,28.86 155.06,29.33 156.45,29.33 158.35,31.24 158.35,31.93 159.45,33.03 160.01,33.03 160.31,33.33 161.91,33.33 162.35,33.76 166.04,33.76 166.69,34.41 170.94,34.41 172.18,33.16 177.63,33.16 178.26,32.52 v2(178.36,32.52)
  BOTTOM w0.109: v2(178.36,32.52) 177.95,32.52 177.63,32.84 177.01,32.84 176.84,32.67 176.84,32.21 176.7,32.07 174.03,32.07 173.71,32.39 172.71,32.39 172.51,32.19 172.51,31.28 172.13,30.9 RH309.2 ; v2(144.65,26.86) v1(144.65,24.91) 144.65,23.97 144.29,23.6 143.22,23.6 RE703.1
SIO_PWRBTN#: length 252.8
  TOP w0.089: UH1.BE46 174.28,21.05 v2(174.1,21.35)
  TOP w0.102: UE1.K11 v2(138.33,21.65)
  TOP w0.109: v2(165.18,49.73) 165.18,51.07 v1(165.75,51.64) 165.75,54.88 184.18,73.31 184.18,77.17 185.5,78.49 187.79,78.49 189.18,79.88 191.07,79.88 198.35,87.16 200.09,87.16 200.72,86.53 204.67,86.53 205.37,87.23 206.3,87.23 216.63,76.91 257.78,76.91 265.03,84.16 265.03,92.58 266.43,93.98 v2(266.98,93.98) ; JXDP1.41 283.13,91.25 v2(283.08,91.2)
  IN2 w0.081: v2(150.36,20.91) 150.36,21.35 151.26,22.25 155.06,22.25 155.46,22.65 156.06,22.65 v2(156.1,22.69) 156.12,22.67 156.28,22.67 156.67,22.28 159.32,22.28 159.43,22.16 160.56,22.16 161.4,21.32 164.75,21.32 165.22,20.84 165.86,20.84 166.98,19.72 167.19,19.72 167.55,20.08 167.55,20.24 167.79,20.49 170.64,20.49 171.84,21.69 173.76,21.69 v2(174.1,21.35)
  IN3 w0.081: v2(283.08,91.2) 282.59,91.2 281.44,92.36 281.44,94.52 281.16,94.79 280.35,94.79 279.78,95.36 276.4,95.36 276.13,95.09 273.04,95.09 272.33,95.8 269.96,95.8 267.91,93.76 267.16,93.76 266.98,93.93 v2(266.98,93.98)
  IN4 w0.102: v2(156.1,22.69) 156.1,23.35 156.38,23.63 156.38,24.25 156.03,24.6 153.46,24.6 153.04,25.02 147.88,25.02 146.48,23.63 145.57,23.63 144.84,22.9 142.63,22.9 142.02,22.29 142.02,21.57 141.62,21.18 140.96,21.18 140.49,21.65 v2(138.33,21.65)
  BOTTOM w0.109: RC241.2 279.44,90.48 CC269.1 280.12,91.2 v2(283.08,91.2) ; v2(150.36,20.91) 150.64,21.19 150.64,22.16 150.13,22.67 150.13,32.09 158.71,40.67 158.71,43.87 163.46,48.63 164.62,48.63 165.18,49.18 v2(165.18,49.73)
SIO_RCIN#: length 5.7
  TOP w0.102: UH1.BE39 174.64,24.64 174.58,24.7 174.12,24.7 172.91,24.7 172.6,24.4 169.49,24.4 T317.1
SIO_SLP_A#: length 201.1
  TOP w0.102: v2(166.91,23.3) 167.01,23.4 v1(167.44,23.4) 169.24,23.4 169.67,23.83 172.85,23.83 173.15,24.13 174.1,24.13 174.19,24.04 174.5,24.04 174.58,24.12 UH1.BE40
  TOP w0.109: v2(15.93,3.53) 15.86,3.6 JAPS1.6
  IN2 w0.081: v2(166.91,23.3) 166.91,23.59 164.71,25.79 161.86,25.79 161.11,25.05 160.4,25.05 160.29,24.93 159.02,24.93 158.81,24.72 154.15,24.72 152.98,23.55 150.24,23.55 145.41,18.72 142.95,18.72 v2(142.43,18.2)
  IN3 w0.081: v2(142.43,18.2) 142.43,17.95 141.18,16.7 141.18,14.71 140.71,14.23 140.71,10.32 141.85,9.17 141.85,8.31 141.35,7.81 140.93,7.81 139.74,9.01 137,9.01 136.85,8.86 135.52,8.86 134.22,7.56 129.91,7.56 128.85,6.49 127.93,6.49 127.45,6.98 127.1,6.98 125.46,8.61 121.42,8.61 120.64,9.39 115.79,9.39 115.19,8.78 110.11,8.78 107.85,11.04 96.51,11.04 94.56,9.1 94.56,8.15 94.21,7.8 93.81,7.8 93.14,7.13 92.32,7.13 91.56,6.37 83.82,6.37 83.27,5.81 83.27,4.28 82.18,3.19 81.1,3.19 79.66,4.63 75.26,4.63 72.92,6.96 70.47,6.96 69.49,6.52 67.1,4.13 67.1,2.38 66.05,1.33 43.5,1.33 42.71,2.13 42.71,4.42 40,7.13 37.05,7.13 36.23,6.31 31.41,6.31 30.41,5.32 26.06,5.32 22.63,1.89 17.57,1.89 v2(15.93,3.53)
  BOTTOM w0.109: v2(142.43,18.2) 142.43,18.28 142.03,18.69 CH343.1 140.62,18.57 RH638.1 139.78,18.74 139.07,18.74 138.77,18.44 RE746.2
SIO_SLP_LAN#: length 186.7
  TOP w0.102: v2(168.47,23.84) 168.64,24.02 172.77,24.02 173.07,24.32 174.18,24.32 174.22,24.28 UH1.BF40
  TOP w0.109: UZ7.3 207.26,126.41 R128.1 208.04,125.63 CH346.1 RH631.1 208.04,123.84 v1(208.37,123.51) 208.37,121.78 209.46,120.69 209.46,116.85 207.02,114.41 202.87,114.41 201.57,113.11 198.82,113.11 196.08,110.37 196.08,109.85 193.1,106.87 189.87,106.87 v2(189.43,107.32) ; RE743.2 145.09,24.52 145.44,24.87 v2(147.07,24.87) ; v2(168.47,23.84) 168.25,23.63 167.71,23.63 167.39,23.94 166.83,23.94 166.45,23.56 166.45,23.11 165.75,22.41 RH204.1
  IN1 w0.102: v2(168.47,23.84) 168.47,24.04 167.49,25.02 165.28,25.02 164.67,25.63 162.19,25.63 161.6,25.04 160.71,25.04 160.48,24.81 159.24,24.81 158.24,25.8 156.58,25.8 156.14,25.36 148.17,25.36 147.69,24.88 147.08,24.88 v2(147.07,24.87)
  IN3 w0.081: v2(158.51,49.77) 158.77,49.5 160.33,49.5 181.16,70.33 181.16,74.63 180.05,75.74 180.05,78.16 182.86,80.98 183.61,80.98 185.62,82.98 185.62,84.35 187.05,85.79 187.05,88.56 187.9,89.4 187.9,94.83 188.47,95.41 188.47,106.36 v2(189.43,107.32) ; v2(168.47,23.84) 168.3,24.01 168.3,27.26 167.05,28.5 163.83,28.5 161.69,30.64 161.69,32.52 159.7,34.51 159.7,39.51 158.41,40.8 158.41,41.73 157.77,42.38 154.56,42.38 152.82,44.11 v2(152.19,44.11)
  BOTTOM w0.109: v2(158.51,49.77) 158.51,49.1 157.72,48.32 157.72,46.64 155.25,44.16 152.24,44.16 v2(152.19,44.11)
SIO_SLP_S0#: length 295.4
  TOP w0.102: 175.31,29.8 175.27,29.84 174.95,29.84 174.83,29.95 174.06,29.95 173.86,30.15 173.29,30.15 173.18,30.04 170.72,30.04 170.63,29.96 166.25,29.96 v2(165.47,30.74)
  TOP w0.109: v2(20.68,4.44) 20.36,4.77 JAPS1.15 ; v2(118.99,27.61) 119.08,27.52 RZ112.1 ; RZ362.2 RZ363.1 v2(114.25,24.47) 114.03,24.47 v1(113.59,24.03) ; v2(195.6,88.44) 196.58,88.44 RH446.1 ; UH1.BC28 175.31,29.8
  IN1 w0.102: v2(165.47,30.74) 165.47,30.73 165.12,30.73 164.38,29.99 161.6,29.99 160.68,30.9 158.66,30.9 156.63,28.88 155.25,28.88 154.77,28.4 153.32,28.4 152.47,27.55 152.19,27.55 v2(151.77,27.97)
  IN2 w0.081: v2(20.68,4.44) 21.87,5.63 21.87,8.32 22.29,8.74 26.1,8.74 27.72,10.35 34.55,10.35 37.56,13.36 43.77,13.36 44.57,14.16 44.57,15.19 46.74,17.36 48.33,17.36 48.96,16.73 49.84,16.73 50.47,17.36 52.65,17.36 54.83,19.54 57.36,19.54 59.04,21.22 v2(59.04,21.64)
  IN3 w0.081: v2(151.77,27.97) 151.77,31.02 149.52,33.27 145.84,33.27 144.33,34.78 139.26,34.78 137.84,36.19 136.82,36.19 135.16,37.85 128.41,37.85 127.78,37.22 126.88,37.22 124.93,35.27 123.13,35.27 122.14,34.28 120.69,34.28 v2(120.51,34.1) 106.3,34.1 104.55,32.35 101.17,32.35 100.34,33.18 99.58,33.18 98.62,32.21 97.41,32.21 95.06,29.86 88.55,29.86 88.09,29.41 88.09,27.83 88.56,27.36 88.56,26.35 88.15,25.93 88.15,25.21 87.17,24.24 84.86,24.24 82.67,22.04 82.11,22.04 78.7,25.45 71.84,25.45 70.6,24.21 60.83,24.21 59.04,22.42 v2(59.04,21.64)
  IN4 w0.102: v2(166.09,50.6) 166.71,50.6 169.67,53.56 171.45,53.56 174.33,56.44 177.05,56.44 179.16,58.55 v2(179.62,58.55)
  BOTTOM w0.109: v2(179.62,58.55) 179.62,61.7 181.17,63.25 182.99,63.25 186.39,66.65 186.39,70.57 188.35,72.53 188.35,77.33 195.08,84.06 197.25,84.06 198.01,84.82 198.01,87.05 197,88.05 195.98,88.05 v2(195.6,88.44) ; v2(166.09,50.6) 166.09,49.31 164.82,48.04 163.75,48.04 159.28,43.57 159.28,40.38 153.23,34.32 153.23,28.18 153.01,27.97 v2(151.77,27.97) ; v2(114.25,24.47) 116.12,24.47 117.22,25.57 117.22,27.06 117.77,27.61 v2(118.99,27.61) 118.99,29.78 119.63,30.42 119.63,31.53 120.51,32.42 v2(120.51,34.1)
SIO_SLP_S3#: length 291.1
  TOP w0.109: v2(36.5,50.32) 36.43,50.25 36.43,49.05 RT593.1 37.21,48.26 37.21,44.13 36.86,43.77 v2(36.58,43.77) ; JAPS1.2 13.86,6.4 11.9,8.36 6.1,8.36 3.69,10.78 3.69,20.15 8.16,24.62 8.16,25.98 8.55,26.38 14.1,26.38 v2(14.74,25.74) ; UE3.2 160.54,18.47 160.69,18.62 160.69,18.69 160.7,18.7 RE280.1 160.7,18.7 160.7,18.73 160.26,19.17 160.26,20.03 159.84,20.46 159.84,21.44 160.27,21.87 ; 160.27,21.87 159.99,22.15 159.99,23.14 159.12,24.01 158.3,24.01 157.9,24.4 157.46,24.4 156.82,25.03 QE11.2 155.86,25.03 155.36,25.53 154.87,25.53 154.52,25.87 154.52,26.51 154.98,26.97 154.98,32.35 154.66,32.67 CH341.1 RH634.1 154.66,34.39 v1(154.47,34.58) 154.17,34.88 152.49,34.88 151.89,34.28 151.89,33.06 151.5,32.68 148.06,32.68 145.37,29.98 144.33,29.98 v2(143.92,29.56) ; 160.27,21.87 UE5.1 161.53,21.87 162.17,21.23 164.02,21.23 164.28,20.97 164.96,20.97 165.53,20.4 166.27,20.4 166.98,19.7 167.36,19.7 168.53,20.87 169.66,20.87 169.8,21.01 169.8,21.39 170.91,22.5 173.47,22.5 173.92,22.94 UH1.BF42
  IN3 w0.081: v2(14.74,25.74) 16.18,25.74 20.7,30.26 23.84,30.26 25.24,31.66 38.84,31.66 39.47,32.29 40.07,32.29 40.3,32.52 40.3,32.99 40.14,33.15 40.14,34 ; 40.14,34 41.17,34 41.65,33.53 42.73,33.53 43.07,33.19 43.07,32.77 44.56,31.29 44.56,28.38 45.46,27.47 45.46,25.22 46.34,24.35 46.34,22.77 46.86,22.25 48.15,22.25 49.01,21.39 49.01,19.67 50.27,18.41 50.27,15.41 49.73,14.88 49.73,13.29 50.37,12.65 52.57,12.65 53.17,13.25 53.17,19.91 55.09,21.84 56.77,21.84 57.71,20.9 61.62,20.9 62.23,21.5 62.23,22 62.47,22.24 62.6,22.24 63.23,22.88 63.23,23.03 63.58,23.38 71.07,23.38 72.45,24.75 78.51,24.75 81.88,21.39 83.09,21.39 83.66,21.96 89.53,21.96 89.85,22.28 92.98,22.28 94.17,21.09 98.43,21.09 98.99,20.53 100.7,20.53 101.41,21.25 101.41,22.83 102,23.42 104.93,23.42 106.36,24.86 106.36,25.22 108.83,27.69 108.83,28.72 109.94,29.82 111.07,29.82 111.7,29.19 118.9,29.19 120.92,31.21 125.27,31.21 125.48,30.99 126.61,30.99 127.55,31.94 128.98,31.94 129.54,31.38 130.65,31.38 130.88,31.61 131.77,31.61 132.11,31.94 134.75,31.94 137.42,29.27 139.96,29.27 140.38,29.69 141.55,29.69 142.69,28.55 143.18,28.55 143.92,29.29 v2(143.92,29.56) ; 40.14,34 40.14,34.42 39.24,35.33 39.24,36.62 37.67,38.19 37.67,40.44 37.04,41.06 36.42,41.06 36.09,41.39 36.09,43.29 v2(36.58,43.77)
  BOTTOM w0.102: UT1.U1 33.07,43.88 33.07,45.01 32.97,45.11 32.97,45.56 34.08,46.66 34.54,46.66 35.37,47.49 35.88,47.49 36.43,48.04
  BOTTOM w0.109: 36.43,48.04 36.43,50.25 v2(36.5,50.32)
SIO_SLP_S4#: length 502
  TOP w0.109: JAPS1.5 15.36,4.7 v2(14.65,3.99) ; v2(170.89,21.9) 171.25,22.26 173.85,22.26 174.49,22.91 UH1.BE42 ; PR401.2 280.77,47.67 280.44,48 280.44,50.2 281.43,51.18 v2(282.37,51.18) ; v2(197.35,11.48) 197.96,12.09 PR208.1 ; v2(189.89,91.43) 190.06,91.27 UZ21.4 ; UZ34.2 279.49,84.33 CH342.1 279.43,84.4 RH635.1 279.19,85.35 279.19,86.51 278.26,87.44 v2(277.71,87.44) ; v2(152.17,22.78) v1(151.44,22.78) 151.24,22.78 150.88,23.14 147.97,23.14 v2(146.66,24.46)
  IN1 w0.102: v2(189.89,91.43) 190.69,92.23 193.13,92.23 193.4,91.97 v2(193.4,90.14) ; v2(197.35,11.48) 197.35,11.88 195.94,13.3 194.54,13.3 v2(189.91,17.92)
  IN2 w0.081: v2(138.41,18.79) 139.06,19.44 139.56,19.44 139.92,19.79 139.92,21.49 140.35,21.92 140.39,21.96 140.73,21.96 140.91,22.15 141.04,22.15 141.76,22.86 144.68,22.86 145.52,23.7 145.52,23.86 146.11,24.46 v2(146.66,24.46) ; 180.5,24.17 180.37,24.31 179.58,24.31 178.48,23.22 178.48,22.37 178.15,22.04 178.15,21.41 177.62,20.87 177.02,20.87 176.7,21.19 176.43,21.19 175.9,21.72 175.73,21.72 174.99,22.46 171.86,22.46 171.3,21.9 v2(170.89,21.9) 170.12,21.9 169.02,20.8 167.52,20.8 166.96,21.35 165.41,21.35 164.96,21.81 163.18,21.81 162.54,22.45 161.16,22.45 161.08,22.37 159.66,22.37 159.42,22.6 156.82,22.6 156.25,23.17 154.52,23.17 154.06,22.71 152.25,22.71 v2(152.17,22.78) ; 180.5,24.17 180.72,24.38 181.27,24.38 181.61,24.72 181.61,31.99 181.83,32.21 181.83,36.21 182.02,36.4 182.02,37.51 183.06,38.55 183.06,39.77 182.34,40.49 182.34,41.03 182.65,41.34 182.65,43.14 185.73,46.22 185.73,46.68 186.77,47.72 186.77,53.15 188.42,54.8 195.34,54.8 197.09,56.56 197.09,58.54 196.82,58.81 196.82,59.16 197.73,60.07 197.73,60.85 198,61.12 198,66.18 198.28,66.46 198.28,74.19 199.11,75.02 199.11,75.72 198.39,76.44 198.39,79.62 194.5,83.51 194.5,87.96 193.4,89.07 v2(193.4,90.14) ; 180.5,24.17 180.52,24.15 180.52,24.03 180.21,23.72 180.21,23.36 179.69,22.83 179.69,22.19 180.71,21.17 182.06,21.17 182.59,21.7 182.59,22.22 182.84,22.48 183.77,22.48 186.5,19.74 186.92,19.74 188.32,18.34 189.49,18.34 v2(189.91,17.92)
  IN3 w0.081: v2(138.41,18.79) 138.61,18.58 138.61,13.05 138.04,12.48 138.04,11.84 137.3,11.1 137.3,10.86 136.3,9.86 135.2,9.86 134.8,9.46 130.64,9.46 128.99,7.81 127.35,7.81 125.83,9.32 122.17,9.32 120.83,10.66 119.5,10.66 119.06,10.22 111.23,10.22 109.74,11.71 96.29,11.71 93.32,8.75 93.32,8.2 92.88,7.76 92.04,7.76 91.27,6.99 83.33,6.99 82.89,6.56 81.5,6.56 80.23,5.29 75.53,5.29 73.2,7.63 70.38,7.63 69.3,7.27 67.62,5.59 66.78,5.59 66.27,5.09 66.27,4.55 65.15,3.43 65.15,2.77 63.91,1.54 43.59,1.54 42.92,2.21 42.92,4.51 40.09,7.34 36.96,7.34 36.15,6.52 31.32,6.52 30.32,5.52 25.97,5.52 22.55,2.1 18.03,2.1 16.14,3.99 v2(14.65,3.99)
  IN4 w0.102: v2(289.66,71.13) 289.66,73.59 287.2,76.05 283.52,76.05 281.99,77.58 281.99,78.86 281.69,79.16 281.69,80.22 281.46,80.45 281.46,82.49 281,82.95 281,83.68 279.2,85.48 279.2,86.58 278.34,87.44 v2(277.71,87.44)
  BOTTOM w0.109: v2(193.4,90.14) 195.19,90.14 196.42,88.91 198.09,88.91 199.23,87.77 199.23,84.75 199.36,84.62 204.97,84.62 212.42,77.17 258.05,77.17 258.63,76.59 272.63,76.59 276.42,80.38 277.44,80.38 278.24,81.19 278.24,81.78 277.71,82.31 277.71,83.52 277.97,83.78 277.97,84.25 277.1,85.12 277.1,86.83 v2(277.71,87.44) ; v2(282.37,51.18) 282.37,53.28 283.69,54.6 290.91,54.6 294.27,51.24 294.27,50.11 294.79,49.58 295.14,49.58 295.82,50.27 295.82,55.87 296.92,56.98 296.92,59.9 289.07,67.76 289.07,70.53 v2(289.66,71.13)
SIO_SLP_S5#: length 199.6
  TOP w0.102: UH1.BC42 175.29,23.21 175.27,23.24 174.99,23.24 174.86,23.36 174.06,23.36 173.88,23.54 173.38,23.54 173.09,23.25 170.26,23.25 169.94,22.92 169.94,22.37 169.7,22.13 v2(169.36,22.13)
  TOP w0.109: v2(14.65,4.65) 14.86,4.86 JAPS1.4
  IN3 w0.081: v2(14.65,4.65) 15.77,4.65 18.12,2.3 22.46,2.3 25.89,5.73 29.02,5.73 30.27,6.98 35.96,6.98 36.53,7.55 40.53,7.55 41.94,6.13 43.25,6.13 44.45,4.93 50.21,4.93 51.36,3.79 55.6,3.79 57.25,2.14 62.92,2.14 64.47,3.69 64.76,3.69 65.46,4.38 65.46,4.7 65.22,4.95 65.22,6.2 65.91,6.89 65.91,8.3 66.07,8.46 66.07,9.09 66.63,9.66 66.8,9.66 67.5,10.35 69.83,10.35 70.88,11.4 76.02,11.4 76.95,10.47 76.95,7.71 78.04,6.62 79.68,6.62 80.46,7.4 80.46,8.31 80.66,8.51 80.66,10.22 81.75,11.32 88.15,11.32 89.04,12.21 92.96,12.21 95.43,14.67 104.24,14.67 104.53,14.96 112.27,14.96 113.19,14.05 119.3,14.05 119.55,14.3 125.12,14.3 127.31,16.5 129.88,16.5 130.53,17.15 131.52,17.15 132.54,18.17 132.54,18.56 132.39,18.71 132.39,19.21 132.81,19.63 133.76,19.63 134.25,19.14 134.25,18.75 133.88,18.37 v2(133.88,17.97) ; v2(160.25,21.03) 161.33,21.03 161.77,21.48 162.96,21.48 164.06,22.58 164.06,22.81 164.8,23.55 165.98,23.55 166.64,22.89 168.77,22.89 169.03,22.64 169.03,22.47 v2(169.36,22.13)
  IN4 w0.102: v2(160.25,21.03) 159.77,20.56 157.85,20.56 157.59,20.3 155.97,20.3 153.97,22.31 153.46,22.31 152.4,23.36 148.66,23.36 145.51,20.21 145.51,19.71 143.37,17.57 141.25,17.57 139.89,18.93 139.12,18.93 137.55,17.36 134.49,17.36 v2(133.88,17.97)
  BOTTOM w0.109: v1(159.95,21.56) 160.25,21.26 v2(160.25,21.03) ; v2(133.88,17.97) 134.36,17.97 134.99,17.34 134.99,17.1 RH632.1 135.27,16.82 CH347.1
SIO_SLP_SUS#: length 56.2
  TOP w0.102: UH1.BD39 175.01,24.39 174.62,24.39 174.5,24.51 174.2,24.51 174.2,24.51 172.98,24.51 172.68,24.21 168.05,24.21 v2(167.89,24.05)
  TOP w0.109: RE349.1 132.81,15.92 132.81,15.31 133.54,14.57 v2(133.54,14.34) ; v2(167.89,24.05) 167.78,24.16 166.42,24.16 RH441.1
  IN2 w0.081: v2(167.89,24.05) 167.89,23.7 167.07,22.88 166.73,22.88 165.19,24.42 164.43,24.42 163.28,25.57 161.95,25.57 161.2,24.82 160.5,24.82 160.37,24.69 159.1,24.69 158.91,24.49 154.25,24.49 153.06,23.31 150.33,23.31 145.48,18.46 144.38,18.46 143.08,17.17 142.3,17.17 139.51,14.38 137.16,14.38 137.11,14.32 135.61,14.32 135.24,14.69 133.89,14.69 v2(133.54,14.34)
  BOTTOM w0.109: RH639.1 134.2,13.25 CH345.1 133.54,13.91 v2(133.54,14.34) ; v2(167.89,24.05) 167.73,24.05 v1(167.32,23.64)
SIO_SLP_SUS#_R: length 3.9
  TOP w0.109: UE1.N4 130.9,18.22 130.9,17.87 RE561.1 132.24,17.4 RE349.2
SIO_SLP_WLAN#: length 70.9
  TOP w0.102: UH1.BD42 174.97,22.99 174.92,23.04 174.79,23.17 173.98,23.17 173.8,23.35 173.48,23.35 173.18,23.06 170.37,23.06 170.15,22.83 170.15,22.31 169.56,21.72 169.02,21.72 168.85,21.9 168.85,22.19 v2(168.54,22.49)
  TOP w0.109: v2(153.54,36.13) 153.48,36.07 CH344.1 RH629.1 150.78,35.02 149.13,35.02 148.92,34.81 148.92,34.36 147,32.44 v3(146.84,32.44) 145.15,32.44 RE569.1 144.37,33.21 142.01,33.21 140.43,34.79 QZ15.1 ; v2(160.83,47.08) 160.33,46.59 160.33,33.87 160.47,33.74 160.91,33.74 161.36,34.19 162.16,34.19 163.45,32.9 v2(164.48,32.9)
  IN4 w0.102: v2(168.54,22.49) 168.9,22.85 168.9,23.98 167.95,24.94 167.95,26.04 168.18,26.28 168.18,26.81 167.55,27.44 167.55,30.56 167.05,31.06 167.05,32.62 166.65,33.01 164.59,33.01 v2(164.48,32.9)
  BOTTOM w0.109: v2(153.54,36.13) 153.75,36.13 158.45,40.83 158.45,44.14 160.83,46.51 v2(160.83,47.08)
SIO_SLP_WLAN#_Q: length 11
  TOP w0.109: v1(132.27,37.44) 132.72,37 134.7,37 RZ1385.2 RZ71.1 136.62,37.02 136.62,36.61 136.96,36.26 137.86,36.26 DZ9.3 139,36.37 139,35 QZ15.3
SKL_CNL#: length 10.4
  TOP w0.102: UC1.BN1 257.15,87.52 257.3,87.37 257.3,87.35 257.64,87.02 257.65,87.02 258.95,85.71 259.49,85.71 259.9,85.31 261.08,85.31 v2(261.58,85.8)
  BOTTOM w0.102: v2(261.58,85.8) 262.29,85.8 263.62,84.47 v1(263.62,84.17) 263.62,82.88 RC171.2
SLEEVE: length 8.9
  TOP w0.203: v2(351.09,22.61) 350.94,22.76 349.52,22.76 348.85,23.43 UA1.31
  TOP w0.381: RA6.2 353.16,23.4 352.37,22.61 v2(351.68,22.61) v2(351.09,22.61)
  IN1 w1.016: 351.17,21.59 351.17,19.28 350.49,18.6
  vias: v1(350.81,18.2) v2(350.82,17.63) v2(350.82,16.99)
SLEEVE_R: length 19.2
  IN2 w1.016: JHP1.4 369.41,12.74 369.41,13.56 366.72,16.25 361.5,16.25 360.09,17.66 355.67,17.66 354.62,16.61 354.6,16.63
  BOTTOM w0.109: v3(352.96,17.04) 353.26,16.73 v2(353.67,16.73)
  vias: v2(353.67,17.34)
SLOT3_DEVSLP: length 130.4
  TOP w0.109: UH1.AH35 182.77,26.61 v2(182.48,26.32) ; v1(160.06,28.13) 160,28.07 v2(160,27.62)
  IN1 w0.102: v2(182.48,26.32) 182.48,26.5 181.7,27.27 181.7,28 181.26,28.45 180.47,28.45 180.42,28.5 177.73,28.5 176.86,27.62 175.43,27.62 174.9,28.16 174.9,28.78 172.28,31.4 170.64,31.4 170.23,30.99 168.35,30.99 167.83,30.48 167.83,28.59 166.68,27.44 163.56,27.44 162.95,26.83 162.2,26.83 160.73,28.3 160.34,28.3 160.02,27.98 160.02,27.64 v2(160,27.62)
  IN2 w0.081: v2(160,27.62) 159.4,27.62 159.08,27.29 157.98,27.29 157.45,26.77 155.14,26.77 154.47,26.09 153.52,26.09 152.5,25.07 149.82,25.07 144.88,20.13 141.5,20.13 140.33,18.97 140.33,18.34 139.64,17.65 138.67,17.65 138.26,17.23 138.25,17.23 137.64,16.62 135.83,16.62 135.58,16.87 133.54,16.87 133.1,17.3 132.54,17.3 132.13,16.89 130.48,16.89 129.75,16.16 126.56,16.16 126.02,15.62 124.27,15.62 123.85,16.05 120.06,16.05 119.2,16.91 119.2,17.33 117.87,18.66 116.8,18.66 116.46,18.32 115.97,18.32 114.96,19.33 113.63,19.33 111.25,21.71 105.88,21.71 105.3,22.29 104.25,22.29 101.14,25.4 101.14,25.69 100.73,26.11 100.37,26.11 99.38,27.09 99.38,27.79 97.25,29.92 97.25,31.5 91.79,36.97 85.71,36.97 85.18,36.44 v2(85.18,36.19)
  BOTTOM w0.109: v2(85.18,36.19) 85.18,38.38 RN37.1 86.42,39.95 JNGFF3.38
SLOT3_SSD_PWR_EN: length 64.6
  TOP w0.102: UE1.G5 v2(132.73,24.85)
  TOP w0.109: UZ9.3 87.68,27.22 87.49,27.42 RZ539.1 86.86,27.49 86.4,27.94 84.8,27.94 v2(84.58,27.73)
  IN3 w0.081: v2(92.25,18.14) 92.25,18.03 93.6,16.68 103.05,16.68 104.99,18.62 111.87,18.62 112.56,19.32 116.12,19.32 117.56,20.76 122.08,20.76 122.85,19.99 124.76,19.99 125.17,20.4 126.54,20.4 127.86,21.72 127.86,23.41 128.19,23.74 128.89,23.74 129.63,24.48 132.36,24.48 v2(132.73,24.85)
  BOTTOM w0.109: v2(92.25,18.14) 91.62,18.14 v1(91.57,18.19) 90.35,19.41 90.35,20.52 89.5,21.37 89.5,22.51 88.02,23.99 87.92,23.99 86.39,25.52 86.39,26.95 85.61,27.73 v2(84.58,27.73)
SLOT4_DEVSLP: length 213.6
  TOP w0.109: v2(179.69,19.85) 179.69,20.39 UH1.AR47 ; v1(351.04,13.68) 350.74,13.68 v2(350.12,13.07) 350.23,12.96 RN202.1
  IN2 w0.081: v2(181.74,13.87) 180.99,14.61 178.27,14.61 177.77,15.11 175.24,15.11 175.02,15.33 175.02,16.08 175.67,16.72 178.47,16.72 179.36,17.62 179.36,18.18 179.06,18.48 179.06,19.22 v2(179.69,19.85) ; v2(216.8,15.07) 216.8,16.59 217.92,17.71 227.62,17.71 228.29,17.04 247.77,17.04 250.11,19.39 263.18,19.39 264.51,18.06 265.95,18.06 267.96,16.05 268.61,16.05 270.04,14.62 273.09,14.62 278.92,8.79 280.8,8.79 281.36,8.24 285.58,8.24 286.74,7.07 286.74,6.36 287.48,5.62 289.89,5.62 290.88,6.61 305.63,6.61 306.79,5.45 308.79,5.45 309.04,5.2 312.94,5.2 313.59,4.54 320.47,4.54 323.78,7.85 324.93,7.85 326.79,9.7 328.35,9.7 329.19,10.54 334.62,10.54 334.81,10.72 337,10.72 337.04,10.76 341.64,10.76 344.2,13.32 344.31,13.32 344.8,13.81 347.45,13.81 348.2,13.07 v2(350.12,13.07)
  IN3 w0.076: JNGFF4.38 353.65,7.68
  IN3 w0.081: v2(216.8,15.07) 216,15.87 198.83,15.87 197.77,14.81 196.33,14.81 196.05,14.53 187.71,14.53 186.91,13.74 181.87,13.74 v2(181.74,13.87) ; v2(350.12,13.07) 350.74,13.68 352.17,13.68 354.09,11.77 354.09,9.43 353.65,9 353.65,7.68
SLOT4_SSD_PWR_EN: length 256.1
  TOP w0.102: UE1.K3 v2(131.13,21.65)
  TOP w0.109: v2(316,2.6) 316.07,2.66 316.07,8.2 316.32,8.45 316.32,9.06 316.56,9.3 317.55,9.3 318.72,8.13 v1(318.9,8.13) 319.18,8.13 319.36,8.31 RZ537.1 319.36,9.76 319.6,10 320.3,10 321.11,10.81 321.11,12.67 320.6,13.17 UZ58.3
  IN2 w0.081: v2(316,2.6) 315.85,2.44 314.17,2.44 312.51,4.1 309.4,4.1 308.2,2.91 306.01,2.91 304.21,4.71 294.91,4.71 294.48,5.14 291.32,5.14 289.93,3.76 286.9,3.76 284.39,6.26 277.93,6.26 273.8,10.39 271.25,10.39 270.27,11.36 269.9,11.36 268.01,13.25 268.01,13.96 265.43,16.54 251.53,16.54 250.1,15.12 241.04,15.12 240.44,15.71 220.45,15.71 219.2,14.46 212.8,14.46 209.32,10.98 209.32,8.99 207.22,6.88 207.22,4.98 206.72,4.48 205.76,4.48 205.25,4.99 197.35,4.99 196.96,4.59 191.37,4.59 190.51,3.73 184.09,3.73 183.26,2.9 179.14,2.9 176.44,5.6 172.73,5.6 170.3,8.03 166.06,8.03 165.32,7.29 161.44,7.29 157.48,11.25 155.63,11.25 154.21,9.82 148.3,9.82 145.74,7.27 144.56,7.27 143.35,6.05 141,6.05 140.56,5.61 139.4,5.61 138.86,5.07 137.76,5.07 137.12,4.43 137.12,3.39 135.69,1.96 130.66,1.96 130.32,2.31 130.32,4.44 129.51,5.25 127.96,5.25 126.42,6.79 125.74,6.79 125.53,6.59 125.12,6.59 v2(125.06,6.64)
  BOTTOM w0.109: v2(125.06,6.64) 125.45,7.03 125.45,7.96 130.47,12.98 130.47,14.8 129.99,15.28 129.99,17.19 130.35,17.55 130.35,18.15 130.14,18.36 130.14,19.55 130.63,20.05 130.63,21.15 v2(131.13,21.65)
SLOT5_SSD_PWR_EN: length 107
  TOP w0.109: v2(44.42,27.21) 44.58,27.21 45.19,27.82 v1(45.6,27.82) 45.67,27.74 47.95,27.74 v2(48.54,27.15) ; UZ9.5 87.76,26.42 87.7,26.36 87.22,26.36 87.11,26.47 RZ538.1 86.85,25.68 v2(86.87,25.66)
  IN3 w0.081: v2(86.87,25.66) 86.87,25.63 86.39,25.15 83.73,25.15 83.19,25.7 82.43,25.7 82.17,25.95 71.72,25.95 70.5,24.73 60.76,24.73 59.56,23.53 56.45,23.53 56.01,23.97 50.38,23.97 49.49,24.86 47.16,24.86 46.35,25.67 46.35,27.21 46.73,27.59 48.1,27.59 v2(48.54,27.15) ; v2(7.95,16) 7.95,16.4 8.57,17.02 8.57,19.15 7.03,20.7 7.03,23.42 7.5,23.89 12.01,23.89 12.92,24.79 15.53,24.79 20.79,30.05 23.92,30.05 25.33,31.45 37.11,31.45 38.84,29.72 40.18,29.72 40.62,30.16 43.19,30.16 43.81,29.54 43.81,27.85 44.42,27.25 v2(44.42,27.21)
  BOTTOM w0.109: UE12.22 v2(7.95,16)
SLP_WLAN#_GATE: length 28.4
  TOP w0.109: RZ375.2 136.69,36.03 137.56,36.03 QZ15.2 137.56,34.86 137.56,33.84 137.81,33.59 141.2,33.59 RE570.1 142.74,32.05 144.23,32.05 144.77,31.51 v2(144.77,30.97)
  BOTTOM w0.109: v2(144.77,30.97) 145.55,30.18 145.55,28.13 146.64,27.05 146.64,26.46 144.99,24.81 144.99,23.63 144.54,23.18 143.68,23.18 143.34,22.84 142.28,22.84 141.98,22.54 141.98,21.33 v1(141.7,21.05) 141.57,20.92 141.57,20.42 141.93,20.05 RE552.2
SLP_WLAN#_GATE_R: length 16.1
  TOP w0.109: UE1.D9 v2(136.73,27.25) ; RE570.2 143.01,32.69 RE569.2 144.07,32.69 v1(145.31,31.45) 145.48,31.28 145.48,30.91 145.1,30.53 144.37,30.53 143.46,31.43 v2(142.21,31.43)
  IN2 w0.081: v2(136.73,27.25) 136.73,27.51 137.15,27.93 137.15,29.57 138.21,30.63 138.52,30.63 139.33,31.43 v2(142.21,31.43)
SMART_SPK_DET0#: length 214.1
  TOP w0.109: v2(177.95,37.57) 178.19,37.33 UH1.AV13 ; v2(329.92,18.65) 329.77,18.8 RA224.2 ; JSPK1.5 331.12,14.97 331.84,14.97 332.21,15.34 v2(332.21,15.43)
  IN1 w0.102: v2(251.06,27.1) 251.06,26.72 252.15,25.64 256.29,25.64 256.5,25.43 257.19,24.73 260.4,24.73 262.84,22.3 273.83,22.3 277.1,25.57 277.1,31.81 280.04,34.74 280.04,36.33 282.17,38.46 290.27,38.46 292.15,40.34 296,40.34 297.89,42.23 306.24,42.23 308.26,40.21 308.26,38.13 312.57,33.82 317.87,33.82 319.17,32.51 319.17,29.96 324.28,24.85 327.27,24.85 330.5,21.62 331.57,21.62 332.07,21.12 v2(332.41,21.12)
  IN2 w0.081: v2(329.92,18.65) 330.51,19.23 330.51,20.02 331.08,20.6 331.89,20.6 v2(332.41,21.12)
  IN3 w0.081: v2(251.06,27.1) 250.69,26.73 250.69,25.86 245.36,20.53 220,20.53 219.57,20.96 219.57,21.48 217.37,23.69 213.25,23.69 210.95,25.98 208.91,25.98 205.3,29.59 201.86,29.59 197.24,34.21 197.24,36.31 195.87,37.67 195.87,40.34 194.9,41.32 194.07,41.32 192.83,42.56 178.96,42.56 177.5,41.1 177.13,41.1 176.67,40.64 176.67,40.03 177.33,39.37 177.33,38.69 177.95,38.07 v2(177.95,37.57) ; v2(332.21,15.43) 332.24,15.45 332.24,15.54 329.92,17.85 v2(329.92,18.65)
SML0_SMBCLK: length 306.8
  TOP w0.102: UH1.BF25 174.03,31.4 173.79,31.16 172.92,31.16 172.86,31.22 170.17,31.22 169.92,30.98 168.41,30.98 168.26,31.12 CC318.1
  TOP w0.109: v2(167.54,31.3) 167.67,31.42 CC318.1
  IN1 w0.102: v2(72.35,44.81) 72.14,44.81 70.67,43.34 67.72,43.34 65.6,41.22 57.08,41.22 56.27,42.03 49.07,42.03 48.68,41.63 48.68,41.07 48.15,40.54 45.46,40.54 44.4,41.61 39.97,41.61 38.28,43.3 38.28,44.54 38.66,44.92 38.66,45.63 38.31,45.98 34.77,45.98 34.44,46.3 34.44,47.08 34.61,47.24 34.61,49.92 v2(34.43,50.09)
  IN3 w0.081: v2(191.11,57.86) 190.76,57.51 186.54,57.51 185.19,58.86 184.12,58.86 181.85,61.13 179.85,61.13 173.85,55.12 172.13,55.12 165.94,48.94 165.94,47.52 163.2,44.77 163.2,42.66 162.66,42.12 162.66,40.16 163.88,38.94 163.88,35.46 164.87,34.47 165.43,34.47 167.02,32.88 167.02,32.08 167.54,31.56 v2(167.54,31.3) 167.2,31.3 166.91,31.58 163.99,31.58 163.5,32.07 163.5,33.38 162.2,34.68 162.2,36.93 162.63,37.36 162.63,38.51 159.5,41.64 159.5,42.32 158.39,43.43 154.93,43.43 153.1,45.26 151.31,45.26 151.02,44.97 142.55,44.97 141.37,46.15 139.12,46.15 138.78,46.49 136.5,46.49 136.38,46.61 130.06,46.61 128.11,44.66 125.02,44.66 123.33,42.97 118.93,42.97 118.34,43.56 117.42,43.56 115.88,45.09 115.88,46.18 114.32,47.75 109.86,47.75 109.13,48.48 96.76,48.48 91.84,43.55 91.84,42.98 90.59,41.73 89.01,41.73 88.86,41.88 84.51,41.88 84.09,42.29 81.27,42.29 80.47,43.09 78.81,43.09 78.36,43.53 76.8,43.53 76.08,44.25 76.08,45.13 75.25,45.96 72.54,45.96 72.24,45.66 72.24,44.93 v2(72.35,44.81) ; v2(194.1,128.62) 194.1,127.51 195.18,126.43 195.18,122.21 195.87,121.52 195.87,114.71 196.2,114.38 196.2,111.8 196,111.59 196,98.51 195.18,97.69 195.18,97.04 197.31,94.9 197.31,92.66 195.81,91.16 195.81,89.42 196.57,88.66 196.57,87.52 195.03,85.98 195.03,82.12 196.37,80.78 196.37,74.91 v2(196,74.54)
  BOTTOM w0.102: RH67.2 167.6,31.35 v2(167.54,31.3)
  BOTTOM w0.109: v2(196,74.54) 195.1,73.64 195.1,64.76 v1(194.95,64.61) 194.74,64.4 194.74,61.1 191.5,57.86 v2(191.11,57.86) ; RT641.1 34.57,49.21 34.57,49.95 v2(34.43,50.09) ; v2(194.1,128.62) 193.42,128.62 193.35,128.54 UL1.28
SML0_SMBDATA: length 306.3
  TOP w0.102: v2(166.6,32.1) 167,32.5 167.5,32.5 167.9,32.9 170.01,32.9 170.74,32.17 174.53,32.17 174.61,32.09 UH1.BE24
  IN1 w0.102: v2(71.83,45.08) 71.84,45.07 71.84,44.83 71.76,44.75 70.57,43.57 67.63,43.57 65.51,41.44 57.18,41.44 56.36,42.26 48.98,42.26 48.45,41.73 48.45,41.17 48.06,40.77 45.56,40.77 44.49,41.84 40.06,41.84 38.51,43.39 38.51,44.44 38.89,44.82 38.89,45.72 38.41,46.21 34.86,46.21 34.67,46.4 34.67,46.98 34.84,47.15 34.84,49.92 v2(35.02,50.09)
  IN3 w0.081: v2(190.36,57.94) 190.16,57.74 186.63,57.74 185.29,59.08 184.22,59.08 181.95,61.36 179.76,61.36 173.75,55.35 172.03,55.35 165.72,49.03 165.72,47.61 162.97,44.87 162.97,44.74 162.96,44.73 162.96,42.71 162.45,42.21 162.45,40.08 163.67,38.86 163.67,35.37 164.78,34.26 165.35,34.26 166.81,32.8 166.81,32.31 v2(166.6,32.1) 166.29,31.79 164.07,31.79 163.71,32.16 163.71,33.47 162.41,34.76 162.41,36.84 162.83,37.27 162.83,38.6 159.7,41.73 159.7,42.41 158.47,43.64 155.02,43.64 153.19,45.47 151.22,45.47 150.93,45.18 142.64,45.18 141.45,46.36 139.21,46.36 138.86,46.7 136.59,46.7 136.47,46.82 129.98,46.82 128.02,44.87 124.94,44.87 123.25,43.18 119.02,43.18 118.43,43.77 117.5,43.77 116.09,45.18 116.09,46.27 114.4,47.96 109.95,47.96 109.22,48.69 96.68,48.69 91.63,43.64 91.63,43.06 90.5,41.94 89.1,41.94 88.95,42.08 84.59,42.08 84.18,42.5 81.36,42.5 80.56,43.3 78.89,43.3 78.45,43.74 76.89,43.74 76.29,44.34 76.29,45.22 75.34,46.17 72.45,46.17 72.03,45.75 72.03,45.27 v2(71.83,45.08) ; v2(193.61,127.23) 194.95,125.9 194.95,122.11 195.4,121.66 195.41,121.66 195.65,121.42 195.65,114.62 195.98,114.29 195.98,111.89 195.77,111.69 195.77,98.61 194.95,97.78 194.95,96.94 197.08,94.81 197.08,92.75 195.58,91.25 195.58,89.33 196.34,88.57 196.34,87.61 194.8,86.07 194.8,82.03 196.13,80.7 196.13,75.36 v2(195.92,75.16)
  BOTTOM w0.109: RT642.1 34.81,49.21 34.81,49.89 v2(35.02,50.09) ; v2(193.61,127.23) 193.51,127.34 UL1.31 ; v2(166.6,32.1) 166.6,33.51 166.83,33.75 RH77.2 ; v2(190.36,57.94) 191.13,58.71 192.02,58.71 194.46,61.15 194.46,64.96 193.76,65.66 193.76,68.02 194.52,68.78 v1(194.52,72.52) 194.52,73.75 v2(195.92,75.16)
SML1_SMBCLK: length 49.3
  TOP w0.102: UE1.D8 v2(135.93,27.25) ; UH1.BF27 174.07,30.21 173.94,30.34 173.2,30.34 173.1,30.24 170.64,30.24 170.62,30.21 170.55,30.15 166.54,30.15 166.09,30.6 v2(166.09,30.75)
  IN1 w0.102: v2(166.09,30.75) 166.09,30.39 165.95,30.25 165.32,30.25 164.58,29.5 161.4,29.5 160.8,30.1 160.01,30.1 159.95,30.04 158.48,30.04 156.83,28.39 155.45,28.39 154.93,27.88 153.49,27.88 152.67,27.06 151.99,27.06 150.68,28.37 149.11,28.37 147.76,27.01 146.58,27.01 145.89,26.32 144.48,26.32 144.38,26.43 143.67,26.43 143.59,26.35 139.83,26.35 139.31,26.87 136.31,26.87 v2(135.93,27.25)
  BOTTOM w0.109: RH80.2 164.62,30.29 165.81,30.29 166.25,29.86 167.27,29.86 167.54,30.13 CC319.1 167.43,30.33 166.38,30.33 166.09,30.63 v2(166.09,30.75)
SML1_SMBDATA: length 45.6
  TOP w0.102: v2(138.33,25.65) UE1.E11 ; UH1.BE27 174.53,30.44 174.11,30.44 174.02,30.53 172.82,30.53 172.72,30.43 170.56,30.43 170.53,30.4 167.05,30.4 166.71,30.74 v2(166.71,30.75)
  IN1 w0.102: v2(138.33,25.65) 138.33,25.67 138.74,26.08 140.84,26.08 141.12,25.79 142.66,25.79 142.84,25.61 144.68,25.61 144.88,25.8 146.05,25.8 146.78,26.53 147.96,26.53 149.31,27.88 150.48,27.88 151.87,26.5 154.24,26.5 155.65,27.91 157.03,27.91 158.65,29.52 159.97,29.52 160.47,29.02 164.98,29.02 165.25,28.76 166.88,28.76 167.35,29.24 167.35,30.11 v2(166.71,30.75)
  BOTTOM w0.102: v2(166.71,30.75) 166.71,31.14 v1(166.52,31.33)
  BOTTOM w0.109: RH81.2 166.14,31.7 v1(166.52,31.33)
SNUB_1.2V: length 3.5
  TOP w0.109: 233.33,10.86 235.98,10.86 v1(236.59,10.25)
SNUB_1V: length 1.3
  TOP w0.109: v1(141.87,12.02) 142.33,11.56 PC808.1
SNUB_3V: length 1.2
  TOP w0.109: v1(103.39,1.66) 103.7,1.96 104.51,1.96
SNUB_5V: length 2.5
  TOP w0.508: PC126.1 67.25,21.49 v1(68.15,21.49) PR112.2
SNUB_5VR: length 5.1
  TOP w0.109: PC512.1 296.37,45.84 v1(295.42,45.84)
  TOP w0.508: PC512.1 298.8,44.25 PR502.2
SNUB_CHG: length 1.7
  TOP w0.109: PR722.2 v1(302.19,10.53)
SNUB_IO:
  vias: v1(277.76,107.18)
SPKR: length 245.4
  TOP w0.089: UH1.AW29 177.53,28.98 v2(177.31,28.76)
  TOP w0.254: v2(271.58,17.99) 270.62,18.95 266.39,18.95 266.16,18.72 262.64,18.72 253.9,9.99 253.9,8.38 253.51,7.99 252.05,7.99 v3(251.72,8.31) v2(248.1,11.93)
  IN1 w0.254: v2(322.7,34.66) 322.7,38.17 317.43,43.44 312.77,43.44 311.98,44.23 311.23,44.23 302.84,52.62 300.91,52.62 299.97,51.69 295.86,51.69 292.27,48.09 291.85,48.09 288.6,44.84 282.62,44.84 274.52,36.74 274.15,36.74 273.33,35.92 273.33,34.54 272.29,33.5 v2(272.29,27.76)
  IN2 w0.254: v2(177.31,28.76) 177.34,28.73 177.34,28.14 176.63,27.43 176.13,27.43 174.73,26.04 168.42,26.04 168.33,25.95 167.5,25.95 167.2,26.26 v2(167.2,26.52)
  IN3 w0.254: v2(272.29,27.76) 272.29,24.59 271.37,23.68 271.37,18.18 271.57,17.99 v2(271.58,17.99)
  IN4 w0.254: v2(248.1,11.93) 245.24,14.79 240.83,14.79 240.13,15.49 231.95,15.49 231.01,16.42 219.74,16.42 217.81,14.49 214.86,14.49 214.45,14.9 214.45,15.54 214.07,15.92 211,15.92 209.86,17.06 203.56,17.06 201.6,19.02 199.54,19.02 199.14,19.43 193.18,19.43 192.57,20.03 183.44,20.03 182.95,20.53 181.05,20.53 179.42,22.15 179.42,23.26 179.06,23.63 178.55,23.63 178.27,23.35 177.81,23.35 177.36,23.8 177.36,24.3 176.77,24.89 176.77,27.52 177.28,28.02 177.28,28.73 v2(177.31,28.76)
  BOTTOM w0.254: RH86.2 166.96,27.02 167.2,26.78 v2(167.2,26.52) ; v2(322.7,34.66) 324.26,36.23 344.92,36.23 349.89,31.26 350.61,31.26 351.75,30.12 RA12.2
SPKR_R: length 4.2
  BOTTOM w0.109: RA12.1 350.18,30.07 v1(349.9,30.36)
  BOTTOM w0.254: CA27.1 350.88,28.1 CA228.1 351.07,29.16 RA225.1 351.08,29.82 RA12.1
SRN_1: length 2.9
  TOP w0.203: PU700.19 287.87,27.39 PR728.2
SRP_1: length 2.7
  TOP w0.203: PU700.20 288.27,27.15 v1(288.07,26.95) 287.29,26.18 PR727.2
SRTCRST#: length 6.9
  TOP w0.102: UH1.BD46 v2(175.36,21.31)
  BOTTOM w0.109: v2(175.36,21.31) 175.36,20.95 175.81,20.5 175.81,18.58 175.97,18.42 RH201.2 175.3,17.43 CH41.2 175.64,16.68 v1(176.67,16.68)
SSD_SCP#: length 349.2
  TOP w0.109: RN220.2 357.5,13.09 v2(357.22,13.37) ; UE1.L6 v2(133.53,20.85)
  IN2 w0.081: v2(133.53,20.85) 133.11,20.43 128.78,20.43 128.6,20.25 126.21,20.25 124.69,21.76 124.69,22.09 123.97,22.81 121.65,22.81 121.64,22.82 120.85,22.82 120.49,23.18 119.53,23.18 119.17,23.54 119.17,23.8 118.65,24.32 117.88,24.32 117.14,25.07 116.57,25.07 114.37,27.27 112.94,27.27 112.21,28.01 109.55,28.01 109.16,28.39 108.41,29.15 103.96,29.15 102.63,30.48 102.63,31.24 101.95,31.92 101.15,31.92 100.47,32.59 100.47,32.94 100.34,33.06 98.68,33.06 98.17,33.57 98.17,35.86 97.63,36.4 95.49,36.4 93.01,38.88 89.12,38.88 89.03,38.97 v2(89.03,39.38) ; v2(357.22,13.37) 352.25,13.37 351.49,14.14 350.13,14.14 349.36,13.37 348.31,13.37 347.45,14.23 343.98,14.23 340.9,11.15 v2(335.55,11.15)
  IN3 w0.081: v2(89.03,39.38) 88.83,39.18 85.25,39.18 84.26,38.2 80.23,38.2 v2(79.61,38.83) ; v2(335.55,11.15) 335.44,11.15 331.61,7.33 331.61,4.98 327.89,1.26 269.23,1.26 v2(268.56,1.93)
  IN4 w0.102: v2(133.53,20.85) 133.58,20.85 133.99,20.44 138.54,20.44 139,20.9 139.7,20.9 140.79,19.81 143.36,19.81 144.52,20.97 144.52,21.75 145.89,23.12 146.8,23.12 148.19,24.51 152.87,24.51 153.93,23.45 154.44,23.45 155.85,22.04 158.38,22.04 158.72,22.38 159.52,22.38 159.55,22.41 160.74,22.41 162.69,20.46 163.3,20.46 163.57,20.18 163.57,19.59 164.67,18.5 165.36,18.5 165.84,18.01 167.81,18.01 169.56,16.26 171.19,16.26 171.33,16.4 171.85,16.4 172.45,15.8 172.8,15.8 174.62,13.97 176.7,13.97 178.97,11.7 179.5,11.7 180.11,11.08 180.77,11.08 180.87,10.98 185.3,10.98 186.09,10.18 196.68,10.18 196.89,10.39 199.41,10.39 201.81,7.99 203.72,7.99 204.71,7 205.7,7 206.03,7.33 207.04,7.33 207.73,6.64 208.83,6.64 209.07,6.88 209.07,7.91 210.7,9.55 219.2,9.55 221.02,11.37 228.41,11.37 229.14,10.64 234.69,10.64 235.66,9.67 236.47,9.67 240.82,5.33 240.82,2.57 241.04,2.34 246.67,2.34 246.84,2.51 246.84,2.94 247.23,3.33 254.52,3.33 255.22,2.64 267.55,2.64 268.25,1.93 v2(268.56,1.93)
  BOTTOM w0.109: RN221.2 87.41,23.16 85.84,24.73 82.97,24.73 82.59,25.12 82.59,25.57 82.93,25.91 82.93,30.19 82.67,30.44 82.58,30.57 82.57,30.6 81.78,31.39 81.46,31.39 80.42,32.42 80.42,33.71 79.28,34.85 79.28,36.4 79.86,36.98 79.86,38.57 v2(79.61,38.83) ; v2(89.03,39.38) 89.07,39.43 89.74,39.43 v1(92.55,42.24) 92.73,42.42 92.73,43.54 92.33,43.94 RN219.2
SUNB_3VR: length 1.4
  TOP w0.508: PC527.1 303.26,33.7 PR511.2
SUSACK#: length 33.7
  TOP w0.109: v2(167.78,26.57) 167.95,26.39 RH443.2 ; v2(143.5,22.44) 143.38,22.55 RE745.1
  IN1 w0.102: v2(159.55,28.84) 159.55,27.61 159.38,27.44 159.38,26.89 159.64,26.63 159.96,26.63 160.68,27.35 161.24,27.35 162.02,26.57 163.01,26.57 163.65,27.21 165.03,27.21 165.19,27.06 165.19,26.5 165.63,26.05 167.46,26.05 167.78,26.36 v2(167.78,26.57)
  IN2 w0.081: v2(143.5,22.44) 143.91,22.02 144.52,22.02 145.86,23.37 146.16,23.37 147.97,25.18 147.97,25.55 149.24,26.82 152.52,26.82 153.32,27.62 154.49,27.62 154.73,27.86 157.24,27.86 157.67,28.29 158.03,28.29 158.58,28.84 v2(159.55,28.84)
SUSACK#_R: length 7.7
  TOP w0.102: RH443.1 171.24,26.39 171.43,26.2 173.92,26.2 173.94,26.23 174.81,26.23 UH1.BE35
  TOP w0.109: v2(169.46,27.04) 169.46,27.04 169.46,26.62 RH443.1
  BOTTOM w0.109: v2(169.46,27.04) 169.53,26.97 169.53,26.57 169.42,26.46 v1(169.41,26.46) RH327.1
SUSCLK: length 377.6
  TOP w0.109: v2(174.9,21.98) 174.9,21.91 174.74,21.75 UH1.BE45
  IN2 w0.081: v2(213.32,15.08) 213.32,15.21 216.77,18.65 216.77,21.63 220.44,25.3 270.72,25.3 278.35,17.67 278.35,17.47 278.49,17.32 286.78,17.32 289.82,14.29 299.51,14.29 301.12,12.68 303.26,12.68 v2(303.81,13.23) 304.56,12.48 311.72,12.48 312.5,11.7 313.5,11.7 314.68,12.89 314.68,15.57 320.05,20.94 322.93,20.94 323.12,21.13 324.74,21.13 325.46,20.4 327.13,20.4 327.65,20.92 328.07,20.92 v2(328.94,21.79)
  IN3 w0.081: v2(174.9,21.98) 172.66,21.98 172.34,22.29 170.72,22.29 170.71,22.29 170.36,22.29 169.59,21.53 167.51,21.53 165.77,23.27 165.31,23.27 165.13,23.08 165.13,22.49 163.56,20.92 163.56,19.85 163.33,19.62 163.03,19.62 163,19.66 161.37,19.66 158.98,17.27 158.98,15.37 158.69,15.08 158.69,13.62 159.99,12.32 v2(161.43,12.32) ; v2(303.81,13.23) 302.53,11.95 v2(302.53,8.9)
  IN4 w0.102: v2(91.05,8.56) 90.58,8.56 90.28,8.85 90.28,18.25 92.05,20.02 v2(92.05,20.67) ; v2(213.32,15.08) 213,14.77 210.98,14.77 209.06,16.68 201.26,16.68 198.82,19.12 192.85,19.12 192.24,19.73 183.14,19.73 182.83,20.04 181.16,20.04 179.53,21.67 179.19,21.67 178.86,21.35 178.26,21.35 177.92,21.69 177.14,21.69 176.06,22.77 175.28,22.77 174.9,22.38 v2(174.9,21.98)
  BOTTOM w0.109: v2(161.43,12.32) 159.89,12.32 158.5,13.71 158.5,14.98 157.95,15.52 157.95,16.02 157.74,16.23 155.7,16.23 155.39,16.55 148.11,16.55 144.84,13.28 144.84,11.86 143.47,10.49 142.05,10.49 140.04,8.48 140.04,8.15 139.69,7.79 135.59,7.79 135.27,7.47 131.57,7.47 130.21,6.11 130.21,4.58 128.89,3.26 127.11,3.26 126.33,2.48 121.78,2.48 118.92,5.34 115.17,5.34 114.28,6.23 114.28,8.7 114.56,8.98 115,8.98 117.32,11.3 117.32,12.47 116.81,12.98 109.87,12.98 109.38,12.49 96.32,12.49 v1(95.47,11.64) 94.61,10.78 94.61,8.11 93.89,7.38 87.56,7.38 RN207.2 87.35,8.21 87.7,8.56 v2(91.05,8.56) ; RN205.2 346.8,12.48 346.56,12.71 343.87,12.71 342.91,13.67 342.91,14.57 341.38,16.11 338.58,16.11 337.83,16.86 337.83,20.31 337.39,20.74 337.39,21.85 336.58,22.66 333.88,22.66 333.65,22.9 331.26,22.9 331.21,22.95 329.43,22.95 328.94,22.47 v2(328.94,21.79) 328.97,21.76 RZ56.2 ; v2(92.05,20.67) 92.05,22.8 91.56,23.3 91.56,26.97 91.19,27.33 91.19,28.8 90.48,29.51 90.48,32.83 90.21,33.1 89.02,33.1 88.36,32.44 RN99.2 ; RH83.1 174.25,22.63 v2(174.9,21.98) ; JNGFF2.60 306.25,9.11 306.11,8.97 302.6,8.97 v2(302.53,8.9)
SUSCLK_R3: length 3.7
  BOTTOM w0.109: JNGFF3.60 84.59,32.45 84.91,32.14 v1(86.27,32.14) 87.02,32.14 RN99.1
SUSCLK_R4: length 5.1
  BOTTOM w0.109: v1(347.83,11.15) RN205.1 346.8,7.96 JNGFF4.68
SUSCLK_R5: length 3.1
  BOTTOM w0.109: RN207.1 85.83,8.2 v2(85.5,8.2) 84.7,7.4 JNGFF5.60
SW1_2PH: length 21
  TOP w0.109: PR1145.2 268.86,138.41 v1(268.53,138.08)
  TOP w0.254: v2(269.74,139.78) 269.67,139.71 PR1145.2
  IN2 w0.254: v2(269.74,139.78) 269.74,139.37 266.75,136.38 264.33,136.38 259.68,131.73 259.68,129.09 v2(259.76,129.01)
  BOTTOM w0.254: PR1160.2 269.52,140 v2(269.74,139.78) ; PL1700.2 v2(259.76,129.01)
SW1_4PH: length 19.7
  TOP w0.203: v2(254.47,140.79) PR1143.1
  TOP w0.254: v2(249.31,129.87) 249.14,130.05 PL1202.2
  IN1 w0.254: v2(254.47,140.79) 255.91,139.36 255.91,135.81 254.04,133.94 251.63,133.94 249.31,131.62 v2(249.31,129.87)
  BOTTOM w0.109: v2(249.31,129.87) v1(250.3,129.87)
  BOTTOM w0.203: PR1154.1 254.53,140.73 v2(254.47,140.79)
SW1_CET: length 25.5
  IN3 w0.081: v2(99.99,40.55) 99.99,41.52 100.5,42.03 100.5,42.63 101.31,43.44 110.63,43.44 112.38,41.68 115.12,41.68 v2(115.72,42.29)
  BOTTOM w0.109: v2(99.99,40.55) 99.46,40.01 99.46,39.56 98.48,38.59 v1(98.48,38.36) 98.48,37.72 CV818.2 ; UV64.47 113.86,41.38 114.77,42.29 v2(115.72,42.29)
SW1_EDP_AUXN: length 9.6
  BOTTOM w0.109: RV840.2 102.84,47.45 CV2.1 104.14,47.09 v4(104.14,46.12) 104.14,45.36 104.73,44.77 104.73,44.05 105.18,43.59 105.42,43.59 105.66,43.36 105.66,43.32 106.16,42.82 106.2,42.82 106.46,42.55 107.02,42.55 107.55,42.02 107.55,41.41 107.46,41.31 UV64.31
SW1_EDP_AUXN_C: length 11.3
  TOP w0.109: v2(108.61,45.47) 108.42,44.98 108.42,44.2 108.5,44.12 JEDP1.29
  BOTTOM w0.109: v2(108.61,45.47) 108.41,45.67 108.41,46.99 108.43,47.01 108.43,47.58 108.41,47.6 108.41,48.46 107.42,49.46 104.44,49.46 104.02,49.04 104.02,48.26 CV2.2
SW1_EDP_AUXP: length 9.6
  BOTTOM w0.109: UV64.32 107.86,41.34 107.77,41.43 107.77,42.11 107.11,42.77 106.55,42.77 106.35,42.97 106.35,42.97 v4(106.02,43.3) 105.81,43.51 105.51,43.81 105.27,43.81 104.94,44.14 104.94,44.86 104.36,45.44 104.36,45.83 104.37,45.84 104.37,46.46 104.36,46.47 104.36,47.13 CV1.1 104.68,47.45 RV842.2
SW1_EDP_AUXP_C: length 11.2
  TOP w0.109: v2(107.93,45.2) 108.14,45.2 108.21,45.14 108.21,44.21 108,44 JEDP1.28
  BOTTOM w0.109: v2(107.93,45.2) 108.14,45.2 108.19,45.26 v4(108.19,47.31) 108.19,48.38 107.33,49.24 104.53,49.24 104.23,48.95 104.23,48.26 104.47,48.03 CV1.2
SW1_EDP_HPD: length 13.3
  TOP w0.109: v2(105.98,44.41) 106,44.41 106.5,43.91 JEDP1.25
  IN3 w0.081: v2(113.05,42.27) 112.38,42.27 110.98,43.67 106.7,43.67 105.98,44.39 v2(105.98,44.41)
  BOTTOM w0.109: v2(105.98,44.41) 106.64,45.08 RV7.2 v1(105.6,45.55) ; UV64.44 112.66,41.88 v2(113.05,42.27)
SW1_EDP_N0: length 3.1
  BOTTOM w0.109: UV64.45 113.06,41.29 113,41.35 113,41.6 113.54,42.15 113.54,42.31 114.24,43.01 114.24,43.12 CV847.1
SW1_EDP_N0_C: length 4.7
  TOP w0.109: JEDP1.38 113,44.19 113.66,44.85 113.66,45.55 v2(113.56,45.65)
  BOTTOM w0.109: v2(113.56,45.65) 113.65,45.55 113.65,45.11 114.23,44.53 114.23,44.09 CV847.2
SW1_EDP_N1: length 2.8
  BOTTOM w0.109: CV845.1 112.4,43.1 112.4,42.94 111.8,42.34 111.8,41.41 111.86,41.35 UV64.42
SW1_EDP_N1_C: length 5.3
  TOP w0.109: JEDP1.36 112,44.91 112.04,44.95 112.04,46 v2(111.95,46.09)
  BOTTOM w0.109: v2(111.95,46.09) 112.04,46 112.04,45.08 v1(112.37,44.75) 112.4,44.72 112.4,44.05 CV845.2
SW1_EDP_N2: length 2.5
  BOTTOM w0.109: CV5.1 110.61,43.05 v1(110.61,42.22) 110.61,42.13 110.66,42.08 UV64.39
