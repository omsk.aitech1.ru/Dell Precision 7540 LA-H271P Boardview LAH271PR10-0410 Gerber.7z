# Allegro board LAH271PR10-0410_Gerber.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP (solid shape): 245.55,142.73 245.55,141.62 245.45,141.52 243.49,141.52 243.4,141.62 243.4,142.94 243.64,143.18 245.11,143.18
GND on TOP (solid shape): 253.26,143.22 253.26,141.8 253.16,141.7 251.2,141.7 251.1,141.8 251.1,142.94 251.52,143.36 253.12,143.36
GND on TOP (solid shape): 267.83,128.4 267.83,120.31 267.6,120.08 263.62,120.08 262.49,121.2 262.49,127.27 265.21,129.99 266.24,129.99
GND on TOP (solid shape): 278.95,32.28 278.95,27.47 278.65,27.17 274.03,27.17 273.84,27.36 273.84,32.32 273.98,32.46 278.76,32.46
GND on TOP (solid shape): 284.98,97.87 284.98,96.56 284.9,96.47 283.57,96.47 283.48,96.56 283.48,97.98 283.57,98.07 284.78,98.07
GND on TOP (solid shape): 319.51,22.52 319.51,21.56 319.35,21.41 318.51,21.41 318.38,21.53 318.38,22.53 318.53,22.69 319.34,22.69
GND on TOP (solid shape): 326.74,20.49 326.74,17.71 326.64,17.61 324.23,17.61 323.55,18.28 323.55,20.43 323.74,20.61 326.62,20.61
GND on TOP (solid shape): 350.13,34.74 350.13,32.34 349.93,32.14 348.1,32.14 347.97,32.27 347.97,34.79 348.09,34.92 349.95,34.92
GND on TOP (solid shape): 351.21,50.61 351.21,48.9 351.2,48.89 349.51,48.89 349.46,48.95 349.46,50.6 349.54,50.69 351.13,50.69
GND on TOP (solid shape): 357.51,47.98 357.51,46.32 357.17,45.98 353.29,45.98 353,46.26 353,47.88 353.38,48.26 357.23,48.26
GND on TOP (solid shape): 97.74,35.81 97.74,34.99 97.64,34.89 96.22,34.89 95.9,35.21 95.9,35.74 96.09,35.93 97.61,35.93
GND on TOP (solid shape): 179.48,117.95 179.48,117.14 178.07,115.72 176.61,115.72 175.65,116.69 175.65,118.01 175.78,118.15 179.29,118.15
GND on TOP (solid shape): 277.82,69.97 277.82,65.72 277.5,65.4 274.01,65.4 273.43,65.97 273.43,69.59 274.01,70.16 277.63,70.16
GND on TOP (solid shape): 319.27,16.56 319.27,16.15 318.81,15.69 317.84,15.69 317.73,15.8 317.73,16.53 317.9,16.7 319.13,16.7
GND on TOP (solid shape): 91.62,19.71 91.62,17.12 91.49,16.99 88.16,16.99 87.18,17.97 87.18,19.65 87.39,19.86 91.48,19.86
GND on TOP (solid shape): 114.35,25.94 114.35,25.2 112.87,23.72 111.92,23.72 111.71,23.93 111.71,25.19 112.54,26.03 114.27,26.03
GND on TOP (solid shape): 123.48,19.17 123.48,18.82 123.39,18.74 123.39,17.98 123.35,17.93 122.52,17.93 122.38,18.07 122.38,19.16 122.47,19.25 123.4,19.25
GND on TOP (solid shape): 200.65,147.68 199.67,147.68 199.24,148.12 199.24,148.12 199.2,148.17 199.2,153.21 198.56,153.84 197.7,153.84 197.7,154.3 200.65,154.3
GND on TOP (solid shape): 215.33,10.89 215.33,10.64 215.55,10.43 215.55,9.58 215.39,9.43 212.4,9.43 212.27,9.57 212.27,10.75 212.51,10.99 215.23,10.99
GND on TOP (solid shape): 285.98,69.98 285.98,67.75 285.64,67.41 281.93,67.41 281.63,67.71 281.63,70.25 281.95,70.57 285.39,70.57
GND on TOP (solid shape): 287.32,19.75 287.32,18.7 286.98,18.36 281.56,18.36 281.47,18.45 281.47,19.51 281.9,19.94 287.13,19.94
GND on TOP (solid shape): 298.48,26.08 298.48,25.06 298.34,24.92 297.15,24.92 297.02,25.05 297.02,25.94 297.32,26.24 298.32,26.24
GND on TOP (solid shape): 299.79,34.22 299.79,33.16 299.63,32.99 293.89,32.99 293.73,33.15 293.73,33.82 293.37,34.18 293.37,34.43 293.49,34.55 299.46,34.55
GND on TOP (solid shape): 306.04,17.01 306.04,16.25 305.92,16.13 304.88,16.13 304.3,15.56 302.81,15.56 302.68,15.69 302.68,17.02 302.87,17.21 305.83,17.21
GND on TOP (solid shape): 58.13,3.35 58.13,3.21 58.13,3.2 58.13,2.72 58.12,2.72 58.12,2.53 58.27,2.39 58.27,1.22 52.37,1.22 52.37,3.02 53.05,3.69 57.78,3.69
GND on TOP (solid shape): 105.6,44.56 105.6,44 105.65,43.95 105.65,42.8 105.55,42.7 104.5,42.7 104.36,42.84 104.36,44 104.07,44.29 104.07,44.59 104.22,44.75 105.41,44.75
GND on TOP (solid shape): 211.24,125.73 211.24,121.24 211.3,121.18 211.3,118.71 211.22,118.62 210.15,118.62 209.81,118.97 209.81,121.1 209.59,121.32 209.59,125.79 209.74,125.94 211.04,125.94
GND on TOP (solid shape): 294.85,44.74 294.85,43.7 295.03,43.52 297.67,43.52 297.83,43.36 297.83,42.66 297.69,42.52 291.49,42.52 291.28,42.73 291.28,44.6 291.58,44.9 294.69,44.9
GND on TOP (solid shape): 59.48,6.95 59.6,6.95 59.7,6.85 59.7,5.61 59.65,5.55 57.96,5.55 57.88,5.64 57.88,6.98 57.8,7.05 57.8,7.41 57.94,7.55 58.88,7.55
GND on TOP (solid shape): 138.7,7.43 138.7,6.54 138.33,6.17 136.12,6.17 136.06,6.24 136.06,6.85 136.22,7.02 136.22,7.52 136.31,7.61 138.52,7.61
GND on TOP (solid shape): 148.14,19.81 148.33,19.81 149.45,18.68 149.45,18.03 148.68,17.25 146.48,17.25 146.39,17.34 146.39,18.15 146.78,18.54 146.78,19.58 147,19.81 148.14,19.81
GND on TOP (solid shape): 209.97,70.06 210,70.06 210.03,70.03 210.03,65.49 210,65.46 203.67,65.46 202.01,67.13 198.77,67.13 198.63,67.27 198.63,70.59 198.77,70.73 209.3,70.73
GND on TOP (solid shape): 249.06,147.32 252.29,147.32 252.87,146.74 252.87,145.34 252.54,145.01 251.93,145.01 251.53,145.42 242.81,145.42 242.79,145.39 230.82,145.39 229.68,146.54 229.68,148.37 231.03,149.71 246.67,149.71
GND on TOP (solid shape): 280.22,17.88 280.22,17.57 280.12,17.46 279.63,17.46 279.43,17.26 279.43,16.04 279.19,15.8 278.36,15.8 278.13,16.03 278.13,17.7 278.51,18.07 280.03,18.07
GND on TOP (solid shape): 19.35,57.15 19.35,56.49 19.12,56.26 19.12,55.73 19.9,54.94 19.9,54.81 19.24,54.15 18.9,54.15 17.47,55.58 17.47,57.01 18.32,57.86 18.64,57.86
GND on TOP (solid shape): 141.52,37.14 141.52,36.04 141.31,35.83 140.69,35.83 140.45,36.08 140.45,36.2 140.45,36.27 140.45,37.21 140.57,37.33 141.32,37.33
GND on TOP (solid shape): 358.22,24.13 358.22,23.57 358.06,23.4 356.99,23.4 356.99,22.86 356.99,22.85 356.81,22.85 356.81,23.41 356.39,23.41 356.35,23.45 356.35,24 356.53,24.18 356.53,24.91 356.7,25.07 357.28,25.07
GND on TOP (solid shape): 369.57,10.65 369.57,9.86 369.47,9.76 368.98,9.76 368.75,9.98 363.58,9.98 363.52,10.04 363.52,11.09 363.66,11.22 367.02,11.22 367.25,11.45 368.77,11.45
GND on TOP (solid shape): 123.97,16.34 123.97,15.22 123.04,14.29 122.9,14.29 122.76,14.15 122.76,13.66 122.71,13.61 122.34,13.61 122.28,13.67 122.28,14.7 122.33,14.75 122.84,14.75 123.27,15.18 123.27,16.31 123.33,16.37 123.93,16.37
GND on TOP (solid shape): 163.13,5.03 163.13,4.59 163.02,4.48 163.02,2.84 163.01,2.79 163.02,2.74 163.02,1.56 162.89,1.43 160.12,1.43 159.65,1.9 159.65,4.91 159.89,5.15 163.01,5.15
GND on TOP (solid shape): 177.87,115.07 177.88,115.06 177.94,114.98 178.02,114.92 178.06,114.89 178.06,113.7 177.48,113.13 175.83,113.13 175.64,113.31 175.64,114.31 176.87,115.53 177.41,115.53
GND on TOP (solid shape): 228.56,10.75 228.56,9.12 227.43,7.99 223.66,7.99 223.47,8.18 223.47,8.85 223.47,8.85 223.47,9.17 222.6,10.03 222.07,10.03 221.57,9.53 221.03,9.53 220.93,9.63 220.93,11.16 221.03,11.25 228.06,11.25
GND on TOP (solid shape): 39.25,31.18 39.46,31.18 39.64,31.19 39.78,31.06 39.78,28.74 39.61,28.58 38.58,28.58 38.14,29.01 38.14,31.1 38.35,31.3 39.13,31.3
GND on TOP (solid shape): 199.88,48.04 199.88,47.24 199.15,46.51 199.15,45.68 198.89,45.42 198.66,45.42 198.45,45.63 198.45,45.9 198.78,46.24 198.78,47.1 199.09,47.41 199.09,47.41 199.21,47.53 199.21,48.05 199.27,48.11 199.82,48.11
GND on TOP (solid shape): 201.32,80.2 201.42,80.17 201.53,80.16 201.55,80.16 201.99,79.72 201.99,76.44 201.74,76.18 198.87,76.18 198.58,76.48 198.58,79.97 198.81,80.21 201.31,80.21
GND on TOP (solid shape): 247.39,7.98 247.39,6.06 247.38,6.05 247.36,5.92 247.38,5.8 247.39,5.79 247.39,4.07 247.26,3.94 244.92,3.94 244.72,4.14 244.72,7.75 245.05,8.08 247.28,8.08
GND on TOP (solid shape): 170.59,114.93 170.8,114.9 171.01,114.93 171.02,114.93 172.34,114.93 172.5,114.77 172.5,113.25 172.45,113.2 170.44,113.2 170.27,113.37 170.27,114.76 170.44,114.93 170.58,114.93
GND on TOP (solid shape): 200.34,54.31 200.34,53.76 200.89,53.21 201.48,53.21 201.73,52.96 201.73,49.97 201.52,49.75 200.27,49.75 200.18,49.66 199.83,49.66 199.77,49.72 199.77,50.18 200,50.41 200,51.51 199.42,52.09 199.42,54.35 199.53,54.46 200.18,54.46
GND on TOP (solid shape): 282.1,35.38 282.1,34.95 282.11,34.94 282.66,34.94 282.67,34.94 282.67,34.78 282.66,34.77 282.11,34.77 282.1,34.76 282.1,34.34 282.03,34.27 281.34,34.27 281.3,34.27 281.17,34.4 281.17,35.38 281.22,35.42 282.06,35.42
GND on TOP (solid shape): 302.26,57.1 302.26,55.14 301.96,54.84 299.41,54.84 298.79,54.22 297.74,54.22 297.58,54.39 297.58,55.84 297.7,55.97 298.99,55.97 299,55.98 299.47,55.98 299.97,56.47 299.97,57.05 300.31,57.39 301.98,57.39
GND on TOP (solid shape): 28.68,53.75 28.68,53.18 28.53,53.03 27.61,53.03 27.57,52.99 27.32,52.99 27.28,53.03 26.21,53.03 25.62,52.44 25.08,52.44 24.77,52.75 24.77,53.38 25.32,53.92 25.55,53.92 26.01,53.47 26.17,53.47 27.46,54.76 27.67,54.76
GND on TOP (solid shape): 171.53,118.12 171.56,118.12 172.36,118.12 172.49,118 172.49,116.55 172.25,116.31 171.16,116.31 171.11,116.33 171.05,116.36 170.4,117 170.4,117.77 170.75,118.11 171,118.11 171,118.12 171.49,118.12
GND on TOP (solid shape): 340.06,44.73 340.06,44.03 340.16,43.92 341.25,43.92 341.25,43.92 341.24,42.93 338.54,42.93 338.51,42.96 338.51,43.82 338.61,43.92 339.7,43.92 339.82,44.03 339.82,44.73 339.89,44.8 339.99,44.8
GND on TOP (solid shape): 9.85,36.35 1.55,36.35 1.55,40.2 2,40.48 1.95,41 9.85,41
GND on TOP (solid shape): 173.5,43.41 173.98,43.41 174.21,43.18 174.22,43.16 174.24,43.1 174.27,43.04 174.27,42.95 174.31,42.91 174.31,42.02 174.26,41.98 174.22,41.92 173.95,41.66 173.47,41.66 172.89,42.24 172.89,43.41 173.01,43.54 173.37,43.54
GND on TOP (solid shape): 197.59,20.47 200.26,20.47 200.43,20.3 200.43,19.47 200.29,19.33 195.93,19.33 195.7,19.55 195.7,19.74 195.55,19.89 194.29,19.89 194.29,19.91 194.12,20.08 194.12,20.13 194.2,20.21 195.55,20.21 195.65,20.31 195.65,20.75 195.73,20.84 195.73,21.23 196.05,21.54 196.52,21.54
GND on TOP (solid shape): 217.65,131.69 217.65,130.57 217.38,130.29 217.15,130.29 216.91,130.05 216.91,129.47 217.03,129.34 217.57,129.34 217.6,129.3 217.6,128.21 217.48,128.08 212.17,128.08 211.75,127.66 208.8,127.66 208.35,128.12 208.35,129.95 208.59,130.19 212.8,130.19 212.9,130.29 215.95,130.29 216.1,130.45 216.1,131.66 216.18,131.74 217.6,131.74
GND on TOP (solid shape): 86.39,27.7 86.39,26.07 86.51,25.94 86.51,24.95 86.41,24.84 84.16,24.84 84.09,24.91 84.09,26.87 84.6,27.37 84.62,27.37 84.84,27.48 84.94,27.69 84.94,27.72 84.99,27.76 86.33,27.76
GND on TOP (solid shape): 207.57,19 207.57,16.93 206.26,15.61 203.88,15.61 203.66,15.4 202.02,15.4 201.91,15.51 201.91,15.97 201.72,16.16 201.51,16.16 201.32,16.35 201.32,17.14 201.42,17.24 202.19,17.24 203.37,18.42 206.4,18.42 206.47,18.42 206.83,18.79 206.83,19.06 206.99,19.21 207.36,19.21
GND on TOP (solid shape): 319.27,29.59 319.27,28.32 318.88,27.94 313.91,27.94 313.45,28.39 310.48,28.39 310.06,28.81 308.33,28.81 308.21,28.92 308.21,29.16 308.36,29.3 308.57,29.3 308.72,29.15 309.98,29.15 310.42,29.6 311.52,29.6 311.99,29.13 313.18,29.13 313.82,29.77 314.94,29.77 315.22,30.04 315.91,30.04 316.26,30.38 318.47,30.38
GND on TOP (solid shape): 306.1,4.84 306.1,4.38 306.34,4.15 306.58,4.15 306.9,3.83 307.22,3.83 307.38,3.66 307.38,1.8 307.21,1.63 303.24,1.63 303.17,1.69 303.16,1.69 303.16,3.68 303.25,3.89 303.16,4.11 303.16,4.5 303.64,4.99 305.96,4.99
GND on TOP (solid shape): 33.33,48.25 33.33,46.9 32.01,45.59 30.34,45.59 30.3,45.55 30.3,44.99 30.07,44.76 30.07,44.36 29.63,43.92 29.17,43.92 29.03,44.06 29.03,44.53 29.38,44.88 29.38,45.84 29.8,46.25 31.86,46.25 32.06,46.45 32.14,46.53 32.14,47.05 31.83,47.37 27.99,47.37 27.84,47.52 27.84,48.75 28.05,48.96 32.62,48.96
GND on TOP (solid shape): 203.7,14.06 203.7,12.54 203.78,12.46 204.16,12.46 204.26,12.57 204.26,13.59 204.55,13.87 204.98,13.87 205.11,13.74 205.11,13.52 204.97,13.38 204.8,13.38 204.79,13.38 204.67,13.38 204.49,13.2 204.49,10.72 204.43,10.65 202.72,10.65 202.68,10.69 202.68,12.4 202.75,12.46 203.38,12.46 203.46,12.54 203.46,13.59 203.19,13.86 203.19,14.1 203.3,14.2 203.56,14.2
GND on TOP (solid shape): 334.94,18.84 334.94,17.81 335.04,17.71 335.04,15.9 334.82,15.68 333.97,15.68 333.92,15.73 333.83,16.09 333.47,16.18 332.79,16.86 331.68,16.86 331.64,16.9 331.64,18.95 331.66,18.97 334.81,18.97
GND on TOP (solid shape): 284.01,47.6 284.01,46.79 284.18,46.61 285.44,46.61 285.66,46.84 285.66,47.42 285.79,47.55 287.96,47.55 288.33,47.17 288.33,45.75 287.89,45.31 286.19,45.31 286.02,45.14 286.02,45 285.68,44.66 285.29,44.66 285.22,44.73 285.22,45.5 285.04,45.69 283.51,45.69 283.16,46.03 283.16,47.1 283.72,47.66 283.94,47.66
GND on TOP (solid shape): 341.14,35.07 341.14,30.48 341.14,30.48 341.14,30.32 340.97,30.15 340.14,30.15 339.74,29.75 339.74,28.87 339.85,28.76 339.85,27.22 339.85,27.22 339.85,26.86 339.76,26.77 339.35,26.77 338.96,27.16 338.96,28.23 338.88,28.31 338.88,28.5 338.68,28.7 338.68,30.6 338.68,30.6 338.68,31.74 339.05,32.12 339.05,35.11 339.23,35.29 340.93,35.29
GND on TOP (solid shape): 33.41,20.36 33.41,20.36 33.73,20.04 33.73,19.31 33.87,19.16 34.36,19.16 34.59,18.94 34.59,18.29 34.44,18.14 31.05,18.14 31.03,18.16 30.55,18.16 30.33,18.38 30.33,19.79 30.87,20.33 31.02,20.33 31.03,20.32 32.28,20.32 32.67,20.2 32.92,20.53 32.95,20.55 33.22,20.55
GND on TOP (solid shape): 316,40.65 316.82,40.65 317.24,40.23 317.24,38.23 317.1,38.08 312.42,38.08 312.2,38.3 309.05,38.3 308.6,38.75 307.62,38.75 307.51,38.64 307.15,38.64 307.06,38.73 307.06,39.03 307.15,39.13 307.37,39.13 307.45,39.04 308.73,39.04 309.09,39.4 310.11,39.4 310.49,39.02 311.86,39.02 312.57,39.73 313.76,39.73 313.79,39.77 313.81,39.77 313.81,40.27 314.28,40.74 314.29,40.74 314.39,40.82 314.46,40.92 314.47,40.93 315.72,40.93
GND on TOP (solid shape): 312.13,10 312.13,8.35 312.43,8.04 312.43,7.08 311.9,6.54 311.9,5.89 311.83,5.83 311.19,5.83 310.74,5.38 310.35,5.38 309.79,4.82 308.96,4.82 308.9,4.75 308.89,4.75 308.8,4.65 308.8,4.6 308.59,4.38 307.72,4.38 307.62,4.48 307.62,5.51 307.75,5.64 309.03,5.64 309.87,6.48 309.87,8.29 310.22,8.63 310.22,9.07 310.23,9.08 310.23,9.43 310.35,9.54 310.69,9.54 310.71,9.56 310.73,9.56 311.03,9.85 311.03,10.09 311.15,10.22 311.91,10.22
GND on TOP (solid shape): 69.46,13.27 69.46,9.76 69.59,9.63 69.71,9.63 70.04,9.3 70.04,8.84 70.17,8.71 70.17,8.64 70.35,8.46 70.36,8.46 70.36,8.19 69.61,7.45 69.24,7.45 68.46,6.66 67.7,6.66 67.19,7.18 67.19,7.73 67.67,8.2 67.67,8.72 67.82,8.87 67.82,10.49 68.11,10.78 68.29,11.03 68.21,11.32 68.21,13.77 68.32,13.88 68.85,13.88
GND on TOP (solid shape): 189.83,16.21 192.07,16.21 192.11,16.17 192.11,15.47 191.61,14.96 190.81,14.96 189.2,13.35 188.7,13.35 188.54,13.52 188.54,14.91 189.15,15.01 188.75,15.49 188.75,16.17 188.81,16.23 189.81,16.23
GND on TOP (solid shape): 116.36,8.74 116.36,8.45 116.59,8.23 116.83,8.23 116.83,8.22 117.01,8.22 117.16,8.38 117.16,8.67 117.31,8.82 119.29,8.82 119.5,8.61 120,8.61 120,7.46 120.01,7.45 120.01,6.73 120.03,6.71 120.03,6 119.98,5.95 118.56,5.95 118.28,6.23 115.2,6.23 114.67,6.76 113.68,6.76 113.6,6.84 112,6.84 111.64,7.19 110.53,7.19 110.46,7.12 109.84,7.12 109.74,7.22 109.74,7.53 109.8,7.59 110.49,7.59 110.54,7.57 110.56,7.55 111.66,7.55 111.98,7.87 113.29,7.87 113.63,7.52 114.47,7.52 114.49,7.55 114.63,7.55 115.92,8.84 116.26,8.84
GND on TOP (solid shape): 142.73,10.19 144.01,10.19 144.69,9.51 145.68,9.51 145.79,9.4 145.79,7.86 145.67,7.73 144.69,7.73 144.21,7.25 144.21,6.64 143.9,6.32 141.02,6.32 140.97,6.27 140.89,6.27 140.89,6.2 140.67,5.97 140.46,5.97 140.36,6.07 140.36,7.23 140.99,7.86 142.36,7.86 142.49,7.98 142.78,8.09 142.89,8.38 142.89,8.39 142.89,9.52 142.69,9.72 142.05,9.72 141.96,9.81 141.96,10.17 142.06,10.28 142.64,10.28
GND on TOP (solid shape): 8.75,53.15 1.6,53.15 1.5,53.2 1.48,53.31 1.42,53.73 1.06,53.95 1,53.95 1,56.55 1.06,56.55 1.42,56.77 1.48,57.19 1.5,57.3 1.6,57.35 8.75,57.35
GND on TOP (solid shape): 86.98,12.25 86.98,9.71 86.73,9.47 86.73,7.81 86.3,7.38 83.84,7.38 83.63,7.59 83.63,8.2 85.14,8.2 85.15,8.14 85.16,8.09 85.18,8.04 85.2,7.99 85.24,7.95 85.28,7.92 85.32,7.89 85.37,7.86 85.42,7.85 85.47,7.84 85.53,7.84 85.58,7.85 85.63,7.86 85.68,7.89 85.72,7.92 85.76,7.95 85.79,7.99 85.82,8.04 85.84,8.09 85.85,8.14 85.86,8.2 85.85,8.25 85.84,8.3 85.82,8.35 85.79,8.4 85.76,8.44 85.72,8.47 85.68,8.5 85.63,8.53 85.58,8.54 85.53,8.55 85.47,8.55 85.42,8.54 85.37,8.53 85.32,8.5 85.28,8.47 85.24,8.44 85.2,8.4 85.18,8.35 85.16,8.3 85.15,8.25 85.14,8.2 83.63,8.2 83.63,10.61 85.44,12.41 86.82,12.41
GND on TOP (solid shape): 194.29,55.85 194.27,55.79 194.27,55.74 194.27,55.68 194.29,55.63 194.31,55.58 194.34,55.53 194.37,55.49 194.41,55.45 194.46,55.42 194.51,55.4 194.58,55.38 194.58,53.52 194.76,53.34 194.91,53.34 194.95,53.34 195,53.33 195.05,53.34 195.08,53.34 195.33,53.34 195.5,53.17 195.5,51.87 194.58,50.95 194.58,46.93 193.82,46.17 193.11,46.17 192.6,45.66 192.6,45.46 192.46,45.32 191.59,45.32 191.15,44.87 190.37,44.87 189.07,46.17 186.69,46.17 186.45,46.41 186.45,47.09 186.68,47.32 186.68,54.38 188.26,54.38 188.26,48.06 188.54,47.78 188.94,47.78 188.94,47.78 192.67,47.78 192.93,48.04 192.93,54.25 192.66,54.52 188.4,54.52 188.26,54.38 186.68,54.38 186.68,55.95 186.76,56.03 190.03,56.03 190.24,56.23 190.24,56.69 190.48,56.93 193.21,56.93
GND on TOP (solid shape): 302.38,17.12 302.38,15.64 302.58,15.44 302.61,15.42 304.39,15.42 304.55,15.26 304.55,13.7 304.54,13.69 304.54,12.02 304.45,11.93 303.91,11.93 303.81,12.03 303.81,12.5 303.15,13.16 300.85,13.16 300.79,13.23 303.45,13.23 303.45,13.17 303.47,13.12 303.49,13.07 303.51,13.03 303.55,12.98 303.58,12.95 303.63,12.92 303.68,12.89 303.73,12.88 303.78,12.87 303.83,12.87 303.89,12.88 303.94,12.89 303.99,12.92 304.03,12.95 304.07,12.98 304.1,13.03 304.13,13.07 304.15,13.12 304.16,13.17 304.16,13.23 304.16,13.28 304.15,13.33 304.13,13.38 304.1,13.43 304.07,13.47 304.03,13.51 303.99,13.54 303.94,13.56 303.89,13.57 303.83,13.58 303.78,13.58 303.73,13.57 303.68,13.56 303.63,13.54 303.58,13.51 303.55,13.47 303.51,13.43 303.49,13.38 303.47,13.33 303.45,13.28 303.45,13.23 300.79,13.23 300.44,13.58 300.44,17.08 300.63,17.28 302.22,17.28
GND on TOP (solid shape): 129.95,6.54 129.95,6.32 129.89,6.26 128.94,6.26 128.88,6.21 128.88,4.77 128.93,4.72 128.89,4.68 128.8,4.14 129.35,4.15 129.42,4.19 129.5,4.16 129.74,3.92 129.74,2.2 129.54,2 124.91,2 124.78,2.13 124.78,2.82 125.1,3.14 127.09,3.14 127.26,3.31 127.26,4.34 126.91,4.69 126.91,5.01 126.97,5.07 127.91,5.07 128.01,5.18 128.01,6.45 128.04,6.52 128.11,6.55 128.2,6.57 128.29,6.61 129.88,6.61
GND on TOP (solid shape): 110.61,17.92 110.61,17.48 110.95,17.15 111.38,17.15 111.66,16.87 111.66,14.53 111.66,13.92 109.34,11.6 108.9,11.6 108.55,11.24 107.94,11.24 107.81,11.37 107.81,15.17 107.76,15.22 107.27,15.71 107.27,16.77 107.62,16.77 107.62,16.28 107.62,16.25 107.63,16.19 107.64,16.13 107.67,16.07 107.7,16.02 107.74,15.96 107.78,15.92 107.83,15.88 107.89,15.85 107.94,15.83 108.01,15.81 108.07,15.8 108.13,15.8 108.19,15.81 108.26,15.83 108.31,15.85 108.37,15.88 108.42,15.92 108.46,15.96 108.5,16.02 108.53,16.07 108.56,16.13 108.57,16.19 108.58,16.25 108.58,16.28 108.58,16.77 108.58,16.8 108.57,16.86 108.56,16.92 108.53,16.98 108.5,17.03 108.46,17.08 108.42,17.13 108.37,17.17 108.31,17.2 108.26,17.22 108.19,17.24 108.13,17.25 108.07,17.25 108.01,17.24 107.94,17.22 107.89,17.2 107.83,17.17 107.78,17.13 107.74,17.08 107.7,17.03 107.67,16.98 107.64,16.92 107.63,16.86 107.62,16.8 107.62,16.77 107.27,16.77 107.27,16.96 106.94,17.29 103.77,17.29 103.25,16.77 102.27,16.77 101.87,17.18 101.87,18.49 102.1,18.72 109.81,18.72
GND on TOP (solid shape): 11.55,74.15 14.02,73.12 15.05,70.65 15.05,67.1 11.65,67.1 9.83,67.71 8.76,69.3 1.55,69.3 2.05,69.8 1.55,70.3 1.55,74.15
GND on TOP (solid shape): outline of 114 points within 32.46,28.54 36.67,31.66
GND on TOP (solid shape): outline of 158 points within 23.84,41.95 27.62,49.26
GND on TOP (solid shape): outline of 186 points within 219.32,127.49 253.53,138.64
GND on TOP (solid shape): outline of 394 points within 91.28,43.69 117.57,50.52
GND on TOP (solid shape): outline of 644 points within 215.72,23.14 372.05,154.3
GND on TOP (solid shape): outline of 1848 points within 0.2,0.15 370.97,151.35
GND on BOTTOM (solid shape): 172.45,145.2 168.45,145.2 168.45,151.55 172.45,151.55
GND on BOTTOM (solid shape): 273.65,153 273.65,145.2 270.65,145.2 270.65,154.5 272.15,154.5
GND on BOTTOM (solid shape): 78.59,50.9 78.59,49.38 77.75,48.54 75.37,48.54 74.95,48.96 74.95,51.31 75.26,51.62 77.87,51.62
GND on BOTTOM (solid shape): 222.77,121.99 222.77,120.92 222.49,120.65 219.02,120.65 218.88,120.79 218.88,121.83 219.21,122.17 222.58,122.17
GND on BOTTOM (solid shape): 233,98.17 233,96.61 232.82,96.43 232.05,96.43 231.83,96.65 231.83,98.17 231.89,98.23 232.94,98.23
GND on BOTTOM (solid shape): 243.21,100.6 243.21,97.7 243.03,97.52 240.17,97.52 239.58,98.11 239.58,100.72 239.97,101.11 242.7,101.11
GND on BOTTOM (solid shape): 261.88,124.29 261.88,121.54 261.67,121.33 259.02,121.33 258.65,121.7 258.65,124.32 258.91,124.58 261.59,124.58
GND on BOTTOM (solid shape): 273.74,125.16 273.74,121.52 273.41,121.19 272.16,121.19 271.94,121.4 271.94,124.92 272.31,125.28 273.62,125.28
GND on BOTTOM (solid shape): 279.13,32.2 279.13,27.46 278.75,27.08 274.12,27.08 273.9,27.3 273.9,32.17 274.08,32.35 278.99,32.35
GND on BOTTOM (solid shape): 277.82,69.97 277.82,65.72 277.5,65.4 274.01,65.4 273.43,65.97 273.43,69.59 274.01,70.16 277.63,70.16
GND on BOTTOM (solid shape): 214.03,32.11 214.03,31.74 213.7,31.41 213.7,26.78 213.42,26.5 212.52,26.5 212.24,26.79 212.24,32.13 212.33,32.21 213.93,32.21
GND on BOTTOM (solid shape): 266.56,147.58 266.56,142.73 266.77,142.52 266.77,141.94 266.71,141.89 260.49,141.89 260.16,142.22 260.16,146.84 261.25,147.93 266.21,147.93
GND on BOTTOM (solid shape): 282.5,70.41 283.4,70.41 283.48,70.34 283.48,69.12 283.38,69.02 282.97,69.02 281.99,69.99 281.99,70.43 282.1,70.54 282.37,70.54
GND on BOTTOM (solid shape): 319.54,21.81 319.54,20.76 319.38,20.61 317.81,20.61 317.8,20.61 316.02,20.61 315.82,20.81 315.82,21.68 316.31,22.16 319.19,22.16
GND on BOTTOM (solid shape): 340.48,30.44 340.48,29.55 340.4,29.47 339.74,29.47 339.57,29.63 339.16,29.63 338.93,29.86 338.93,30.5 339.21,30.78 340.14,30.78
GND on BOTTOM (solid shape): 358.24,24.35 358.24,23.25 357.95,22.95 356.31,22.95 355.96,23.31 355.96,24.16 355.68,24.44 355.68,24.93 355.86,25.11 357.48,25.11
GND on BOTTOM (solid shape): 91.92,5.06 91.92,4.37 91.59,4.04 90.71,4.04 89.74,5.01 87.18,5.01 86.88,5.31 86.88,6.9 87.04,7.07 89.92,7.07
GND on BOTTOM (solid shape): 143.6,6.76 143.6,6.11 143.04,5.54 140.97,5.54 140.96,5.55 140.43,5.55 140.3,5.68 140.3,6.39 140.86,6.96 143.41,6.96
GND on BOTTOM (solid shape): 10.13,21.69 10.13,21.36 10.23,21.26 10.23,20.04 10.27,20 10.27,19.55 10.18,19.46 8.86,19.46 8.46,19.87 8.46,21.73 8.55,21.83 9.99,21.83
GND on BOTTOM (solid shape): 21.25,9.38 21.77,9.38 21.83,9.31 21.83,6.25 21.71,6.13 20.44,6.13 20.26,6.3 20.26,9.72 20.3,9.76 20.87,9.76
GND on BOTTOM (solid shape): 24.51,18.65 24.51,13.02 24.47,12.98 19.93,12.98 19.89,13.02 19.89,17.45 19.96,17.51 23.55,17.51 23.79,17.75 23.79,18.66 23.85,18.72 24.45,18.72
GND on BOTTOM (solid shape): 64.82,16.93 64.82,14.96 64.69,14.84 63.16,14.84 63.03,14.97 63.01,14.97 63.01,16.83 63.24,17.05 64.7,17.05
GND on BOTTOM (solid shape): 79.17,25.79 79.17,23.59 78.94,23.36 77.46,23.36 77.33,23.49 75.63,23.49 75.28,23.84 75.28,25.55 75.82,26.1 78.86,26.1
GND on BOTTOM (solid shape): 89,20.58 89,17.43 88.27,16.69 86.61,16.69 86.58,16.73 86.58,17.18 86.86,17.46 86.86,18.91 87.05,19.1 87.05,21.29 87.19,21.44 88.14,21.44
GND on BOTTOM (solid shape): 202.82,73.96 202.82,70.33 202.81,70.32 202.81,69.83 202.38,69.4 200.63,69.4 200.14,69.89 196.97,69.89 196.83,70.03 196.83,74.4 197.02,74.58 202.19,74.58
GND on BOTTOM (solid shape): 339.77,29.22 340.45,29.22 340.89,28.78 340.89,28.44 340.49,28.04 340.49,27.52 340.41,27.43 339.94,27.43 338.67,28.71 338.67,28.93 339.25,29.51 339.48,29.51
GND on BOTTOM (solid shape): 260.63,12.21 260.63,10.16 260.52,10.05 260.52,9.54 260.97,9.08 260.97,8.14 260.62,7.78 255.73,7.78 254.76,8.75 254.76,11.89 255.34,12.48 260.36,12.48
GND on BOTTOM (solid shape): 16.7,15.44 16.7,14.8 16.66,14.75 15.24,14.75 15.03,14.54 14.33,14.54 14.18,14.7 14.18,14.96 14.32,15.11 14.43,15.11 14.44,15.11 14.49,15.11 14.87,15.5 16.64,15.5
GND on BOTTOM (solid shape): 26.39,10.31 26.69,10.31 26.84,10.16 26.84,8.37 28.32,6.89 28.32,6.36 28.17,6.21 26.66,6.21 26.33,6.54 26.33,7.93 26.02,8.24 26.02,10.3 26.08,10.35 26.35,10.35
GND on BOTTOM (solid shape): 39.52,31.19 39.61,31.2 39.63,31.2 39.74,31.09 39.74,28.86 39.6,28.72 38.94,28.72 38.85,28.8 38.85,30.95 39.12,31.21 39.42,31.21
GND on BOTTOM (solid shape): 94.75,24.57 94.75,23.99 94.66,23.9 93.96,23.9 93.84,23.78 93.84,23.72 93.84,23.72 93.84,21.44 93.68,21.29 92.64,21.29 92.34,21.58 92.34,24.45 92.61,24.72 94.6,24.72
GND on BOTTOM (solid shape): 369.43,10.65 369.43,9.84 369.16,9.58 368.73,9.58 368.73,9.62 368.57,9.62 368.51,9.68 364.43,9.68 363.55,10.56 363.55,11.06 363.71,11.22 366.96,11.22 367.15,11.4 368.67,11.4
GND on BOTTOM (solid shape): 17.27,12.57 17.27,12.54 17.27,11.83 16.51,11.07 15.68,11.07 15.61,11.15 15.61,12.32 15.72,12.43 16.59,12.43 16.67,12.43 16.85,12.62 17.23,12.62
GND on BOTTOM (solid shape): 20.8,22.82 21.18,22.82 21.3,22.71 21.3,20.81 21.43,20.68 21.43,20.44 21.28,20.3 21.03,20.3 20.87,20.45 20.87,21.8 19.86,22.8 19.86,22.98 20.02,23.14 20.48,23.14
GND on BOTTOM (solid shape): 211.16,125.84 211.16,120.04 210.8,119.68 210.16,119.68 209.99,119.85 209.99,120.89 209.5,121.39 209.5,121.9 209.34,122.06 209.34,122.07 209.13,122.28 209.13,125.51 209.71,126.09 210.91,126.09
GND on BOTTOM (solid shape): 201.19,51.5 201.19,49.94 200.89,49.64 200.89,46.47 200.71,46.29 199.86,46.29 199.74,46.4 199.74,46.65 199.72,46.67 199.72,51.08 199.92,51.28 200.43,51.28 200.76,51.6 201.09,51.6
GND on BOTTOM (solid shape): 242.39,109.44 242.39,109.24 242.75,108.89 242.75,107.78 242.3,107.33 241.43,107.33 241.28,107.48 241.28,107.73 241.43,107.87 241.57,107.87 241.7,108 241.7,109.39 241.89,109.58 242.25,109.58
GND on BOTTOM (solid shape): 252.73,100.93 252.73,100.15 251.4,98.83 251.4,92.46 251.12,92.18 250.58,92.18 250.37,92.39 250.37,95.99 249.84,96.52 249.84,98.94 249.7,99.09 249.7,99.7 250.08,100.08 250.08,101.22 250.23,101.37 252.29,101.37
GND on BOTTOM (solid shape): 29.58,17.81 29.58,16.41 29.4,16.23 28.8,16.23 28.74,16.28 28.74,16.63 28.74,16.69 28.68,16.74 28.68,16.76 28.61,16.76 28.6,16.77 28.38,16.77 28.24,16.92 28.24,17.75 28.4,17.92 29.47,17.92
GND on BOTTOM (solid shape): 47.5,30.49 47.5,30.14 47.72,29.92 48.81,29.92 48.97,29.76 48.97,29.06 48.88,28.97 48.41,28.97 48,29.38 47.02,29.38 46.62,29.79 46.62,30.05 46.66,30.09 46.66,30.54 46.74,30.62 47.37,30.62
GND on BOTTOM (solid shape): 347.83,5.92 363.06,5.92 363.06,5.82 363.03,5.8 362.96,5.77 362.88,5.76 344.42,5.76 344.34,5.77 344.27,5.8 344.24,5.82 344.24,5.92 346.23,5.92 346.68,6.37 347.37,6.37
GND on BOTTOM (solid shape): 83.66,54.77 83.66,53.79 82.69,52.82 82.01,52.82 81.92,52.73 81.92,52.2 81.69,51.97 79.86,51.97 79.68,52.14 79.68,53.18 79.82,53.32 80.28,53.32 81.8,54.84 82.98,54.84 83.05,54.91 83.52,54.91
GND on BOTTOM (solid shape): 210.62,108.96 210.62,108.24 210.61,108.24 210.45,108.08 209.93,108.08 209.81,107.96 209.81,106.57 209.75,106.51 208.89,106.51 208.71,106.69 208.71,107.29 208.28,107.73 208.28,109.01 208.41,109.14 210.44,109.14
GND on BOTTOM (solid shape): 80.24,7.85 80.24,4.75 79.28,3.78 75.76,3.78 75.74,4.47 75.6,5.14 75.6,6.73 75.69,6.82 77.08,6.82 78.3,8.04 80.06,8.04
GND on BOTTOM (solid shape): 132.72,46.03 132.72,45.64 133.05,45.32 133.58,45.32 133.66,45.25 133.66,40.96 133.6,40.9 130.24,40.9 130.2,40.94 130.2,44.65 130.13,44.72 129.72,44.72 129.67,44.77 129.67,45.19 129.77,45.29 130.26,45.29 130.63,45.66 130.63,45.97 130.78,46.12 132.63,46.12
GND on BOTTOM (solid shape): 238.83,66.73 238.83,65.47 238.89,65.41 238.89,65.39 238.97,65.31 238.97,62.92 238.97,62.83 238.8,62.67 237.18,62.67 237.06,62.8 237.06,64.45 236.8,64.7 234.52,64.7 234.39,64.83 234.39,66.49 234.51,66.61 235.41,66.61 235.66,66.86 238.71,66.86
GND on BOTTOM (solid shape): 53.83,24 53.83,23.05 53.83,23.05 53.83,22.88 54.04,22.67 54.4,22.67 54.46,22.61 54.46,21.14 54.27,20.94 51.74,20.94 51.7,20.99 51.7,21.53 51.75,21.58 52.4,21.58 52.59,21.77 52.59,23.29 53.06,23.77 53.06,23.93 53.28,24.15 53.69,24.15
GND on BOTTOM (solid shape): 92.43,43.26 92.43,42.69 90.96,41.21 86.12,41.21 85.77,41.57 85.77,42.95 85.85,43.04 86.26,43.04 86.51,42.79 86.54,42.79 86.61,42.71 89.7,42.71 89.77,42.79 89.82,42.79 90.02,42.98 90.02,43.03 90.04,43.05 90.04,43.3 90.13,43.4 90.5,43.4 90.58,43.48 92.22,43.48
GND on BOTTOM (solid shape): 239.02,100.18 239.02,99.32 238.53,98.83 238.53,98.38 238.43,98.28 238.38,98.23 238.38,97.15 238.33,97.1 237.32,97.1 237.26,97.16 237.26,98.13 237.31,98.18 237.6,98.18 237.71,98.29 237.71,100.2 237.87,100.37 238.83,100.37
GND on BOTTOM (solid shape): 166.35,58.44 166.91,57.88 166.94,57.86 166.97,57.84 167.58,57.22 167.58,53.24 166.82,52.48 163.32,52.48 162.3,53.49 162.27,53.54 162.22,53.58 161.07,54.72 161.07,55.96 163.56,58.45 166.34,58.45
GND on BOTTOM (solid shape): 33.34,20.41 33.34,20.37 33.37,20.37 33.37,20.14 33.34,20.13 33.17,19.94 33.16,19.69 33.16,19.69 33.16,19.47 32.74,19.05 31.18,19.05 30.75,19.49 30.75,19.99 30.93,20.17 32.71,20.17 33.07,20.53 33.23,20.53
GND on BOTTOM (solid shape): 226,102.56 226,102.13 226.01,102.13 226.01,101.33 226.02,101.31 226.81,101.31 226.97,101.15 226.97,98.48 226.82,98.33 226.82,97.16 226.77,97.11 226.39,97.11 226.25,97.26 226.25,97.37 224.77,98.85 224.77,98.86 224.15,99.48 224.15,102.63 224.41,102.57 224.63,102.74 224.78,102.9 225.67,102.9
GND on BOTTOM (solid shape): 188.31,122.21 188.31,121.23 188.61,120.93 192.58,120.93 192.88,120.64 192.88,116.71 192.82,116.65 192.82,115.74 193.17,115.38 193.17,114.07 192.76,113.66 189.93,113.66 189.8,113.78 189.8,114.97 189.15,115.62 189.15,117.52 188.47,118.19 188.47,118.86 188.6,118.98 189.33,118.98 189.44,119.09 189.44,119.96 189.27,120.12 188.43,120.12 187.54,121.01 187.54,122.19 187.7,122.35 188.18,122.35
GND on BOTTOM (solid shape): 218.48,132.79 218.48,131.82 218.73,131.56 218.73,131.32 218.73,130.93 218.62,130.82 218.04,130.82 217.6,130.39 217.6,128.52 217.24,128.15 215.71,128.15 215.03,127.46 215.03,126.39 214.77,126.14 213.27,126.14 211.75,127.66 208.33,127.66 208.12,127.88 208.12,129.98 208.33,130.19 212.8,130.19 214.04,131.42 216.81,131.42 217.42,132.03 217.42,132.62 217.66,132.85 218.41,132.85
GND on BOTTOM (solid shape): 183.35,88.82 183.35,87.73 183.45,87.63 184.31,87.63 184.44,87.77 184.76,87.77 184.87,87.65 184.87,87.42 184.75,87.3 184.43,87.3 184.32,87.41 183.45,87.41 183.35,87.32 183.35,83.94 183.21,83.8 181.21,83.8 181.01,84 181.01,84.58 181.05,84.62 181.07,84.62 181.23,84.72 181.33,84.88 181.33,84.9 181.39,84.95 181.39,85.17 181.99,85.77 182.35,86.13 182.35,88.82 182.39,88.86 183.31,88.86
GND on BOTTOM (solid shape): 235.76,100.19 235.76,98.44 235.57,98.25 235.57,97.16 235.49,97.08 234.42,97.08 234.34,97.16 234.34,98.26 234.26,98.34 234.17,98.34 233.96,98.55 233.96,99.76 234.05,99.85 234.08,99.84 234.18,99.84 234.29,99.86 234.36,99.86 234.45,99.95 234.45,100 234.46,100.01 234.5,100.12 234.5,100.23 234.52,100.31 234.6,100.35 235.6,100.35
GND on BOTTOM (solid shape): 68.83,15.51 68.83,14.46 69.27,14.02 69.27,11.57 69.28,11.57 69.28,10.19 70.09,9.38 70.09,8.62 70.39,8.32 70.39,7.98 70.32,7.92 69.9,7.92 69.62,7.64 69.17,7.64 68.21,6.67 67.68,6.67 67.22,7.14 67.22,7.24 67.18,7.28 67.18,7.72 67.67,8.21 67.67,8.74 67.78,8.85 67.78,8.86 67.82,8.89 67.82,9.72 68.35,10.25 68.35,10.88 68.52,11.05 68.52,12.48 68.09,12.91 68.09,14.1 68.16,14.18 68.54,14.55 68.54,15.5 68.64,15.6 68.73,15.6
GND on BOTTOM (solid shape): 240.04,109.42 240.04,109.29 240.07,109.26 240.07,109.24 240.17,109.07 240.34,108.97 240.38,108.96 240.38,108.03 240.3,107.95 240.28,107.95 240.04,107.79 239.98,107.51 239.98,107.48 239.85,107.35 239.12,107.35 239.12,107.37 238.98,107.37 238.87,107.48 238.87,107.74 239.03,107.89 239.29,107.89 239.29,108.15 239.29,109.34 239.53,109.58 239.88,109.58
GND on BOTTOM (solid shape): 15.62,35.86 15.62,35.28 15.67,35.24 15.67,34.75 15.95,34.47 15.97,34.47 15.98,34.46 16.7,34.46 16.75,34.41 16.75,34.37 16.74,34.36 16.74,34.27 16.88,34.13 17.1,34.13 17.17,34.06 17.27,34.06 17.4,33.93 17.4,33.69 17.29,33.58 17.29,33.58 16.96,33.54 16.81,33.25 16.81,33.23 16.76,33.18 15.69,33.18 15.69,33.17 14.07,33.17 13.99,33.25 13.99,33.81 14.08,33.91 14.66,33.91 14.85,34.09 14.85,35.66 15.25,36.06 15.43,36.06
GND on BOTTOM (solid shape): 26.52,31.97 26.52,31.54 27.19,30.87 27.19,26.06 27.5,25.75 28.27,25.75 28.58,25.44 28.58,25.2 27.31,23.93 26.63,23.25 24.09,23.25 24,23.16 24,22.87 23.85,22.72 23.73,22.72 23.42,22.4 22.81,22.4 22.72,22.49 22.72,23.04 22.42,23.34 18.97,23.34 17.97,24.33 17.97,31.05 18.57,31.65 18.61,31.65 19.11,32.16 20.03,32.16 20.54,31.65 24,31.65 24.2,31.45 24.2,31.09 23.93,30.82 20.75,30.82 20.27,30.33 20.27,24.57 20.3,24.53 25.12,24.53 25.14,24.56 25.14,31.57 25.14,31.57 25.14,31.78 25.53,32.17 26.32,32.17
GND on BOTTOM (solid shape): 246.96,109.53 246.96,109.18 246.73,108.95 246.73,107.53 246.65,107.45 246.18,107.45 246.1,107.49 246.08,107.57 246.06,107.79 245.9,107.94 245.89,107.95 245.84,107.99 245.53,107.99 245.41,108.1 245.41,109.06 245.5,109.14 245.71,109.14 246.04,109.07 246.25,109.33 246.25,109.34 246.53,109.63 246.87,109.63
GND on BOTTOM (solid shape): 305.72,17.81 305.72,16.26 305.56,16.11 304.91,16.11 304.65,15.85 304.64,15.84 304.64,13.21 304.53,13.1 304.29,13.1 304.2,13.14 304.16,13.23 304.07,13.46 303.85,13.58 303.55,13.48 303.45,13.17 303.46,13.1 301.58,13.1 301.35,13.33 301.35,17.5 301.77,17.92 305.6,17.92
GND on BOTTOM (solid shape): 233.56,109.51 233.56,109.21 233.42,109.08 233.32,109.08 233.32,108.98 233.32,108.97 233.32,107.85 233.43,107.73 233.43,107.44 233.35,107.36 233.13,107.36 233.13,107.35 233.01,107.35 232.91,107.25 232.91,105.76 232.86,105.71 232.34,105.71 232.29,105.75 232.29,107.39 232.3,107.41 232.35,107.58 232.3,107.76 232.29,107.78 232.29,107.93 232.21,108.02 232.21,108.97 232.28,109.05 232.36,109.05 232.68,109.01 232.9,109.24 232.9,109.26 233.22,109.57 233.5,109.57
GND on BOTTOM (solid shape): 111.58,41.32 111.58,40.37 111.84,40.1 114.6,40.1 114.88,39.82 114.88,38.35 114.88,38.35 114.88,38.27 115.27,37.89 116.19,37.89 116.26,37.82 116.26,37.71 116.2,37.65 115.31,37.65 115.25,37.65 114.91,37.3 114.91,36.86 114.83,36.79 112.78,36.79 112.37,36.38 112.37,35.42 112.31,35.36 112.22,35.36 112.15,35.43 112.15,36.35 111.81,36.68 108.68,36.68 108.38,36.38 108.38,35.42 108.31,35.35 108.21,35.35 108.15,35.42 108.15,36.36 107.62,36.88 107.62,39.83 108.13,40.34 108.13,41.32 108.2,41.38 108.32,41.38 108.37,41.33 108.37,40.39 108.65,40.12 111.09,40.12 111.33,40.36 111.33,41.3 111.42,41.39 111.5,41.39
GND on BOTTOM (solid shape): 235.26,109.61 235.35,109.57 235.36,109.47 235.39,109.18 235.64,109.01 235.68,109 235.68,107.89 235.85,107.72 235.85,107.69 235.83,107.6 235.84,107.49 235.6,107.25 235.6,105.78 235.47,105.66 234.99,105.66 234.87,105.78 234.87,107.15 234.72,107.3 234.72,107.34 234.71,107.34 234.71,107.43 234.72,107.44 234.74,107.58 234.72,107.72 234.71,107.73 234.71,107.83 234.58,107.97 234.58,109.35 234.83,109.61
GND on BOTTOM (solid shape): 317.07,12.18 317.07,11.65 317.03,11.56 316.93,11.52 316.53,11.17 316.93,10.82 317.03,10.78 317.07,10.69 317.07,8.69 316.85,8.48 316.59,8.48 316.47,8.59 316.47,8.99 316.19,9.27 315.89,9.27 315.87,9.29 315.29,9.29 315.21,9.37 315.21,12.17 315.38,12.34 316.92,12.34
GND on BOTTOM (solid shape): 231.95,100.28 231.95,100.03 231.82,99.91 231.8,99.92 231.4,99.74 231.47,99.31 231.47,98.43 231.41,98.37 230.73,98.37 230.65,98.3 230.57,98.3 230.51,98.24 230.51,97.17 230.43,97.09 229.41,97.09 229.39,97.11 229.39,98.2 229.5,98.32 229.5,99.12 229.29,99.34 229.19,99.34 229.08,99.45 229.08,99.73 229.2,99.85 229.23,99.84 229.4,99.84 229.56,99.92 229.57,99.94 229.65,99.94 229.69,99.98 229.69,100.35 229.74,100.4 231.83,100.4
GND on BOTTOM (solid shape): 216.28,65.78 216.28,61.15 216.09,60.96 212.36,60.96 211.84,61.47 211.84,62.4 215.42,62.4 215.42,62.35 215.43,62.29 215.45,62.24 215.47,62.19 215.5,62.15 215.54,62.11 215.58,62.08 215.62,62.05 215.67,62.03 215.73,62.02 215.78,62.02 215.83,62.02 215.88,62.03 215.93,62.05 215.98,62.08 216.02,62.11 216.06,62.15 216.09,62.19 216.11,62.24 216.13,62.29 216.13,62.35 216.13,62.4 216.13,62.45 216.11,62.5 216.09,62.55 216.06,62.6 216.02,62.63 215.98,62.67 215.93,62.69 215.88,62.71 215.83,62.73 215.78,62.73 215.73,62.73 215.67,62.71 215.62,62.69 215.58,62.67 215.54,62.63 215.5,62.6 215.47,62.55 215.45,62.5 215.43,62.45 215.42,62.4 211.84,62.4 211.84,63.65 210,65.49 205.95,65.49 205.43,66.01 205.43,69.43 206.13,70.13 211.93,70.13
GND on BOTTOM (solid shape): 268.54,129.92 268.54,128.52 268.4,128.37 267.38,128.37 267.14,128.13 267.14,125.2 267.36,124.97 267.89,124.97 268.18,124.68 268.18,123.74 267.85,123.41 267.85,120.24 267.7,120.09 262.82,120.09 262.71,120.2 262.57,120.25 262.55,120.26 262.41,120.4 262.41,122.36 262.61,122.57 264.16,122.57 264.4,122.8 264.4,124.62 264.44,124.68 264.47,124.74 264.47,124.88 264.41,125 264.4,125.04 264.42,125.09 264.81,125.48 264.81,126.07 264.92,126.18 264.92,129.84 265.02,129.94 266.15,129.94 266.17,129.91 266.17,129.56 266.16,129.55 266.16,129.15 266.19,129.13 266.86,129.13 267.2,129.47 267.2,129.75 267.4,129.95 268.51,129.95
GND on BOTTOM (solid shape): 244.62,109.52 244.62,109.27 244.48,109.14 244.32,109.14 244.14,108.96 244.14,107.87 244.21,107.8 244.65,107.8 244.74,107.7 244.74,107.45 244.97,107.22 244.97,106.87 244.98,106.84 245.12,106.7 245.15,106.7 245.18,106.67 245.56,106.56 245.56,106.33 245.45,106.21 245.13,106.21 245.11,106.2 245.09,106.2 244.98,106.09 244.98,105.63 245.15,105.46 245.5,105.46 245.57,105.38 245.57,105.09 245.46,104.99 245.13,104.99 245.12,104.97 245.06,104.97 244.97,104.89 244.97,104.41 245.11,104.27 245.14,104.27 245.17,104.23 245.57,104.13 245.57,103.78 245.53,103.74 244.32,103.74 244.11,103.95 244.11,106.9 243.68,107.33 243.68,109.03 243.68,109.05 243.71,109.11 243.72,109.17 243.72,109.19 244.14,109.61 244.52,109.61
GND on BOTTOM (solid shape): 276.79,84.21 276.79,83.92 276.44,83.58 275.63,83.58 272.01,79.95 271.01,79.95 270.91,80.05 270.91,83.19 271,83.28 271.72,83.28 271.85,83.15 271.85,82.84 271.86,82.83 271.86,82.62 272.11,82.36 272.11,82.04 272.46,81.69 272.56,82.17 272.56,82.41 272.67,82.52 273.56,82.52 273.72,82.68 273.72,83.39 273.59,83.53 273.05,83.53 272.93,83.65 272.93,84.12 273.1,84.29 274.41,84.29 274.43,84.31 275.81,84.31 276,84.36 276.15,84.51 276.48,84.51
GND on BOTTOM (solid shape): 251.45,109.63 251.67,109.63 251.78,109.52 251.78,109.25 252.06,108.97 252.57,108.97 252.61,108.93 252.61,107.55 252.44,107.38 252.23,107.38 252.06,107.21 252.06,106.83 252.18,106.71 252.33,106.71 252.37,106.7 252.41,106.7 252.55,106.7 252.64,106.6 252.64,106.19 252.58,106.13 252.4,106.13 252.27,106.12 252.22,106.07 252.17,106.03 252.14,105.99 252.04,105.9 252.04,105.74 252.1,105.69 252.11,105.68 252.22,105.54 252.4,105.49 252.54,105.49 252.63,105.4 252.63,105.02 252.54,104.92 252.21,104.92 252.07,104.78 252.07,104.42 252.23,104.27 252.55,104.27 252.64,104.17 252.64,103.73 252.54,103.63 251.58,103.63 251.23,103.98 251.23,107.94 251.26,107.94 251.26,109.12 251.23,109.12 251.23,109.51 251.35,109.63
GND on BOTTOM (solid shape): 237.3,109.64 237.34,109.65 238.02,109.65 238.06,109.64 238.22,109.65 238.35,109.51 238.35,109.22 238.21,109.08 238.05,109.08 238.05,107.91 238.16,107.8 238.16,107.73 238.15,107.72 238.13,107.58 238.15,107.45 238.16,107.44 238.16,107.36 238.12,107.33 238.12,106.08 238.13,106.08 238.13,105.74 238.37,105.5 238.37,101.11 238.14,100.88 236.37,100.88 236.25,101.01 236.25,105.22 236.7,105.67 236.67,105.69 236.67,107.22 236.72,107.26 236.75,107.25 236.92,107.24 237.07,107.3 237.08,107.31 237.12,107.31 237.18,107.37 237.18,107.45 237.19,107.45 237.18,107.74 236.97,107.93 236.96,107.93 236.93,107.96 236.93,109.44 237.14,109.65
GND on BOTTOM (solid shape): 247.5,150.09 247.58,150.05 247.59,149.95 247.72,149.51 248.18,149.56 248.25,149.6 248.32,149.56 248.78,149.51 248.91,149.95 248.92,150.05 249,150.09 249.98,150.09 252.95,147.12 252.95,145.37 252.72,145.14 229.58,145.14 229.07,145.65 229.07,149.2 229.96,150.09
GND on BOTTOM (solid shape): 366.65,6.21 368.78,6.9 370.95,6.33 370.95,4.4 368.89,4.4 367.39,2.9 368.89,1.4 370.95,1.4 370.95,0 366.65,0
GND on BOTTOM (solid shape): 200.99,35.54 200.99,35.42 200.8,35.01 201.16,34.74 201.16,34.61 200.8,34.19 201.3,33.93 201.3,32.87 201.22,32.8 200.97,32.45 201.3,32.17 201.81,32.17 202.13,31.86 202.13,30.39 202.02,30.29 201.21,30.29 200.14,31.36 200.14,35.45 200.34,35.65 200.88,35.65
GND on BOTTOM (solid shape): 225.77,109.15 225.77,108.56 225.49,108.28 225.49,107.61 225.79,107.31 226.59,107.31 226.73,107.17 226.73,106.23 225.75,105.25 224.84,105.25 224.34,104.75 224.31,104.75 223.76,104.75 223.13,105.37 222.68,105.37 222.48,105.58 222.48,106.24 222.68,106.44 223.77,106.44 223.85,106.36 223.85,105.93 223.95,105.83 223.97,105.83 224,105.8 224.63,105.8 224.89,106.07 224.89,106.09 224.9,106.09 224.99,106.06 225.09,106.05 225.37,106.34 225.14,106.67 225.03,106.69 224.89,106.65 224.89,106.85 224.78,106.97 224.78,107.38 224.77,107.39 224.77,107.49 224.88,107.6 224.88,108.37 224.74,108.51 224.4,108.51 224.35,108.56 224.35,109.1 224.42,109.17 225.74,109.17
GND on BOTTOM (solid shape): 6.18,63.33 6.18,62.88 6.11,62.81 5.53,62.81 4.98,62.26 4.98,61.71 5.18,61.51 6.17,61.51 6.28,61.4 6.28,60.62 6.68,60.23 6.65,60.18 6.64,60.12 5.97,60.19 5.61,59.62 5.61,59.54 6.25,58.91 6.89,59.54 6.89,59.67 7.01,59.65 7.13,59.67 7.19,59.65 7.27,59.64 7.67,59.24 7.67,57.74 7.53,57.61 6.59,57.61 4.17,60.04 4.17,63.06 4.5,63.39 6.13,63.39
GND on BOTTOM (solid shape): 229.81,48.26 231.45,48.26 231.98,47.74 231.98,46.95 231.84,46.81 231.84,45.1 231.76,45.03 231.58,45.03 231.52,45.09 231.53,45.18 231.53,46.62 231.18,46.98 230.82,46.62 230.82,45.18 230.82,45.16 230.78,45.07 230.69,45.03 230.66,45.03 230.57,45.07 230.53,45.16 230.53,45.18 230.53,46.62 230.18,46.98 229.82,46.62 229.82,45.18 229.82,45.16 229.78,45.07 229.69,45.03 229.45,45.03 229.45,46.62 229.44,46.72 229.39,46.8 229.39,47.95 228.72,48.63 228.52,48.63 228.49,48.65 228.47,48.7 228.5,48.74 228.54,48.79 228.57,48.83 229.24,48.83
GND on BOTTOM (solid shape): 370.78,10.91 370.89,10.84 370.88,10.71 370.78,10.52 370.75,10.3 370.75,4.4 368.89,4.4 367.39,2.9 368.89,1.4 370.75,1.4 370.75,0.2 364.45,0.2 364.45,5.56 364.2,6.09 363.64,6.25 363.5,6.32 363.53,6.46 363.78,6.72 364.1,6.66 364.39,6.52 364.85,6.07 369.2,6.07 370.29,7.15 370.29,10.3 370.33,10.62 370.47,10.91
GND on BOTTOM (solid shape): 228.89,109.4 228.89,109.18 228.79,109.08 228.6,109.08 228.6,107.72 228.62,107.7 228.62,105.73 228.49,105.6 228.49,102.1 228.42,102.03 227.24,102.03 227.15,102.12 227.15,102.47 227.27,102.59 227.42,102.58 227.51,102.59 227.59,102.59 227.7,102.7 227.7,102.72 227.71,102.74 227.71,103.14 227.33,103.28 227.32,103.28 227.22,103.28 227.15,103.35 227.15,103.67 227.24,103.76 227.28,103.75 227.73,103.93 227.59,104.39 227.56,104.41 227.53,104.42 227.44,104.44 227.35,104.43 227.32,104.43 227.16,104.59 227.16,104.89 227.25,104.98 227.29,104.97 227.42,104.95 227.55,104.98 227.57,104.98 227.62,104.98 227.71,105.08 227.71,105.12 227.72,105.13 227.76,105.26 227.75,105.4 227.74,105.43 227.8,105.5 227.9,105.5 227.91,105.51 227.93,105.51 227.93,105.52 227.94,105.54 227.94,107.14 227.74,107.34 227.68,107.34 227.68,107.35 227.58,107.35 227.51,107.42 227.51,108.93 227.54,108.96 228.14,108.96 228.39,109.21 228.39,109.4 228.52,109.53 228.75,109.53
GND on BOTTOM (solid shape): 121.84,11.43 118.96,16.66 124.92,16.85 125.41,16.85 125.67,16.59 125.67,16.21 125.36,15.9 124.91,12.99 122.4,11.45 122.39,11.44 122.39,10.68 122.24,10.52 121.96,10.52 121.84,10.64 121.84,11.42
GND on BOTTOM (solid shape): outline of 132 points within 60.52,28.25 72.05,38.45
GND on BOTTOM (solid shape): 338.89,22.81 339.13,22.91 339.41,22.91 341.9,20.42 341.9,17.15 341.1,16.34 340.37,16.34 340.29,16.38 340.27,16.46 340.27,16.52 340.23,16.7 340.1,16.83 340.05,16.92 340.1,17 340.1,17.01 340.25,17.39 339.95,17.65 339.56,17.42 339.71,17 339.76,16.91 339.72,16.82 339.68,16.79 339.58,16.64 339.57,16.46 339.54,16.38 339.47,16.34 338.91,16.34 338.24,17.01 338.24,20.15 337.57,20.83 337.57,22.12 337.58,22.12 337.69,22.26 337.73,22.43 337.7,22.59 337.61,22.72 337.52,22.77 337.42,22.8 337.31,22.9 337.31,23.56 337.44,23.69 337.88,23.69
GND on BOTTOM (solid shape): 6.03,48.39 6.17,48.25 6.17,47.67 4.77,46.27 4.77,45.56 4.94,45.39 6.27,45.39 6.35,45.31 6.35,44.75 6.35,44.74 6.33,44.64 6.35,44.53 6.35,44.52 6.35,44.47 6.61,44.2 7.28,44.2 8.33,43.16 8.33,42.49 7.91,42.07 7.91,41.68 8.16,41.43 8.16,40.92 8.09,40.85 7.39,40.85 6.2,42.04 6.26,42.1 6.32,42.11 7.41,42.11 8.13,42.83 7.41,43.55 6.89,43.55 6.87,43.59 6.32,44 5.7,43.72 5.57,43.67 5.47,43.76 4.76,44.22 4.2,43.58 4.2,43.52 4.21,43.46 4.22,43.39 4.17,43.28 4.04,43.3 3.6,43.74 3.6,48 3.99,48.39 4.92,48.39
GND on BOTTOM (solid shape): outline of 98 points within 247.43,103.59 250.35,109.61
GND on BOTTOM (solid shape): 54.37,32.28 54.46,32.3 54.47,32.31 54.74,32.31 54.87,32.28 54.96,32.3 54.97,32.31 55.23,32.31 55.36,32.17 55.36,31.82 55.46,31.72 55.89,31.72 56.12,31.95 56.12,32 56.23,32.11 56.5,32.11 56.6,32.01 56.6,31.14 56.45,30.98 56.41,30.99 56.07,30.84 56.11,30.47 56.14,30.39 56.11,30.3 56.07,29.95 56.39,29.78 56.42,29.78 56.54,29.66 56.54,29.42 56.43,29.32 56.41,29.32 56.36,29.31 56.29,29.29 56.05,29.29 55.99,29.36 55.99,29.37 54.33,29.37 54.19,29.51 54.19,30.57 53.94,30.83 53.81,30.83 53.73,30.91 53.73,31.28 53.77,31.29 53.81,31.29 53.93,31.29 54.04,31.35 54.12,31.38 54.19,31.35 54.62,31.54 54.19,31.72 54.12,31.69 54.04,31.72 53.92,31.78 53.79,31.78 53.75,31.81 53.75,32 53.76,32.06 53.76,32.17 53.88,32.28 53.92,32.29 53.97,32.31 54.24,32.31
GND on BOTTOM (solid shape): outline of 100 points within 229.5,101.01 232.37,109.59
GND on BOTTOM (solid shape): outline of 81 points within 271.72,92.6 284.06,98.92
GND on BOTTOM (solid shape): outline of 635 points within 219.44,126.94 254.37,138.54
GND on BOTTOM (solid shape): outline of 752 points within 215.72,23.08 372.05,154.3
GND on BOTTOM (solid shape): outline of 1198 points within 0.2,0 343.53,154.3
GND on BOTTOM (solid shape): outline of 2813 points within 25.7,33.85 36.23,43.92
GND on IN1 (solid shape): 172.35,13.74 172.35,12.01 172.26,11.92 168.68,11.92 167.45,13.15 167.45,13.65 167.63,13.82 172.27,13.82
GND on IN1 (solid shape): 217.87,130.93 217.87,128.46 216.84,127.42 209.2,127.42 208.51,128.12 208.51,129.23 210.6,131.32 215.46,131.32 215.72,131.57 217.23,131.57
GND on IN1 (solid shape): 228.65,135.28 228.65,132.76 224.73,128.83 220.29,128.83 219.61,129.51 219.61,133.87 221.71,135.97 227.96,135.97
GND on IN1 (solid shape): 193.16,53.45 193.16,50.51 193.01,50.35 191.82,50.35 191.33,50.84 189.55,50.84 189.39,51.01 188.58,51.01 188.56,51.03 188.56,53.95 188.71,54.11 192.51,54.11
GND on IN1 (solid shape): 246.02,137.14 246.36,136.66 246.69,137.14 251.34,137.14 252,136.47 252,134.79 248.6,131.39 248.6,129.41 247.98,128.79 245.62,128.79 245.23,129.19 245.23,132.17 245.23,132.19 245.27,132.34 245.23,132.5 245.23,132.51 245.23,136.88 245.32,136.97 245.81,136.97 245.98,137.14
GND on IN1 (solid shape): 238.9,138.25 239.01,138.19 239.02,138.07 239.34,137.55 239.66,138.07 239.66,138.19 239.77,138.25 243.71,138.25 244.16,137.8 244.16,135.04 240.55,131.43 240.55,129.05 240.01,128.51 237.97,128.51 237.4,129.09 237.4,132.06 237.43,132.08 237.64,132.4 237.43,132.73 237.4,132.75 237.4,137.22 237.45,137.27 237.96,137.22 237.98,137.74 238.13,137.84 238.2,138.01 238.21,138.03 238.43,138.25
GND on IN1 (solid shape): 236.54,137.56 236.54,135.33 233.09,131.89 233.09,128.45 232.14,127.5 230.14,127.5 229.57,128.08 229.57,134.62 229.62,134.72 229.73,134.74 230.13,134.9 230.08,135.32 230.07,135.37 230.09,135.41 230.15,135.86 229.73,136.02 229.67,136.01 229.61,136.04 229.61,136.43 230.06,136.88 230.62,136.69 230.59,137.28 230.79,137.29 230.96,137.4 231.03,137.44 231.11,137.4 231.63,137.36 231.65,137.87 231.62,137.94 231.65,138.01 231.7,138.08 231.73,138.16 231.75,138.21 235.89,138.21
GND on IN1 (solid shape): 370.88,11.03 371,10.95 370.97,10.81 370.81,10.58 370.75,10.3 370.75,4.4 368.89,4.4 367.39,2.9 368.89,1.4 370.75,1.4 370.75,0.2 364.45,0.2 364.45,5.56 364.2,6.09 363.64,6.25 363.62,6.25 363.34,6.13 363.14,5.91 363.03,5.8 362.88,5.76 344.42,5.76 344.34,5.77 344.27,5.8 344.24,5.82 344.24,5.92 346.49,5.92 346.74,6.17 346.74,6.33 346.81,6.4 347.6,6.4 348.08,5.92 362.85,5.92 363.64,6.71 363.9,6.71 364.25,6.6 364.56,6.39 367.81,6.39 370.29,8.87 370.29,10.3 370.36,10.69 370.55,11.03
GND on IN1 (solid shape): outline of 121 points within 215.71,23.03 372.05,154.3
GND on IN1 (solid shape): outline of 985 points within 0.2,0.2 343.23,154.3
GND on IN2 (solid shape): 172.37,13.82 172.37,12.03 172.2,11.85 168.72,11.85 167.45,13.12 167.45,13.65 167.69,13.88 172.31,13.88
GND on IN2 (solid shape): 193.17,53.45 193.17,51.58 192.1,50.51 192.1,50.33 189.24,50.33 188.57,50.99 188.57,53.73 188.86,54.01 192.61,54.01
GND on IN2 (solid shape): 228.61,135.63 228.61,132.78 225.2,129.37 220.33,129.37 219.55,130.14 219.55,134.28 221.34,136.07 228.18,136.07
GND on IN2 (solid shape): 217.73,130.76 217.73,128.48 216.74,127.48 208.99,127.48 208.31,128.16 208.31,129.64 209.52,130.85 210.69,130.85 210.71,130.83 212.2,130.83 212.69,131.33 217.15,131.33
GND on IN2 (solid shape): outline of 118 points within 215.71,23.03 372.05,154.3
GND on IN2 (solid shape): outline of 686 points within 229.74,127.19 253.93,138.35
GND on IN2 (solid shape): outline of 1014 points within 0.2,0.2 371.45,154.3
GND on IN3 (solid shape): 217.75,130.78 217.75,128.54 216.74,127.53 208.85,127.53 208.37,128.01 208.37,129.75 210.04,131.42 217.12,131.42
GND on IN3 (solid shape): 193.08,53.53 193.08,51.46 192.54,50.92 192.05,50.92 192.03,50.93 191.87,50.97 191.7,50.93 191.69,50.92 188.63,50.92 188.48,51.07 188.48,54.03 188.64,54.19 192.43,54.19
