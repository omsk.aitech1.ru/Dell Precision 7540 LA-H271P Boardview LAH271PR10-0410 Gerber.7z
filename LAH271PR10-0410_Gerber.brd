# Allegro board LAH271PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D47: length 64.5
  TOP w0.076: v2(229.88,92.47) UC1.V8
  TOP w0.152: JDIMM4.203 222.93,58.6 222.7,58.38 221.92,58.38 221.61,58.07 221.61,56.35 220.93,55.66 v2(220.78,55.66)
  IN1 w0.076: 222.82,82.17 222.96,82.31 224.68,82.31 229.04,86.67 229.04,90.85 229.16,90.98 229.16,91.72 229.88,92.44 v2(229.88,92.47)
  IN1 w0.14: v2(220.78,55.66) 220.78,55.46 220.32,54.99 220.32,53.84 220.23,53.74 219.97,53.74 219.86,53.86 219.86,55.17 220.35,55.66 220.35,58.26 218.74,59.86 218.74,60.41 218.51,60.64 218.51,62.78 214.38,66.92 214.38,69.55 213.28,70.65 213.28,73.32 219.8,79.83 220.49,79.83 222.82,82.17
  BOTTOM w0.152: JDIMM3.204 222.68,59 221.53,57.86 221.53,55.65 221.31,55.43 221.01,55.43 v2(220.78,55.66)
DDR_B_D48: length 67.7
  TOP w0.076: v2(228.05,94.42) UC1.R11
  TOP w0.152: v2(219.49,56.45) 219.68,56.45 220.04,56.09 220.04,53.73 220.68,53.09 JDIMM4.212
  IN1 w0.076: 221.67,82.97 221.7,83.01 224.66,83.01 228.4,86.75 228.4,90.95 228.6,91.15 228.6,93.88 v2(228.05,94.42)
  IN1 w0.14: v2(219.49,56.45) 219.04,56.91 219.04,57.61 217.33,59.32 217.33,59.86 216.62,60.58 216.62,62.67 211.9,67.39 211.9,73.89 215.68,77.68 215.68,77.87 215.49,78.06 215.3,78.06 213.78,76.54 213.58,76.54 213.39,76.73 213.39,76.93 215.13,78.67 215.81,78.67 218.6,81.45 220.14,81.45 221.67,82.97
  BOTTOM w0.152: v2(219.49,56.45) 219.94,56 219.94,54.05 220.93,53.06 JDIMM3.211
DDR_B_D49: length 68.9
  TOP w0.076: v2(227.14,94.42) UC1.P11
  TOP w0.152: JDIMM4.229 216.43,59.08 215.04,57.7 214.85,57.7 214.61,57.46 214.61,54.87 214.81,54.67 v2(215.12,54.67)
  IN1 w0.076: v2(227.14,94.42) 226.73,94.01 226.58,93.38 226.58,92.84 226.32,92.58 226.32,91.37 225.86,90.92 225.86,87.61 223.04,84.79 219.39,84.79 219.04,85.14
  IN1 w0.14: v2(215.12,54.67) 214.77,55.02 214.68,55.35 214.68,57.01 213.89,57.79 213.89,58.58 211.79,60.67 211.79,62.77 208.47,66.1 208.47,67.7 207.37,68.79 207.37,71.35 207.8,71.78 207.8,76.27 216.67,85.14 219.04,85.14
  BOTTOM w0.152: v2(215.12,54.67) 214.63,55.16 214.63,57.5 215.96,58.83 216.32,58.83 216.68,59.18 JDIMM3.228
DDR_B_D50: length 61.5
  TOP w0.076: UC1.P7 v2(227.14,91.17)
  TOP w0.152: JDIMM4.224 217.68,54.3 v2(217.02,54.95)
  IN1 w0.076: 219.17,83.99 219.62,83.99 219.88,84.26 223.26,84.26 226.65,87.65 226.65,90.72 227.11,91.17 v2(227.14,91.17)
  IN1 w0.14: 219.17,83.99 217.09,83.99 208.91,75.82 208.91,74.57 209.57,73.92 209.57,66.56 212.9,63.23 212.9,62.83 213.39,62.34 213.39,60.64 215.05,58.98 215.05,58.54 215.8,57.8 215.8,55.99 216.39,55.41 216.39,53.56 216.54,53.4 216.88,53.4 217.02,53.54 v2(217.02,54.95)
  BOTTOM w0.152: v2(217.02,54.95) 216.87,54.8 216.87,53.16 217.43,52.6 JDIMM3.225
DDR_B_D51: length 64.5
  TOP w0.076: v2(228.05,92.47) UC1.R8
  TOP w0.152: v2(218.22,55.89) 218.66,56.33 218.66,57.55 219.38,58.26 220.16,58.26 220.93,59.02 JDIMM4.211
  IN1 w0.076: 220.61,83.47 220.66,83.53 224.47,83.53 227.87,86.92 227.87,91.45 227.66,91.65 227.66,92 228.05,92.4 v2(228.05,92.47)
  IN1 w0.14: v2(218.22,55.89) 218,55.67 217.77,55.67 217.53,55.91 217.53,57.56 216.22,58.86 216.22,59.41 214.93,60.7 214.93,62.4 214.03,63.3 214.03,63.7 210.79,66.93 210.79,75.02 210.93,75.15 211.58,75.15 211.72,75.29 211.72,75.56 211.58,75.7 210.93,75.7 210.79,75.84 210.79,76.04 217.31,82.56 219.69,82.56 220.61,83.47
  BOTTOM w0.152: JDIMM3.212 220.68,59.01 219.93,58.26 218.94,58.26 218.64,57.97 218.64,56.31 v2(218.22,55.89)
DDR_B_D52: length 64
  TOP w0.076: v2(228.05,93.77) UC1.R10
  TOP w0.152: v2(218.24,54.6) 218.44,54.6 219.68,53.36 JDIMM4.216
  IN1 w0.076: v2(228.05,93.77) 228.43,93.39 228.43,91.22 228.22,91 228.22,86.8 224.59,83.17 221.35,83.17 221.13,82.95
  IN1 w0.14: v2(218.24,54.6) 217.96,54.32 217.96,53.61 218.14,53.43 218.57,53.43 218.69,53.55 218.69,55.73 219.06,56.1 219.06,56.37 218.69,56.74 218.69,57.44 216.96,59.17 216.96,59.71 216.25,60.42 216.25,62.52 211.53,67.24 211.53,74.05 213.41,75.93 213.41,76.19 212.98,76.62 212.98,77.04 215,79.06 215.68,79.06 218.44,81.82 219.99,81.82 221.13,82.95
  BOTTOM w0.152: v2(218.24,54.6) 219.93,52.91 JDIMM3.215
DDR_B_D53: length 65.2
  TOP w0.076: v2(227.14,93.77) UC1.P10
  TOP w0.152: v2(215.06,57.21) 215.27,57.21 215.45,57.39 215.45,57.6 216.51,58.65 217.17,58.65 217.43,58.91 JDIMM4.225
  IN1 w0.076: 218.7,84.77 218.72,84.79 219,84.79 219.17,84.62 223.16,84.62 226.14,87.61 226.14,90.89 226.54,91.29 226.54,92.53 226.76,92.76 226.76,93.39 v2(227.14,93.77)
  IN1 w0.14: v2(215.06,57.21) 214.32,57.95 214.32,58.67 212.16,60.83 212.16,62.92 208.83,66.25 208.83,70.85 208.69,70.99 208.43,70.99 208.29,70.85 208.29,68.95 208.15,68.81 207.88,68.81 207.74,68.95 207.74,71.19 208.17,71.61 208.17,76.11 216.82,84.77 218.7,84.77
  BOTTOM w0.152: JDIMM3.224 217.68,59.14 216.64,58.1 215.96,58.1 v2(215.06,57.21)
DDR_B_D54: length 60.3
  TOP w0.076: v2(228.05,91.82) UC1.R7
  TOP w0.152: v2(218.2,57.18) 218.2,57.53 219.36,58.7 219.77,58.7 219.93,58.85 JDIMM4.215
  IN1 w0.076: v2(228.05,91.82) 228.05,91.82 228.05,86.87 224.52,83.34 220.99,83.34 220.87,83.21
  IN1 w0.14: v2(218.2,57.18) 218.2,57.41 216.59,59.02 216.59,59.56 215.3,60.85 215.3,62.55 214.4,63.45 214.4,63.85 211.16,67.08 211.16,74.2 212.92,75.96 212.92,76.16 212.74,76.35 212.54,76.35 212.16,75.96 211.96,75.96 211.77,76.15 211.77,76.35 214.84,79.42 215.53,79.42 215.75,79.64 215.75,79.84 215.53,80.06 215.53,80.25 215.72,80.44 215.92,80.44 216.13,80.23 216.33,80.23 216.52,80.42 216.52,80.61 216.31,80.83 216.31,81.03 216.49,81.21 216.69,81.21 216.91,81 217.1,81 217.29,81.19 217.29,81.39 217.08,81.6 217.08,81.8 217.27,81.99 217.46,81.99 217.68,81.77 217.88,81.77 218.29,82.19 219.84,82.19 220.87,83.21
  BOTTOM w0.152: v2(218.2,57.18) 218.2,57.94 218.94,58.68 219.52,58.68 219.68,58.83 JDIMM3.216
DDR_B_D55: length 64
  TOP w0.076: v2(227.14,92.47) UC1.P8
  TOP w0.152: v2(215.06,56.04) 216.68,54.43 JDIMM4.228
  IN1 w0.076: 218.97,84.4 218.99,84.42 223.19,84.42 226.4,87.63 226.4,90.79 226.73,91.13 226.73,92.07 v2(227.14,92.47)
  IN1 w0.14: 218.97,84.4 216.98,84.4 208.55,75.97 208.55,74.14 208.75,73.93 209.03,73.93 209.2,73.76 209.2,73.47 209.06,73.33 208.67,73.33 208.54,73.19 208.54,72.93 208.67,72.79 209.06,72.79 209.2,72.65 209.2,72.38 209.06,72.24 208.67,72.24 208.54,72.1 208.54,71.84 208.67,71.7 209.06,71.7 209.2,71.56 209.2,66.41 212.53,63.07 212.53,62.68 213.02,62.18 213.02,60.49 214.69,58.83 214.69,58.18 215.48,57.39 215.48,55.97 215.38,55.87 215.24,55.87 v2(215.06,56.04)
  BOTTOM w0.152: JDIMM3.229 216.43,54.89 215.27,56.04 v2(215.06,56.04)
DDR_B_D56: length 69.5
  TOP w0.076: v2(224.42,94.42) UC1.L11
  TOP w0.152: JDIMM4.246 212.18,52.42 209.4,55.2 208.57,55.2 v2(208.3,54.93)
  IN1 w0.076: 220.63,91.12 222.34,91.12 222.85,91.63 222.85,91.78 223.11,92.04 223.11,92.05 223.42,92.36 223.42,93.1 223.95,93.63 223.95,93.95 v2(224.42,94.42)
  IN1 w0.14: 220.63,91.12 218.1,91.12 217.75,90.77 216.52,90.77 203.08,77.32 203.08,60.55 204.95,58.68 204.95,58.48 204.76,58.29 204.56,58.29 203.87,58.99 203.67,58.99 203.48,58.8 203.48,58.6 207.16,54.93 v2(208.3,54.93)
  BOTTOM w0.152: JDIMM3.245 212.43,52.44 209.94,54.93 v2(208.3,54.93)
DDR_B_D57: length 69.6
  TOP w0.076: v2(225.31,94.42) UC1.M11
  TOP w0.152: v2(213.84,56.17) 214.31,55.69 214.31,53.94 215.68,52.58 JDIMM4.232
  IN1 w0.076: 221.55,85.28 223.14,85.28 225.58,87.73 225.58,90.91 226.11,91.44 226.11,92.65 225.85,92.91 225.85,93.57 225.76,93.66 225.76,93.97 v2(225.31,94.42)
  IN1 w0.14: 221.55,85.28 219.48,85.28 218.94,85.81 216.43,85.81 207.15,76.53 207.15,75.55 207.01,75.41 206.71,75.41 206.57,75.27 206.57,75 206.71,74.86 207.01,74.86 207.15,74.72 207.15,74.45 207.01,74.31 206.71,74.31 206.57,74.18 206.57,73.91 206.71,73.77 207.01,73.77 207.15,73.63 207.15,73.36 207.01,73.22 206.71,73.22 206.57,73.08 206.57,72.82 206.71,72.68 207.01,72.68 207.15,72.54 207.15,72.05 206.73,71.62 206.73,66.93 206.87,66.79 207.13,66.79 207.27,66.93 207.27,67.41 207.41,67.55 207.68,67.55 207.82,67.41 207.82,65.83 210.87,62.78 210.87,60.68 213.42,58.14 213.42,56.59 v2(213.84,56.17)
  BOTTOM w0.152: v2(213.84,56.17) 214.05,56.17 214.35,55.87 214.35,53.49 215.43,52.42 JDIMM3.233
DDR_B_D58: length 64.7
  TOP w0.076: v2(224.47,91.84) UC1.L7
  TOP w0.152: v2(209.6,56.82) 210.25,56.82 212.43,59 JDIMM4.245
  IN1 w0.076: 221.47,88.97 221.92,88.97 221.99,89.03 222.16,89.03 223.28,90.16 223.28,90.65 v2(224.47,91.84)
  IN1 w0.14: v2(209.6,56.82) 210.25,56.82 210.41,56.98 210.41,57.95 208.89,59.46 207.35,59.46 206.02,60.79 206.02,60.99 206.21,61.18 206.41,61.18 207.35,60.24 207.54,60.24 207.73,60.43 207.73,60.62 204.18,64.17 204.18,76.86 216.51,89.19 219.24,89.19 219.38,89.33 220.01,89.33 220.37,88.97 221.47,88.97
  BOTTOM w0.152: v2(209.6,56.82) 210.44,56.82 210.78,57.16 210.78,57.65 212.18,59.04 JDIMM3.246
DDR_B_D59: length 66.1
  TOP w0.076: v2(225.35,92.47) 225.63,92.15 UC1.M8
  TOP w0.152: JDIMM4.233 215.43,58.71 214.94,58.22 214.68,58.22 213.28,56.83 213.28,56.6 v2(212.52,55.84)
  IN1 w0.076: 221.23,86.05 221.93,86.76 222.98,86.76 223.85,87.63 223.85,87.85 224.36,88.36 224.8,88.36 224.97,88.53 224.97,90.84 225.74,91.61 225.74,92.09 v2(225.35,92.47)
  IN1 w0.14: 221.23,86.05 219.77,86.05 219.15,86.66 216.1,86.66 205.75,76.32 205.75,66.85 207.87,64.74 207.87,64.54 207.68,64.35 207.48,64.35 207.38,64.46 207.19,64.46 207,64.27 207,64.06 208.41,62.65 209.35,62.65 210.07,61.93 210.07,60.44 212.96,57.55 212.96,56.25 212.55,55.84 v2(212.52,55.84)
  BOTTOM w0.152: JDIMM3.232 215.68,59.07 213.86,57.26 213.71,57.26 213.36,56.91 213.36,56.68 v2(212.52,55.84)
DDR_B_D60: length 66.5
  TOP w0.076: v2(224.42,93.77) UC1.L10
  TOP w0.152: JDIMM4.250 211.18,52.71 210,53.89 208.66,53.89 v2(208.45,53.68)
  IN1 w0.076: 220.74,90.29 221.5,90.29 222.06,90.84 222.37,90.84 223.02,91.49 223.02,91.71 223.78,92.47 223.78,93.13 v2(224.42,93.77)
  IN1 w0.14: v2(208.45,53.68) 208.95,54.17 208.95,56.13 207.97,57.11 206.05,57.11 205.26,57.9 205.26,58.1 205.45,58.29 205.65,58.29 206.01,57.92 206.21,57.92 206.4,58.11 206.4,58.31 203.44,61.26 203.44,77.17 216.56,90.29 220.74,90.29
  BOTTOM w0.152: v2(208.45,53.68) 210.28,53.68 211.43,52.53 JDIMM3.249
DDR_B_D61: length 66.1
  TOP w0.076: v2(225.31,93.77) UC1.M10
  TOP w0.152: v2(213.84,55) 213.84,53.56 214.68,52.73 JDIMM4.236
  IN1 w0.076: 221.44,85.66 222.06,86.27 222.83,86.27 224.21,87.64 224.76,87.64 225.28,88.16 225.28,90.89 225.92,91.53 225.92,92.4 225.92,92.4 225.92,92.59 225.68,92.82 225.68,93.4 v2(225.31,93.77)
  IN1 w0.14: v2(213.84,55) 213.19,55.65 213.19,57.84 210.5,60.53 210.5,62.63 209.52,63.61 209.32,63.61 208.75,63.03 208.55,63.03 207.85,63.73 207.85,63.93 208.04,64.12 208.24,64.12 208.55,63.81 208.75,63.81 208.94,64 208.94,64.19 206.12,67.01 206.12,76.16 216.21,86.26 219.05,86.26 219.65,85.66 221.44,85.66
  BOTTOM w0.152: JDIMM3.237 214.43,52.98 213.69,53.71 213.69,54.85 v2(213.84,55)
DDR_B_D62: length 62.8
  TOP w0.076: UC1.M7 v2(225.37,91.81)
  TOP w0.152: v2(212.52,57.16) 212.52,57.77 213.44,58.68 214.18,58.68 214.43,58.92 JDIMM4.237
  IN1 w0.076: 221.16,86.44 221.78,87.06 222.85,87.06 223.48,87.7 223.48,87.94 224.03,88.49 224.03,90.52 224.59,91.08 224.83,91.08 225.37,91.62 v2(225.37,91.81)
  IN1 w0.14: 221.16,86.44 219.9,86.44 219.31,87.03 215.95,87.03 205.31,76.39 205.31,66.77 206.91,65.17 206.91,64.98 206.72,64.79 206.53,64.79 205.72,65.6 205.52,65.6 205.33,65.41 205.33,65.21 208.26,62.28 209.2,62.28 209.69,61.79 209.69,60.27 212.52,57.43 v2(212.52,57.16)
  BOTTOM w0.152: v2(212.52,57.16) 213.08,57.16 214.68,58.75 JDIMM3.236
DDR_B_D63: length 64.4
  TOP w0.076: v2(224.42,92.47) 224.75,92.15 UC1.L8
  TOP w0.152: JDIMM4.249 211.43,58.65 210.77,58 v2(209.58,58)
  IN1 w0.076: v2(224.42,92.47) 224,92.05 224,91.63 223.65,91.28 223.15,91.28 222.51,90.63 222.33,90.63 221.22,89.53 220.55,89.53 220.27,89.8
  IN1 w0.14: 220.27,89.8 216.6,89.8 203.81,77.02 203.81,63.93 205.98,61.77 205.98,61.57 205.79,61.38 205.59,61.38 204.24,62.73 204.04,62.73 203.85,62.55 203.85,62.35 204.98,61.22 204.98,61.02 204.75,60.79 204.75,60.59 204.94,60.41 205.13,60.41 205.36,60.64 205.56,60.64 205.75,60.45 205.75,60.25 205.52,60.02 205.52,59.82 205.71,59.63 205.91,59.63 206.14,59.86 206.33,59.86 206.52,59.67 206.52,59.48 206.29,59.25 206.29,59.05 206.48,58.86 206.68,58.86 206.91,59.09 207.11,59.09 208.37,59.09 209.46,58 v2(209.58,58)
  BOTTOM w0.152: v2(209.58,58) 209.74,57.84 210.57,57.84 211.18,58.44 JDIMM3.250
DDR_B_DQS0: length 65.8
  TOP w0.076: UC1.BP9 v2(257.54,93.64)
  TOP w0.152: v2(273.79,56.09) 273.72,56.16 273.55,56.16 273.08,55.69 272.64,55.69 272.36,55.97 272.36,57.29 272.68,57.61 273.06,57.61 273.21,57.76 273.21,58.17 273.09,58.29 272.71,58.29 272.43,58.58 JDIMM4.13
  IN1 w0.076: 264.04,91.26 264.03,91.27 264.03,91.33 263.31,92.06 262.12,92.06 261.21,92.97 260.9,92.97 259.79,94.08 257.39,94.08 257.31,94 257.31,93.87 v2(257.54,93.64)
  IN1 w0.14: v2(273.79,56.09) 273.79,56.42 273.65,56.56 273.41,56.56 273.1,56.87 273.1,58.28 275.94,61.12 275.94,62.38 276.63,63.06 276.63,68.96 277.81,70.14 277.81,77.5 264.04,91.26
  BOTTOM w0.152: JDIMM3.13 272.43,52.49 273.2,53.27 273.97,53.27 274.26,53.55 274.26,56.4 274.1,56.56 273.95,56.56 273.79,56.4 v2(273.79,56.09)
DDR_B_DQS1: length 62.9
  TOP w0.076: v2(255.42,93.12) 255.18,93.12 255.03,92.97 UC1.BJ9
  TOP w0.152: JDIMM4.34 267.18,52.53 267.4,52.75 267.4,52.94 268.34,53.88 269.37,53.88 269.65,54.16 269.65,55.9 269.5,56.05 269.38,56.05 269.22,55.88 v2(269.22,55.54)
  IN1 w0.076: v2(255.42,93.12) 255.58,93.12 255.73,92.98 255.73,92.87 255.63,92.77 255.63,91.87 256,91.5 257.29,91.5 257.51,91.29 257.51,90.91 258.74,89.68 258.74,87.79 261.28,85.25 262.71,85.25 262.75,85.21 262.77,85.21
  IN1 w0.14: 262.77,85.21 264.27,85.21 271.4,78.09 271.4,64.45 270.16,63.22 270.16,61.19 268.67,59.69 268.67,58.77 268.24,58.35 268.24,56.53 268.75,56.02 269.04,56.02 269.22,55.84 v2(269.22,55.54)
  BOTTOM w0.152: v2(269.22,55.54) 269.12,55.65 268.29,55.65 267.93,56.01 267.93,56.62 268.49,57.18 268.49,57.66 268.34,57.82 268.07,57.82 268,57.74 267.49,57.74 267.18,58.06 JDIMM3.34
DDR_B_DQS2: length 60.6
  TOP w0.076: v2(251.83,93.12) UC1.BF9
  TOP w0.152: JDIMM4.55 261.93,59.16 262.59,58.5 263.14,58.5 264.27,57.37 264.27,55.68 264.03,55.44 264,55.44 263.79,55.44 263.66,55.57 v2(263.66,55.96)
  IN1 w0.076: 259.14,81.9 259.13,81.91 259.13,81.98 258.83,82.27 258.83,82.7 253.55,87.98 253.55,90.25 252.2,91.6 252.2,92.78 252.31,92.89 252.31,93.05 252.23,93.12 v2(251.83,93.12)
  IN1 w0.14: 259.14,81.9 260.59,80.45 262.14,80.45 266.51,76.08 266.51,69.41 265.42,68.32 265.42,65.96 264.56,65.11 264.56,63.44 264.18,63.06 264.18,55.66 264.03,55.51 263.8,55.51 263.66,55.66 v2(263.66,55.96)
  BOTTOM w0.152: JDIMM3.55 261.93,52.47 262.01,52.56 262.01,52.74 261.35,53.4 261.35,53.85 261.68,54.18 262.59,54.18 262.74,54.33 262.74,54.68 262.53,54.89 262.53,55.53 262.86,55.86 263.45,55.87 263.56,55.87 v2(263.66,55.96)
DDR_B_DQS3: length 59.7
  TOP w0.076: v2(249.09,93.12) UC1.BB9
  TOP w0.152: v2(258.55,56.01) 258.38,55.84 257.48,55.84 256.79,55.15 256.79,54.46 257.11,54.13 257.57,54.13 257.73,53.97 257.73,53.74 257.57,53.57 257.11,53.57 256.79,53.24 256.79,52.63 256.68,52.52 JDIMM4.76
  IN1 w0.076: v2(249.09,93.12) 249.49,93.12 249.57,93.05 249.57,92.82 249.47,92.72 249.47,91.3 250.09,90.68 250.09,89.14 250.57,88.66 250.57,84.85 252.67,82.75 253.11,82.75 254.38,81.48 254.38,80.8 254.77,80.41 254.77,80.35 254.78,80.34
  IN1 w0.14: v2(258.55,56.01) 258.55,55.79 258.7,55.64 258.88,55.64 259.02,55.79 259.02,56.92 258.29,57.65 258.29,63.26 259.31,64.28 259.31,64.69 260.15,65.54 260.15,67.28 261.2,68.33 261.2,73.91 254.78,80.34
  BOTTOM w0.152: v2(258.55,56.01) 258.46,55.92 258.46,55.68 258.61,55.52 259.05,55.52 259.2,55.68 259.2,56.91 257.84,58.27 257.1,58.27 256.79,58.58 256.79,58.96 256.68,59.07 JDIMM3.76
DDR_B_DQS4: length 59.3
  TOP w0.076: v2(232.63,93.12) UC1.AA9
  TOP w0.152: v2(226.99,55.91) 226.91,55.83 226.91,55.62 227.04,55.49 227.28,55.49 227.48,55.7 227.48,57.8 227.91,58.23 228.76,58.23 229.13,58.6 229.13,58.92 228.93,59.13 JDIMM4.179
  IN1 w0.076: 227.27,78.97 227.27,79.08 229.45,81.26 229.45,81.79 232.73,85.07 232.73,91.39 233.01,91.67 233.01,92.78 233.09,92.87 233.09,93.07 233.03,93.12 v2(232.63,93.12)
  IN1 w0.14: 227.27,78.97 227.18,78.88 227.18,78.74 221.7,73.26 221.7,66.78 225.22,63.26 225.22,60.22 225.4,60.04 225.4,59.57 226.9,58.07 226.9,57.2 227.46,56.65 227.46,55.65 227.35,55.54 227.13,55.54 226.99,55.69 v2(226.99,55.91)
  BOTTOM w0.152: v2(226.99,55.91) 226.89,55.81 226.56,55.81 226.21,55.46 226.21,54.25 227.17,53.29 228.25,53.29 228.93,52.62 JDIMM3.179
DDR_B_DQS5: length 64
  TOP w0.076: v2(229.88,93.12) UC1.V9
  TOP w0.152: v2(222.82,54.36) 222.82,54.64 222.9,54.72 223.22,54.72 223.39,54.55 223.39,54.34 223.18,54.12 223.18,53.67 223.45,53.39 223.83,53.39 224.22,53.78 224.36,53.78 224.85,53.29 224.85,53.15 224.72,53.02 224.18,53.02 224.08,52.92 223.81,52.92 223.68,52.79 JDIMM4.200
  IN1 w0.076: v2(229.88,93.12) 230.16,92.84 230.16,92.7 230.26,92.6 230.26,86.4 225.79,81.93 223.79,81.93 223.65,81.79 223.59,81.79
  IN1 w0.14: 223.59,81.79 220.82,79.02 220.14,79.02 215.19,74.07 215.19,67.26 219.83,62.61 219.83,59.96 221.23,58.56 221.23,55.69 222.41,54.51 222.67,54.51 v2(222.82,54.36)
  BOTTOM w0.152: v2(222.82,54.36) 222.69,54.49 222.46,54.49 222.19,54.75 222.08,55.03 222.08,57.62 222.22,57.96 222.45,58.19 223.32,58.7 223.68,59.06 JDIMM3.200
DDR_B_DQS6: length 65.7
  TOP w0.076: v2(227.14,93.12) UC1.P9
  TOP w0.152: v2(216.95,56.15) 216.82,56.27 216.16,56.27 215.84,56.6 215.84,57.26 216.87,58.29 217.95,58.29 218.43,58.76 JDIMM4.221
  IN1 w0.076: 219.84,83.68 219.9,83.68 220.13,83.9 224.31,83.9 227.51,87.11 227.51,91.3 227.21,91.6 227.21,92.04 227.51,92.34 227.51,92.75 v2(227.14,93.12)
  IN1 w0.14: 219.84,83.68 219.4,83.24 218.49,83.24 218.18,83.55 217.33,83.55 209.36,75.58 209.36,74.76 210.01,74.1 210.01,66.74 213.35,63.41 213.35,63.01 214.13,62.23 214.13,61.82 213.84,61.53 213.84,60.82 215.5,59.16 215.5,58.58 216.28,57.8 216.28,57.07 216.28,57.03 216.28,56.67 216.55,56.4 216.7,56.4 v2(216.95,56.15)
  BOTTOM w0.152: JDIMM3.221 218.43,52.65 218.54,52.77 218.7,52.77 218.8,52.87 218.8,53.07 217.51,54.36 217.51,56.34 217.37,56.49 217.1,56.49 216.95,56.34 v2(216.95,56.15)
DDR_B_DQS7: length 68
  TOP w0.076: UC1.L9 224.75,92.8 v2(224.42,93.12)
  TOP w0.152: JDIMM4.242 213.18,52.43 213.29,52.54 213.29,52.72 211.94,54.06 211.13,54.06 210.53,54.66 210.53,55.94 210.85,56.26 211.04,56.26 v2(211.28,56.49)
  IN1 w0.076: 222.85,88.09 222.86,88.11 222.92,88.11 223.58,88.77 223.58,90.61 224.41,91.44 224.61,91.44 224.85,91.67 224.85,93.06 224.78,93.12 v2(224.42,93.12)
  IN1 w0.14: v2(211.28,56.49) 211.28,56.17 211.38,56.06 211.58,56.06 211.78,56.26 211.78,57.2 204.63,64.36 204.63,76.68 215.77,87.82 222.57,87.82 222.85,88.09
  BOTTOM w0.152: JDIMM3.242 213.18,59.08 213.29,58.97 213.29,58.24 213.01,57.97 212.84,57.97 212.49,58.31 211.98,58.31 211.58,57.92 211.58,57.37 211.8,57.16 211.8,56.03 211.69,55.92 211.41,55.92 211.28,56.06 v2(211.28,56.49)
DDR_B_DQS8: length 57.2
  TOP w0.076: v2(246.34,93.12) UC1.AW9
  TOP w0.132: v2(252.86,56.45) 252.67,56.64 252.27,56.64 252.14,56.77 251.85,56.77 251.59,57.03 251.59,57.34 251.84,57.59 252.05,57.59 252.18,57.72 252.18,57.99 252.03,58.14 251.79,58.14 251.55,57.9 250.92,57.9 250.68,58.14 250.68,58.51 250.94,58.77 251.24,58.77 251.43,58.96 JDIMM4.97
  IN2 w0.076: v2(246.34,93.12) 246.7,92.76 246.7,91.69 245.18,90.16 245.18,89.32 245.14,89.28
  IN2 w0.119: 245.14,89.28 245.14,86.59 244.8,86.26 244.8,81.5 244.21,80.9 244.21,78.67 253.66,69.22 253.66,59.79 252.01,58.14 252.01,57.1 252.39,56.72 252.62,56.72 252.86,56.48 v2(252.86,56.45)
  BOTTOM w0.132: JDIMM3.97 251.43,52.68 253.57,54.82 253.57,56.52 253.23,56.86 253.05,56.86 252.86,56.67 v2(252.86,56.45)
DDR_B_DQS#0: length 65.8
  TOP w0.076: UC1.BN9 v2(256.89,93.64)
  TOP w0.152: JDIMM4.11 272.93,59.13 272.7,58.91 272.7,58.69 272.83,58.57 273.21,58.57 273.49,58.29 273.49,57.64 273.17,57.33 272.79,57.33 272.64,57.17 272.64,56.08 272.75,55.97 272.97,55.97 273.44,56.44 273.6,56.44 273.81,56.65 v2(273.81,56.93)
  IN1 w0.076: v2(256.89,93.64) 257.06,93.64 257.16,93.74 257.16,94.06 257.32,94.23 259.86,94.23 260.97,93.12 261.27,93.12 262.18,92.21 263.37,92.21 264.13,91.45 264.2,91.45 264.21,91.44
  IN1 w0.14: 264.21,91.44 278.05,77.6 278.05,70.04 276.87,68.86 276.87,62.96 276.18,62.28 276.18,61.02 273.34,58.18 273.34,56.97 273.51,56.8 273.68,56.8 v2(273.81,56.93)
  BOTTOM w0.152: v2(273.81,56.93) 273.9,56.84 274.21,56.84 274.54,56.51 274.54,53.44 274.09,52.99 273.32,52.99 272.93,52.6 JDIMM3.11
DDR_B_DQS#1: length 62.8
  TOP w0.076: v2(255.5,93.72) UC1.BL9
  TOP w0.152: JDIMM4.32 267.68,52.82 268.46,53.6 269.49,53.6 269.93,54.05 269.93,56.01 269.62,56.33 269.31,56.33 v2(269.21,56.43)
  IN1 w0.076: 262.77,85.45 262.75,85.45 262.71,85.41 261.34,85.41 258.89,87.85 258.89,89.74 257.66,90.97 257.66,91.35 257.36,91.65 256.06,91.65 255.78,91.94 255.78,92.7 255.88,92.81 255.88,93.04 255.78,93.15 255.78,93.45 v2(255.5,93.72)
  IN1 w0.14: 262.77,85.45 264.37,85.45 271.64,78.19 271.64,64.35 270.4,63.12 270.4,61.08 268.91,59.59 268.91,58.67 268.48,58.25 268.48,56.63 268.85,56.26 269.04,56.26 v2(269.21,56.43)
  BOTTOM w0.152: JDIMM3.32 267.68,59.18 267.45,58.96 267.45,58.18 267.61,58.02 267.88,58.02 267.95,58.09 268.46,58.09 268.77,57.78 268.77,57.06 268.21,56.5 268.21,56.12 268.41,55.93 269.06,55.93 269.21,56.08 v2(269.21,56.43)
DDR_B_DQS#2: length 60.5
  TOP w0.076: v2(252.74,93.12) UC1.BG9
  TOP w0.152: JDIMM4.53 262.43,59.06 262.7,58.78 263.25,58.78 264.55,57.48 264.55,55.56 264.15,55.16 264,55.16 263.79,55.16 v2(263.66,55.03)
  IN1 w0.076: 259.31,82.07 259.3,82.08 259.24,82.08 258.98,82.34 258.98,82.76 253.7,88.05 253.7,90.31 252.35,91.66 252.35,92.71 252.46,92.82 252.46,93.05 252.53,93.12 v2(252.74,93.12)
  IN1 w0.14: 259.31,82.07 260.69,80.7 262.24,80.7 266.75,76.18 266.75,69.31 265.66,68.22 265.66,65.86 264.8,65 264.8,63.34 264.42,62.96 264.42,55.56 264.13,55.27 263.9,55.27 v2(263.66,55.03)
  BOTTOM w0.152: JDIMM3.53 262.43,52.49 262.29,52.62 262.29,52.85 261.63,53.52 261.63,53.74 261.79,53.9 262.7,53.9 263.02,54.22 263.02,54.8 262.81,55.01 262.81,55.42 262.98,55.58 263.45,55.59 263.5,55.59 263.66,55.43 v2(263.66,55.03)
DDR_B_DQS#3: length 59.7
  TOP w0.076: v2(250,93.12) UC1.BC9
  TOP w0.152: JDIMM4.74 257.18,52.51 257.06,52.62 257.06,53.13 257.23,53.29 257.68,53.29 258.01,53.62 258.01,54.08 257.68,54.41 257.23,54.41 257.06,54.57 257.06,55.03 257.59,55.56 258.51,55.56 258.66,55.41 258.66,55.2 v2(258.55,55.09)
  IN1 w0.076: 254.95,80.51 254.94,80.52 254.87,80.52 254.53,80.86 254.53,81.54 253.17,82.9 252.73,82.9 250.72,84.91 250.72,88.72 250.24,89.2 250.24,90.74 249.63,91.36 249.63,92.66 249.72,92.75 249.72,92.84 v2(250,93.12)
  IN1 w0.14: 254.95,80.51 261.44,74.01 261.44,68.23 260.39,67.18 260.39,65.44 259.55,64.59 259.55,64.18 258.53,63.16 258.53,57.75 259.26,57.02 259.26,55.69 258.98,55.4 258.87,55.4 v2(258.55,55.09)
  BOTTOM w0.152: v2(258.55,55.09) 258.71,55.24 259.16,55.24 259.48,55.56 259.48,57.03 257.96,58.55 257.22,58.55 257.06,58.7 257.06,58.97 257.18,59.08 JDIMM3.74
DDR_B_DQS#4: length 59.3
  TOP w0.076: v2(233.54,93.12) UC1.AC9
  TOP w0.152: JDIMM4.177 229.43,59.05 229.41,59.04 229.41,58.49 228.88,57.95 228.03,57.95 227.76,57.68 227.76,55.58 227.39,55.21 227.14,55.21 v2(226.99,55.06)
  IN1 w0.076: 227.44,78.8 227.45,78.82 227.45,79.05 229.6,81.2 229.6,81.72 232.88,85.01 232.88,91.33 233.16,91.6 233.16,92.72 233.24,92.81 233.24,93.06 233.31,93.12 v2(233.54,93.12)
  IN1 w0.14: 227.44,78.8 227.42,78.78 227.42,78.64 221.94,73.16 221.94,66.88 225.46,63.36 225.46,60.32 225.64,60.14 225.64,59.67 227.14,58.17 227.14,57.3 227.7,56.75 227.7,55.55 227.45,55.3 227.23,55.3 v2(226.99,55.06)
  BOTTOM w0.152: JDIMM3.177 229.43,52.51 228.37,53.57 227.29,53.57 226.49,54.37 226.49,55.34 226.68,55.53 226.89,55.53 226.99,55.43 v2(226.99,55.06)
DDR_B_DQS#5: length 64
  TOP w0.076: v2(230.8,93.12) UC1.W9
  TOP w0.152: JDIMM4.198 224.18,52.62 224.3,52.74 224.83,52.74 225.13,53.04 225.13,53.41 224.47,54.06 224.1,54.06 223.72,53.67 223.57,53.67 223.45,53.79 223.45,54.01 223.67,54.22 223.67,54.66 223.33,55 222.9,55 v2(222.78,55.12)
  IN1 w0.076: 223.76,81.62 223.76,81.62 223.76,81.68 223.85,81.77 225.85,81.77 230.42,86.34 230.42,92.66 230.32,92.76 230.32,92.96 230.48,93.12 v2(230.8,93.12)
  IN1 w0.14: 223.76,81.62 220.92,78.78 220.24,78.78 215.43,73.97 215.43,67.36 220.07,62.71 220.07,60.06 221.47,58.66 221.47,55.79 222.51,54.75 222.67,54.75 222.78,54.86 v2(222.78,55.12)
  BOTTOM w0.152: JDIMM3.198 224.18,58.91 224.03,58.76 223.77,58.76 223.49,58.48 222.62,57.97 222.46,57.8 222.36,57.56 222.36,55.09 222.43,54.91 222.57,54.77 222.69,54.77 222.78,54.85 v2(222.78,55.12)
DDR_B_DQS#6: length 65.7
  TOP w0.076: v2(228.05,93.12) UC1.R9
  TOP w0.152: JDIMM4.219 218.93,58.71 218.8,58.59 218.65,58.59 218.06,58.01 216.98,58.01 216.12,57.14 216.12,56.71 216.28,56.55 216.95,56.55 217.02,56.63 v2(217.02,56.89)
  IN1 w0.076: 220,83.5 220.03,83.52 220.03,83.59 220.19,83.75 224.37,83.75 227.67,87.04 227.67,91.37 227.36,91.67 227.36,91.98 227.67,92.28 227.67,92.86 227.59,92.93 227.59,93.04 227.67,93.12 v2(228.05,93.12)
  IN1 w0.14: v2(217.02,56.89) 217.02,56.72 216.94,56.64 216.65,56.64 216.52,56.77 216.52,57.9 215.74,58.68 215.74,59.26 214.08,60.92 214.08,61.43 214.37,61.72 214.37,62.33 213.59,63.11 213.59,63.51 210.26,66.84 210.26,74.2 209.6,74.86 209.6,75.48 217.43,83.31 218.08,83.31 218.39,83 219.5,83 220,83.5
  BOTTOM w0.152: JDIMM3.219 218.93,52.6 219.08,52.76 219.08,53.19 217.79,54.48 217.79,56.46 217.48,56.77 217.14,56.77 v2(217.02,56.89)
DDR_B_DQS#7: length 68
  TOP w0.076: UC1.M9 225.63,92.8 v2(225.3,93.12)
  TOP w0.152: v2(211.28,55.5) 211.4,55.62 211.4,55.83 211.24,55.98 210.97,55.98 210.81,55.83 210.81,54.78 211.25,54.34 212.06,54.34 213.56,52.84 213.56,52.52 213.68,52.41 JDIMM4.240
  IN1 w0.076: 222.98,87.89 223.01,87.92 223.01,87.98 223.73,88.71 223.73,90.54 224.47,91.28 224.68,91.28 225,91.6 225,92.82 v2(225.3,93.12)
  IN1 w0.14: 222.98,87.89 222.67,87.58 215.87,87.58 204.87,76.58 204.87,64.46 212.02,57.3 212.02,56.16 211.68,55.82 211.38,55.82 211.28,55.72 v2(211.28,55.5)
  BOTTOM w0.152: JDIMM3.240 213.68,59.08 213.56,58.97 213.56,58.12 213.13,57.69 212.72,57.69 212.37,58.03 212.1,58.03 211.86,57.8 211.86,57.49 212.08,57.28 212.08,55.91 211.81,55.64 211.42,55.64 v2(211.28,55.5)
DDR_B_DQS#8: length 57.2
  TOP w0.076: v2(247.26,93.12) UC1.AY9
  TOP w0.132: JDIMM4.95 251.93,59.15 251.33,58.55 251.03,58.55 250.9,58.42 250.9,58.23 251.01,58.12 251.45,58.12 251.7,58.36 252.12,58.36 252.4,58.08 252.4,57.63 252.14,57.37 251.93,57.37 251.81,57.25 251.81,57.12 251.94,56.99 252.23,56.99 252.36,56.86 252.72,56.86 252.85,56.99 v2(252.85,57.29)
  IN2 w0.076: v2(247.26,93.12) 246.95,93.12 246.86,93.03 246.86,91.63 245.33,90.1 245.33,89.34 245.36,89.31 245.36,89.26
  IN2 w0.119: v2(252.85,57.29) 252.85,57.06 252.73,56.94 252.48,56.94 252.23,57.19 252.23,58.05 253.88,59.7 253.88,69.31 244.43,78.76 244.43,80.81 245.03,81.4 245.03,86.17 245.36,86.5 245.36,89.26
  BOTTOM w0.132: JDIMM3.95 251.93,52.86 253.79,54.73 253.79,56.62 253.33,57.08 253.06,57.08 v2(252.85,57.29)
DDR_B_DRAMRST#: length 23.2
  TOP w0.102: v2(249.09,48.63) 248.96,48.75 248.73,48.75 248.39,49.09 248.39,50.61 248.68,50.89 JDIMM4.108
  IN2 w0.081: v2(249.04,58.66) 249.04,51.62 248.14,50.73 248.14,49.13 248.65,48.63 v2(249.09,48.63)
  BOTTOM w0.102: JDIMM3.108 248.68,61.32 248.49,61.5 v1(248.49,62.18) 248.49,62.6 248.67,62.77 CD113.1 248.18,63.75 248.18,65.05 CD78.1
  BOTTOM w0.109: CD78.1 248.75,65.62 RD77.2 ; JDIMM3.108 248.68,59.02 v2(249.04,58.66)
DDR_B_MA0: length 57.3
  TOP w0.076: UC1.AJ9 239.35,92.8 v2(239.03,93.12)
  TOP w0.211: v2(237.86,56.88) 238.46,56.27 238.46,53.23 238.96,52.74 239.45,52.74 239.68,52.52 JDIMM4.144
  IN1 w0.076: v2(239.03,93.12) 238.66,92.76 238.66,91.56 238.43,91.33 238.43,87.54 238.31,87.42 238.31,79.84 235.91,77.45 235.91,77.17
  IN1 w0.188: v2(237.86,56.88) 238.28,57.3 238.28,58.65 236.32,60.61 236.32,61.21 236.14,61.38 235.89,61.38 235.71,61.56 235.71,61.81 235.89,61.99 236.14,61.99 236.32,62.17 236.32,62.49 235.86,62.96 235.61,62.96 235.44,63.14 235.44,63.39 235.61,63.57 235.73,63.57 235.92,63.75 235.92,64.05 235.73,64.23 235.54,64.23 235.35,64.42 235.35,66.54 234.87,67.02 234.87,72.09 234.69,72.26 234.69,73.87 234.87,74.05 235.12,74.05 235.3,73.87 235.3,72.82 235.48,72.64 235.73,72.64 235.91,72.82 235.91,77.17
  BOTTOM w0.211: v2(237.86,56.88) 238.65,57.67 238.65,57.92 237.89,58.68 237.89,58.93 238.08,59.11 238.33,59.11 239.08,58.36 239.34,58.36 239.68,58.7 JDIMM3.144
DDR_B_MA1: length 60.4
  TOP w0.076: UC1.AK6 v2(240.47,90.52)
  TOP w0.211: JDIMM4.133 242.43,59.09 242.07,58.74 242.07,58.46 241.46,57.84 241.46,57.48 241.36,57.38 241.36,56.17 241.56,55.97 241.85,55.97 242.02,56.14 242.02,56.69 242.02,56.69 242.02,56.98 242.04,57 242.04,57.49 v2(242.47,57.92)
  IN1 w0.076: 241.18,78.1 241.18,78.55 241.33,78.71 241.33,89.22 240.86,89.69 240.86,90.13 v2(240.47,90.52)
  IN1 w0.188: v2(242.47,57.92) 242.45,57.94 242.45,63.76 241.24,64.98 241.24,67.48 241.41,67.65 241.67,67.65 241.84,67.48 241.84,65.33 242.02,65.15 242.27,65.15 242.45,65.33 242.45,68.09 243.48,69.12 243.48,69.37 243.3,69.55 243.05,69.55 241.8,68.29 241.54,68.29 241.37,68.47 241.37,68.72 242.88,70.24 243.25,70.24 243.49,70.47 243.49,72.71 243.9,73.12 243.9,73.39 242.44,74.84 242.15,74.84 241.97,75.03 241.97,75.3 241.18,76.09 241.18,78.1
  BOTTOM w0.211: JDIMM3.133 242.43,52.59 241.6,53.42 241.6,55.49 241.72,55.62 241.72,57.23 242.41,57.92 v2(242.47,57.92)
DDR_B_MA2: length 62.3
  TOP w0.076: UC1.AK5 v2(240.46,89.85)
  TOP w0.211: JDIMM4.132 242.68,52.71 242.05,53.34 242.05,54.67 241.65,55.08 241.65,55.35 241.32,55.67 v2(240.89,55.67)
  IN1 w0.076: 240.64,78.09 240.64,78.38 241.17,78.9 241.17,89.15 v2(240.46,89.85)
  IN1 w0.188: 240.64,78.09 240.64,75.87 241.44,75.08 241.44,74.68 241.8,74.31 242.21,74.31 242.96,73.56 242.96,71.06 240.83,68.94 240.83,67.82 240.71,67.7 240.71,64.76 241.95,63.51 241.95,56.51 242.1,56.37 242.1,51.94 242.28,51.75 243.68,51.75 243.86,51.58 243.86,51.32 243.68,51.15 242.28,51.15 242.1,50.96 242.1,50.59 241.91,50.4 241.64,50.4 241.46,50.59 241.46,55.48 241.27,55.67 v2(240.89,55.67)
  BOTTOM w0.211: v2(240.89,55.67) 241.36,56.14 241.36,57.63 242.68,58.94 JDIMM3.132
DDR_B_MA3: length 61.2
  TOP w0.076: UC1.AL5 240.95,90.19 v2(241.28,89.86)
  TOP w0.211: v2(242.47,56.65) 242.6,56.78 243.86,56.78 244.07,56.98 244.07,57.27 243.86,57.47 243.13,57.47 242.92,57.67 242.92,58.08 242.57,58.43 242.57,58.81 242.93,59.16 JDIMM4.131
  IN1 w0.076: v2(241.28,89.86) 241.56,89.58 241.56,88.79 241.76,88.59 241.76,87.81 242.12,87.45 242.12,79.05 241.71,78.63 241.71,78.26
  IN1 w0.188: v2(242.47,56.65) 242.79,56.65 242.98,56.84 242.98,64.32 243.23,64.56 243.23,64.83 242.98,65.08 242.98,65.33 243.16,65.51 243.38,65.51 243.55,65.69 243.55,65.94 243.38,66.12 243.16,66.12 242.98,66.29 242.98,67.87 243.16,68.05 243.41,68.05 244.27,67.19 244.52,67.19 244.7,67.37 244.7,67.62 243.84,68.48 243.84,68.73 244.02,68.9 244.02,72.49 244.2,72.67 244.45,72.67 244.62,72.49 244.62,68.61 244.8,68.43 245.05,68.43 245.23,68.61 245.23,72.8 241.71,76.33 241.71,78.26
  BOTTOM w0.211: v2(242.47,56.65) 242.17,56.65 242.03,56.51 242.03,55.49 241.9,55.37 241.9,53.55 242.93,52.52 JDIMM3.131
DDR_B_MA4: length 65.6
  TOP w0.076: UC1.AL6 240.95,90.84 v2(241.28,90.51)
  TOP w0.211: v2(242.67,53.68) 242.67,53.71 242.87,53.91 243,53.91 243.13,54.05 243.13,55.57 243.32,55.75 243.6,55.75 243.73,55.63 243.73,53.63 243.53,53.43 243.31,53.43 243.13,53.24 243.13,52.95 243.28,52.81 243.33,52.81 243.41,52.73 243.54,52.73 243.68,52.59 JDIMM4.128
  IN1 w0.076: 243,80.57 243,80.81 242.54,81.26 242.54,90.59 242.19,90.94 241.85,90.94 241.42,90.51 v2(241.28,90.51)
  IN1 w0.188: 243,80.57 243,76.54 246.29,73.24 246.29,68.17 245.85,67.72 245.85,65.67 244.18,64 244.18,58.01 244.45,57.74 244.45,53.15 245.53,52.07 245.53,51.07 245,50.53 244.59,50.53 244.41,50.72 244.41,52.04 244.15,52.29 242.85,52.29 242.67,52.48 v2(242.67,53.68)
  BOTTOM w0.211: JDIMM3.128 243.68,58.89 243.53,58.74 243.27,58.74 243.13,58.61 243.13,58.02 243.3,57.86 243.3,57.37 243.02,57.09 243.02,55.81 242.74,55.53 242.5,55.53 242.21,55.24 242.21,53.88 242.41,53.68 v2(242.67,53.68)
DDR_B_MA5: length 61.2
  TOP w0.076: v2(242.12,90.51) 241.79,90.84 UC1.AM6
  TOP w0.211: v2(242.67,55.04) 242.67,55.86 243.04,56.23 243.82,56.23 244.03,56.02 244.03,52.7 244.18,52.56 JDIMM4.126
  IN1 w0.076: 242.47,80.49 242.47,80.89 242.32,81.03 242.32,88.35 241.75,88.93 241.75,90.14 v2(242.12,90.51)
  IN1 w0.188: v2(242.67,55.04) 243.02,55.04 243.21,54.86 243.21,53.03 243.41,52.83 243.72,52.83 243.91,53.02 243.91,55.42 243.73,55.6 243.34,55.6 243.17,55.78 243.17,56.03 243.34,56.21 243.73,56.21 243.91,56.38 243.91,57.17 243.64,57.44 243.64,60.91 243.86,61.13 243.86,62.69 243.52,63.02 243.52,64.1 244.1,64.68 244.1,66.44 244.28,66.61 244.53,66.61 244.71,66.44 244.71,65.9 244.88,65.72 245.14,65.72 245.31,65.9 245.31,67.94 245.76,68.39 245.76,73.02 242.47,76.32 242.47,80.49
  BOTTOM w0.211: v2(242.67,55.04) 243.15,54.57 243.35,54.57 243.47,54.69 243.47,57.11 244.44,58.08 244.44,58.68 244.18,58.95 JDIMM3.126
DDR_B_MA6: length 62.2
  TOP w0.076: UC1.AN7 241.84,91.78 v2(241.77,91.82)
  TOP w0.211: v2(244.98,57.87) 245.05,57.94 245.05,58.23 244.76,58.52 244.29,58.52 244.09,58.31 244.09,57.98 243.88,57.77 243.43,57.77 243.23,57.98 243.23,58.58 243.47,58.82 243.74,58.82 243.93,59.01 JDIMM4.127
  IN1 w0.076: v2(241.77,91.82) 241.77,91.62 242.75,90.64 242.75,81.57 243.53,80.8 243.53,80.54
  IN1 w0.188: 243.53,80.54 243.53,76.78 248.04,72.27 248.04,69.92 248.23,69.72 248.62,69.72 248.8,69.54 248.8,69.29 248.62,69.11 248.23,69.11 248.04,68.92 248.04,67.61 247.86,67.43 247.61,67.43 247.43,67.61 247.43,71.97 247.25,72.14 247,72.14 246.82,71.97 246.82,67.95 246.38,67.5 246.38,67.14 246.57,66.95 246.79,66.95 246.97,66.78 246.97,66.52 246.79,66.35 246.57,66.35 246.38,66.16 246.38,65.45 244.8,63.88 244.8,63.36 244.49,63.05 244.49,60.94 244.83,60.6 244.83,58.93 244.98,58.77 v2(244.98,57.87)
  BOTTOM w0.211: v2(244.98,57.87) 243.93,56.81 JDIMM3.127
DDR_B_MA7: length 58
  TOP w0.076: UC1.AN10 241.84,93.73 v2(241.77,93.77)
  TOP w0.211: v2(245.01,55.4) 244.7,55.4 244.4,55.1 244.4,53.42 244.58,53.24 244.96,53.24 245.18,53.03 JDIMM4.122
  IN1 w0.076: v2(241.77,93.77) 242.13,93.41 242.13,92.24 242.42,91.94 242.42,91.48 243.25,90.65 243.25,81.86 244.49,80.62 244.49,77.44 244.84,77.09
  IN1 w0.188: 244.84,77.09 249.56,72.36 250.29,72.36 251.35,71.31 251.35,69.32 250.83,68.8 249.84,68.8 249.16,68.12 249.16,67.2 247.53,65.58 247.53,65.1 245.71,63.28 245.71,60.12 246.07,59.76 246.07,56.46 245.64,56.03 245.64,55.77 246.07,55.34 246.07,55.06 245.84,54.84 245.57,54.84 v2(245.01,55.4)
  BOTTOM w0.211: JDIMM3.122 245.18,58.57 245.46,58.29 245.46,55.78 245.08,55.4 v2(245.01,55.4)
DDR_B_MA8: length 62.2
  TOP w0.076: v2(241.77,92.47) 241.84,92.43 UC1.AN8
  TOP w0.211: v2(245.01,56.65) 245.04,56.65 245.77,55.92 246.06,55.92 246.26,56.12 246.26,56.41 245.59,57.09 245.59,57.37 245.93,57.71 245.93,58.01 245.72,58.21 245.5,58.21 244.89,58.82 244.63,58.82 244.43,59.03 JDIMM4.125
  IN1 w0.076: 244.06,80.27 244.06,80.66 242.99,81.72 242.99,90.65 242.21,91.44 242.21,91.9 241.77,92.34 v2(241.77,92.47)
  IN1 w0.188: v2(245.01,56.65) 245.41,56.65 245.59,56.84 245.59,59.49 245.35,59.73 245.35,63.68 247,65.32 247,65.8 248.63,67.42 248.63,68.34 249.65,69.36 250.64,69.36 250.82,69.54 250.82,69.79 250.64,69.97 249.98,69.97 249.8,70.15 249.8,70.4 249.98,70.58 250.64,70.58 250.82,70.75 250.82,71.01 250.64,71.18 250.01,71.18 249.87,71.33 249.87,71.58 249.69,71.77 249.37,71.77 249.18,71.58 249.18,70.43 249,70.25 248.75,70.25 248.57,70.43 248.57,72.61 244.06,77.12 244.06,80.27
  BOTTOM w0.211: v2(245.01,56.65) 244.87,56.78 244.57,56.78 244.43,56.63 244.43,53.88 244.61,53.7 244.93,53.7 245.12,53.51 245.12,53.25 244.93,53.07 244.61,53.07 244.43,52.88 JDIMM3.125
DDR_B_MA9: length 56.8
  TOP w0.076: v2(243.6,94.42) UC1.AR11
  TOP w0.211: v2(246.98,57.34) 246.97,57.32 246.95,57.32 246.64,57.01 246.35,57.01 246.14,57.21 246.14,57.5 246.66,58.02 246.66,58.25 246.4,58.52 245.63,58.52 245.43,58.72 JDIMM4.121
  IN1 w0.076: v2(243.6,94.42) 243.13,93.96 243.13,93.58 243.04,93.49 243.04,92.32 242.86,92.14 242.86,91.53 243.74,90.66 243.74,82.09 245.03,80.8 245.03,78.4 245.17,78.26
  IN1 w0.188: 245.17,78.26 248.67,74.76 249.34,74.76 249.65,74.46 249.65,73.78 249.95,73.48 250.67,73.48 252.41,71.75 252.41,68.88 251.38,67.85 251.38,67.61 249.83,66.06 249.52,66.06 248.59,65.14 248.59,64.61 246.45,62.46 246.45,61.27 246.98,60.73 v2(246.98,57.34)
  BOTTOM w0.211: v2(246.98,57.34) 246.97,57.32 246.93,57.32 246.12,56.51 246.12,53.78 245.43,53.09 JDIMM3.121
DDR_B_MA10: length 63
  TOP w0.076: v2(238.11,91.82) UC1.AH7
  TOP w0.211: JDIMM4.146 237.18,52.32 237.32,52.46 237.59,52.46 238.47,51.58 238.71,51.58 238.92,51.79 238.92,52.09 238,53.02 238,53.95 237.75,54.2 237.39,54.2 v2(237.08,53.89)
  IN1 w0.076: 234.75,77.4 234.75,77.75 235.7,78.7 236.26,78.7 237.83,80.27 237.83,87.61 238.07,87.85 238.07,91.78 v2(238.11,91.82)
  IN1 w0.188: 234.75,77.4 234.75,75.47 232.44,73.16 232.44,69.33 233.72,68.05 233.72,62.76 234.25,62.23 234.25,61.17 237.38,58.04 237.38,55.92 237.63,55.68 237.63,52.49 237.42,52.29 235.61,52.29 235.45,52.45 235.45,52.72 235.63,52.9 236.84,52.9 237.03,53.09 237.03,53.84 v2(237.08,53.89)
  BOTTOM w0.211: v2(237.08,53.89) 237.49,54.3 237.49,55.69 236.87,56.31 236.87,58.07 237.18,58.38 JDIMM3.146
DDR_B_MA11: length 64.3
  TOP w0.076: UC1.AN11 241.84,94.38 v2(241.77,94.42)
  TOP w0.211: v2(245.01,54.19) 245.62,54.8 246.28,54.8 246.83,54.24 246.83,53.95 246.64,53.75 246.43,53.75 246.21,53.97 245.9,53.97 245.69,53.77 245.69,53.58 245.91,53.37 245.91,52.71 245.68,52.48 JDIMM4.120
  IN1 w0.076: v2(241.77,94.42) 242.22,93.97 242.22,93.65 242.3,93.57 242.3,92.35 242.64,92.01 242.64,91.52 243.51,90.66 243.51,82.01 244.74,80.78 244.74,77.94 245.01,77.67
  IN1 w0.188: 245.01,77.67 249.78,72.9 250.51,72.9 251.88,71.53 251.88,69.1 250.84,68.07 250.84,67.83 249.61,66.59 249.3,66.59 248.06,65.36 248.06,64.84 246.07,62.85 246.07,60.76 246.52,60.32 246.52,53.13 246.21,52.83 245.53,52.83 245.01,53.35 v2(245.01,54.19)
  BOTTOM w0.211: JDIMM3.120 245.68,58.68 245.67,58.67 245.81,58.53 245.81,54.99 v2(245.01,54.19)
DDR_B_MA12: length 57
  TOP w0.076: v2(243.6,93.77) UC1.AR10
  TOP w0.211: v2(246.98,56.07) 247.41,56.5 247.41,57.94 246.53,58.82 246.26,58.82 245.93,59.16 JDIMM4.119
  IN1 w0.076: v2(243.6,93.77) 243.22,93.39 243.22,92.2 243.03,92.01 243.03,91.59 244,90.63 244,86.99 244.62,86.37 244.62,84.11 245.97,82.76 245.97,81.8
  IN1 w0.188: 245.97,81.8 245.97,78.32 246.28,78.02 246.89,78.02 247.26,77.65 247.26,76.92 247.56,76.62 248.29,76.62 248.44,76.47 248.44,75.74 248.89,75.29 249.62,75.29 252.94,71.97 252.94,68.66 252,67.72 252,67.48 250.05,65.53 249.74,65.53 249.12,64.92 249.12,63.79 248.87,63.53 248.27,63.53 248.03,63.3 248.03,62.58 248.43,62.18 248.43,61.4 247.4,60.37 247.4,56.48 v2(246.98,56.07)
  BOTTOM w0.211: JDIMM3.119 245.93,53.12 246.42,53.62 246.42,55.92 246.57,56.07 v2(246.98,56.07)
DDR_B_MA13: length 65.1
  TOP w0.076: v2(236.28,93.12) UC1.AF9
  TOP w0.211: JDIMM4.158 234.18,52.52 234.56,52.91 234.56,53.62 234.16,54.03 233.29,54.03 233.11,54.21 233.11,54.62 233.31,54.82 234.17,54.82 v2(234.41,55.05)
  IN1 w0.076: 235.07,81.45 236.12,82.5 236.12,88.7 236.59,89.17 236.59,91.59 236.64,91.64 236.64,92.77 v2(236.28,93.12)
  IN1 w0.188: 235.07,81.45 231.94,78.33 231.94,76.41 228.02,72.49 228.02,69.01 229.99,67.05 229.99,65.82 230.49,65.32 230.49,64.43 231.06,63.86 231.06,60.55 232.38,59.23 232.38,58.21 232.9,57.68 232.9,55.96 232.51,55.57 232.51,53.29 232.83,52.97 232.83,51.86 233.34,51.35 234.41,51.35 234.91,51.85 234.91,54.55 v2(234.41,55.05)
  BOTTOM w0.211: JDIMM3.158 234.18,58.73 233.27,57.83 233.27,56.19 v2(234.41,55.05)
DDR_B_MA14: length 58.4
  TOP w0.076: v2(238.11,94.42) UC1.AH11
  TOP w0.211: v2(235.88,56.22) 236.58,56.92 236.58,57.74 236.3,58.02 235.73,58.02 235.52,58.23 235.52,58.59 235.93,58.99 JDIMM4.151
  IN1 w0.076: 233.08,77.4 233.08,77.81 235.06,79.78 236.37,79.78 237.17,80.59 237.17,88 237.54,88.38 237.54,91.38 237.36,91.57 237.36,92.09 237.57,92.3 237.57,93.88 v2(238.11,94.42)
  IN1 w0.188: 233.08,77.4 233.08,76.05 229.09,72.05 229.09,69.45 231.05,67.49 231.05,66.26 231.55,65.76 231.55,64.87 232.12,64.3 232.12,60.99 233.51,59.6 233.51,58.57 234.26,57.83 234.44,57.83 235.25,57.02 235.25,56.67 234.92,56.35 234.92,55.52 235.06,55.38 235.25,55.38 235.44,55.57 235.44,56.03 235.63,56.22 v2(235.88,56.22)
  BOTTOM w0.211: v2(235.88,56.22) 235.44,55.78 235.44,53.39 235.93,52.9 JDIMM3.151
DDR_B_MA15: length 61.6
  TOP w0.076: UC1.AF8 v2(237.2,92.47)
  TOP w0.211: JDIMM4.156 234.68,52.49 234.86,52.68 234.86,55.54 v2(234.39,56.01)
  IN1 w0.076: v2(237.2,92.47) 236.88,92.15 236.88,91.64 236.76,91.52 236.76,88.77 236.28,88.3 236.28,81.83 235.49,81.03
  IN1 w0.188: 235.49,81.03 232.55,78.09 232.55,76.27 228.55,72.27 228.55,69.23 230.52,67.27 230.52,66.04 231.02,65.54 231.02,64.65 231.59,64.08 231.59,60.77 232.91,59.45 232.91,58.43 233.43,57.9 233.43,55.74 233.04,55.35 233.04,53.51 233.36,53.19 233.36,52.08 233.56,51.88 234.19,51.88 234.38,52.07 234.38,53.8 233.82,54.36 233.82,55.21 234.39,55.79 v2(234.39,56.01)
  BOTTOM w0.211: v2(234.39,56.01) 233.69,56.7 233.69,57.51 234.68,58.49 JDIMM3.156
DDR_B_MA16: length 62.5
  TOP w0.076: v2(238.11,93.77) UC1.AH10
  TOP w0.211: v2(235.87,57.48) 235.45,57.06 235.45,53.39 235.68,53.17 JDIMM4.152
  IN1 w0.076: v2(238.11,93.77) 237.73,93.39 237.73,92.23 237.52,92.02 237.52,91.64 237.73,91.43 237.73,88.22 237.36,87.86 237.36,80.44 236.35,79.43 235.33,79.43 233.61,77.71 233.61,77.4
  IN1 w0.188: v2(235.87,57.48) 235.94,57.54 235.94,57.81 235.75,57.99 235.54,57.99 235.41,57.86 235.16,57.86 234.99,58.03 234.99,58.28 235.16,58.45 235.16,58.7 234.98,58.88 234.72,58.88 234.46,58.62 234.22,58.62 234.04,58.79 234.04,59.07 234.29,59.32 234.29,59.57 232.65,61.21 232.65,64.74 232.47,64.92 232.25,64.92 232.08,65.09 232.08,65.34 232.25,65.51 232.47,65.51 232.65,65.69 232.65,66.08 232.42,66.31 232.18,66.31 232.09,66.22 231.84,66.22 231.67,66.39 231.67,66.64 231.93,66.9 231.93,67.16 231.59,67.51 231.59,67.99 231.76,68.16 231.76,68.52 231.62,68.65 231.38,68.65 231.16,68.44 230.91,68.44 230.74,68.61 230.74,68.86 231.35,69.47 231.35,69.71 231.18,69.89 230.93,69.89 230.32,69.28 230.07,69.28 229.9,69.45 229.9,69.7 230.11,69.91 230.11,70.11 229.94,70.28 229.79,70.28 229.62,70.46 229.62,70.7 229.79,70.88 229.94,70.88 230.11,71.05 230.11,71.29 229.77,71.64 229.77,71.98 233.61,75.83 233.61,77.4
  BOTTOM w0.211: v2(235.87,57.48) 235.7,57.48 235.45,57.22 235.45,56.52 235.24,56.31 235.02,56.31 234.81,56.52 234.81,58.11 235.02,58.33 235.46,58.33 235.68,58.54 JDIMM3.152
DDR_B_ODT0: length 53.4
  TOP w0.076: v2(236.28,91.85) UC1.AF7
  TOP w0.168: JDIMM4.155 234.93,57.77 v2(234.38,57.23)
  IN2 w0.076: v2(236.28,91.85) 234.57,91.85 233.83,91.12 233.83,90.94 233.59,90.7
  IN2 w0.127: 233.59,90.7 233.24,90.35 233.24,84.84 231.43,83.03 231.43,71.16 231.3,71.04 230.96,71.04 230.82,71.17 230.82,75.84 230.69,75.97 230.48,75.97 230.31,75.8 230.31,61.3 v2(234.38,57.23)
DDR_B_ODT1: length 55.6
  TOP w0.076: v2(235.37,92.47) UC1.AE8
  TOP w0.168: JDIMM4.161 233.43,58.48 232.84,57.9 231.36,57.9 230.3,56.83 230.3,56.52 230.5,56.32 230.87,56.32 v2(231.59,57.04)
  IN1 w0.076: v2(235.37,92.47) 235.53,92.31 235.53,83.3 234.7,82.46
  IN1 w0.152: v2(231.59,57.04) 231.27,57.04 231.12,57.19 231.12,58.34 230.93,58.53 230.63,58.53 230.44,58.72 230.44,58.92 230.57,59.05 230.57,59.26 229.31,60.51 229.31,60.73 229.46,60.88 229.66,60.88 229.79,61.02 229.79,63.01 229.64,63.17 229.3,63.17 229.15,63.32 229.15,64.87 228.65,65.37 228.65,66.6 226.82,68.43 226.59,68.43 226.43,68.27 226.43,68.05 227.24,67.24 227.24,67.02 227.08,66.87 226.86,66.87 225.59,68.13 225.59,70.09 225.35,70.34 225.35,70.6 225.59,70.85 225.59,71.05 225.31,71.34 225.31,71.57 230.68,76.94 230.68,78.45 234.7,82.46
DDR_B_ODT2: length 56.9
  TOP w0.076: v2(235.37,93.12) UC1.AE9
  IN1 w0.076: v2(235.37,93.12) 235.37,93.12 235,92.76 235,92.2 235.3,91.9 235.3,83.71 234.38,82.79
  IN1 w0.152: v2(231.61,54.34) 231.7,54.25 231.7,52.84 231.55,52.69 231.28,52.69 231.13,52.84 231.13,56.13 230.66,56.6 230.66,57.85 229.89,58.63 229.89,59.29 228.78,60.4 228.78,63.02 228.69,63.11 228.69,64.68 228.2,65.18 228.2,66.41 227.89,66.72 227.58,66.72 227.13,66.27 226.81,66.27 225.14,67.94 225.14,69.9 224.77,70.27 224.77,71.67 230.22,77.12 230.22,78.64 234.38,82.79
  BOTTOM w0.168: v2(231.61,54.34) 233.86,54.34 234.93,53.27 JDIMM3.155
DDR_B_ODT3: length 58.2
  TOP w0.076: v2(235.37,94.42) UC1.AE11
  IN1 w0.076: 234.05,83.11 235.04,84.1 235.04,91.93 234.84,92.13 234.84,93.34 234.87,93.38 234.87,93.93 v2(235.37,94.42)
  IN1 w0.152: v2(230.62,54.42) 230.62,52.37 230.2,51.95 229.84,51.95 229.63,52.17 229.63,52.41 230.06,52.85 230.06,54.75 230.2,54.89 230.2,57.66 229.37,58.5 229.37,59.16 228.32,60.21 228.32,62.84 228.23,62.93 228.23,64.2 224.68,67.75 224.68,69.71 224.31,70.08 224.31,71.86 229.77,77.31 229.77,78.82 234.05,83.11
  BOTTOM w0.168: JDIMM3.161 233.43,52.86 232.73,53.56 231.48,53.56 v2(230.62,54.42)
DDR_B_PARITY: length 58.3
  TOP w0.076: v2(239.03,91.82) UC1.AJ7
  TOP w0.211: v2(239.15,53.25) 239.74,53.85 239.74,56.07 239.37,56.45 239.37,58.46 239.93,59.01 JDIMM4.143
  IN1 w0.076: v2(239.03,91.82) 239.03,91.7 238.6,91.27 238.6,79.57 236.44,77.41 236.44,76.86
  IN1 w0.188: v2(239.15,53.25) 238.68,52.79 238.35,52.79 238.16,52.97 238.16,56.4 238.69,56.93 238.69,58.99 236.85,60.83 236.85,62.71 236.45,63.11 236.45,64.29 235.88,64.86 235.88,66.76 235.41,67.23 235.41,71.53 236.44,72.56 236.44,76.86
  BOTTOM w0.211: v2(239.15,53.25) 239.15,52.45 238.97,52.26 238.63,52.26 238.45,52.08 238.45,51.83 238.63,51.65 238.88,51.65 239.06,51.47 239.06,51.17 238.28,50.38 238.28,50.09 238.49,49.87 238.78,49.87 239.92,51.01 239.92,51.7 JDIMM3.143
DDR_RCOMP0: length 6.7
  TOP w0.254: 219.6,85.42 220.24,86.06 220.53,86.06 222.05,87.59 UC1.G1
  TOP w0.381: 219.6,85.42 218.26,84.08 v1(218.26,83.58) RC5.2
DDR_RCOMP1: length 6.4
  TOP w0.254: 221.19,85.54 221.34,85.7 221.34,85.95 UC1.H1
  TOP w0.381: 221.19,85.54 219.51,83.86 v1(219.51,83.85) 219.28,83.62 RC6.2
DDR_RCOMP2: length 6.9
  TOP w0.254: UC1.J2 223.39,88.13 223.39,87.26 221.84,85.71 221.84,85.43
  TOP w0.381: 221.84,85.43 221.84,84.24 v1(221.19,83.59) RC7.2
DDR_VTT_CTRL: length 40
  TOP w0.102: v2(259.77,95.61) UC1.BT13
  IN4 w0.102: v2(282.73,71) 282.73,71.3 281.94,72.08 281.94,73.84 280.88,74.9 280.88,75.9 264.51,92.27 264.51,92.7 263.12,94.09 261.3,94.09 v2(259.77,95.61)
  BOTTOM w0.102: UD1.2 283.93,68.17 v3(284.27,67.84)
  BOTTOM w0.109: v2(282.73,71) 283.09,70.64 283.8,70.64 283.93,70.5 UD1.2
DDR_XDP_WAN_SMBCLK: length 323.8
  TOP w0.102: JDIMM2.253 210.43,44.93 208.86,43.37 208.86,41.71 208.11,40.95 v2(208.11,40.74) ; QH4.1 162.39,31.71 162.37,31.73 RH333.1 162.37,32.78 v2(162.51,32.92)
  TOP w0.109: JDIMM4.253 210.43,61.98 211.02,62.58 v2(211.36,62.58) 211.41,62.63 211.41,63.94 216.61,69.13 234.94,69.13 240.08,63.99 v1(242.53,63.99) 246.94,63.99 249.05,66.1 250.52,66.1 254.77,70.36 267.24,70.36 273.11,64.49 278.64,64.49 280.29,66.13 280.29,66.5 280.4,66.61 v2(280.87,66.61) ; v2(283.3,94.59) 283.56,94.85 JXDP1.53 ; v2(209.83,48.45) 210.43,47.86 JDIMM2.253
  IN1 w0.102: v2(283.3,94.59) 284.34,94.59 285.56,93.38 285.56,90.3 286.28,89.58 286.28,77.32 281.16,72.19 281.16,67.24 280.87,66.96 v2(280.87,66.61) 281.97,66.61 285.28,69.92 285.28,70.67 287.5,72.89 289.3,72.89 308.51,53.67 312.22,53.67 315.61,50.28 334.88,50.28 338.19,46.98 339.95,46.98 345.93,41 v2(345.93,40.48)
  IN2 w0.081: v2(186.86,59.11) 184.03,56.28 182.95,56.28 177.92,51.24 177.92,47.59 176.44,46.12 175.89,46.12 175.09,45.32 175.09,45 175.33,44.76 176.34,44.76 176.54,44.56 176.54,43.7 176.27,43.43 175.57,43.43 173.39,41.25 173.39,39.65 171.93,38.19 170.43,38.19 169.82,37.57 169.53,37.57 168.84,36.88 168.54,36.88 167.57,35.91 167.57,35.29 166.99,34.71 164.03,34.71 162.51,33.19 v2(162.51,32.92) ; v2(209.83,48.45) 209.83,49.02 210.74,49.93 210.74,59.6 211.9,60.76 211.9,62.03 v2(211.36,62.58)
  IN3 w0.081: v2(342.89,31.53) 342.44,31.97 342.44,36.91 345.93,40.39 v2(345.93,40.48) ; v2(186.86,59.11) 186.44,59.53 186.44,62.26 189.11,64.93 191.92,64.93 193.79,63.06 201.62,63.06 203.4,64.85 208.05,64.85 210.32,62.58 v2(211.36,62.58)
  BOTTOM w0.102: JDIMM3.253 210.43,49.79 209.83,49.2 v2(209.83,48.45) ; JDIMM1.253 210.43,38.62 209.84,39.2 208.69,39.2 208.11,39.78 v2(208.11,40.74)
  BOTTOM w0.109: v2(342.89,31.53) 342.54,31.18 342.54,27.52 342.08,27.05 LGA1.1
DDR_XDP_WAN_SMBDAT: length 330.8
  TOP w0.102: RH374.1 161.09,28.16 QH4.4 161.09,30.25 160.39,30.95 160.39,32.63 v1(161.1,33.33) v2(161.51,33.74) ; JDIMM4.254 210.18,49.8 v2(209.34,48.97) ; v2(207.72,42.91) 207.48,42.91 206.63,42.06 206.63,41.14 208.43,39.34 209.65,39.34 210.18,38.82 JDIMM2.254
  TOP w0.109: JXDP1.51 283.85,94.25 v2(283.68,94.09) ; v2(280.7,65.84) 280.8,65.74 280.8,65.68 279.12,64 272.9,64 267.03,69.87 254.98,69.87 250.73,65.61 249.25,65.61 247.14,63.5 239.88,63.5 234.74,68.64 216.81,68.64 212.21,64.04 212.21,62.77 v2(211.37,61.93)
  IN1 w0.102: v2(283.68,94.09) 283.81,94.09 285.08,92.82 285.08,90.02 285.78,89.32 285.78,77.52 280.66,72.4 280.66,67.73 280.45,67.52 280.45,66.27 280.7,66.02 v2(280.7,65.84) 281.53,65.84 285.51,69.82 285.51,70.58 287.59,72.66 289.12,72.66 308.38,53.41 312.16,53.41 315.52,50.04 334.8,50.04 338.09,46.75 339.8,46.75 345.07,41.48 v2(345.07,40.48)
  IN2 w0.081: v2(161.51,33.74) 161.94,34.18 163.18,34.18 163.92,34.92 166.89,34.92 167.33,35.36 167.33,36.09 168.38,37.14 168.38,37.76 168.62,38 169.92,38 172.93,41.01 172.93,41.12 175.47,43.66 176.18,43.66 176.31,43.79 176.31,44.31 176.09,44.53 175.24,44.53 174.86,44.9 174.86,45.41 175.95,46.5 175.95,47.65 176.9,48.6 176.9,50.55 183.06,56.72 184.06,56.72 186.3,58.95 186.3,59.22 v2(186.85,59.77) ; v2(211.37,61.93) 210.42,61.93 210.35,61.86 210.35,50.35 209.22,49.22 209.22,49.1 v2(209.34,48.97) 209.22,48.85 209.22,44.42 v2(207.72,42.91)
  IN3 w0.081: v2(338.23,27.75) 340.68,27.75 341.16,28.24 341.16,30.4 341.96,31.2 341.96,37.37 v2(345.07,40.48) ; v2(186.85,59.77) 188.29,61.21 189.42,61.21 191.62,63.41 192.27,63.41 193.12,62.55 201.97,62.55 203.74,64.32 207.66,64.32 210.05,61.93 v2(211.37,61.93)
  BOTTOM w0.102: JDIMM3.254 210.18,61.33 210.77,61.93 v2(211.37,61.93)
  BOTTOM w0.109: v2(207.72,42.91) 208.27,43.47 208.88,43.47 210.18,44.76 JDIMM1.254 ; LGA1.4 338.93,27.05 v2(338.23,27.75)
