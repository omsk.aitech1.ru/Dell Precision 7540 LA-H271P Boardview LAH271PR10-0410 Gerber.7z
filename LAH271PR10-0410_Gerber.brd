# Allegro board LAH271PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PANEL_BKEN_PCH: length 98.6
  TOP w0.089: UH1.AV46 178.28,21.46
  TOP w0.102: 178.28,21.46 v2(178.54,21.72)
  IN1 w0.102: v2(112.45,49.17) 111.34,48.07 v2(107.69,48.07)
  IN3 w0.081: v2(178.54,21.72) 178.26,22 178.26,22.88 177.36,23.78 177.36,24.31 177.01,24.66 176.28,24.66 176,24.38 174.56,24.38 172.8,26.14 172.09,26.14 171.4,26.84 171.4,28.05 169.21,30.23 167.83,30.23 166.89,31.17 163.91,31.17 163.24,31.84 163.24,33.19 161.89,34.54 161.89,37.2 162.32,37.63 162.32,38.31 159.06,41.57 159.06,42.13 158.07,43.13 154.78,43.13 152.94,44.96 151.65,44.96 151.41,44.72 142.38,44.72 141.18,45.91 138.91,45.91 138.68,46.15 136.48,46.15 136.26,46.37 130.17,46.37 128.22,44.42 125.24,44.42 123.5,42.68 118.71,42.68 118.11,43.28 117.33,43.28 114.88,45.72 114.88,46.68 114.17,47.39 109.79,47.39 109.11,48.07 v2(107.69,48.07)
  BOTTOM w0.109: v2(178.54,21.72) 178.54,21.57 v1(178.25,21.28) ; DV35.2 113.1,49.83 v2(112.45,49.17)
PANEL_MONITOR: length 75.3
  TOP w0.109: v2(86.1,36.2) 86.1,34.68 85.08,33.66 RV911.1 RV910.2 85.08,31.4 QV23.3 ; UE1.M8 135.92,20.06 135.92,19.51 135.73,19.33 135.73,17.65 136.16,17.23 v1(136.16,16.45) 136.16,15.73 v2(135.78,15.35)
  IN2 w0.081: v2(135.78,15.35) 135.7,15.35 135.01,16.03 133.6,16.03 133.41,15.84 132.39,15.84 131.82,15.27 127.82,15.27 127,14.45 126.61,14.45 126.31,14.75 124.4,14.75 124.1,14.45 121.81,14.45 121.09,15.17 118.65,15.17 117.21,16.61 113.76,16.61 113.02,17.36 113.02,19.06 111.03,21.04 106.88,21.04 106.71,20.87 104.39,20.87 103.74,21.52 103.74,21.89 102.21,23.42 101.7,23.42 100.05,25.07 100.05,25.83 98.96,26.92 98.96,27.59 96.82,29.74 96.82,31.35 91.64,36.53 86.42,36.53 v2(86.1,36.2)
PBAT_CHARGER_SMBCLK: length 213.1
  TOP w0.109: 129.67,17.86 129.67,18.48 130.73,19.54 UE1.N2 ; 129.67,17.86 v2(129.65,17.86) ; 129.67,17.86 RE43.1 ; PR711.1 v2(281.92,28.95) ; v2(254.98,5.03) 256.26,3.75 263.23,3.75 264.21,4.73 264.21,7.03 263.42,7.82 PR65.2 263.42,8.32 262.83,8.9 262.83,9.82 263.99,10.98 PD9.2 264.1,11.83 267.11,14.84 269.15,14.84 v2(270.37,16.06)
  IN1 w0.102: v2(281.92,28.95) 282.23,28.63 282.23,25.74 275.38,18.88 271.89,18.88 270.51,17.5 270.51,16.2 v2(270.37,16.06) ; v2(123.87,5.68) 124.03,5.52 125.55,5.52 126.18,4.9 126.18,4.77 129.45,1.5 157.78,1.5 159.13,2.85 159.13,5.26 159.91,6.03 165.13,6.03 165.64,6.54 169.64,6.54 172.39,3.8 172.39,2.38 173.25,1.52 191.56,1.52 192.15,2.11 203.48,2.11 204,1.59 210.38,1.59 211.99,3.21 211.99,4.61 217.04,9.65 219.84,9.65 220.98,10.79 227.57,10.79 228.71,9.65 236.38,9.65 237.29,8.75 251.78,8.75 254.98,5.54 v2(254.98,5.03)
  BOTTOM w0.102: v2(123.87,5.68) 123.83,5.72 123.83,8.18 124.77,9.12 125.96,9.12 130.01,13.17 130.01,14.61 129.24,15.38 v1(129.24,16.7) 129.24,17.42 129.67,17.85 129.67,17.86 v2(129.65,17.86)
PBAT_CHARGER_SMBDAT: length 218.7
  TOP w0.109: v2(270.09,16.58) 270.09,16.44 268.99,15.35 267.24,15.35 263.1,11.21 PD9.3 262.59,10.48 262.59,8.86 262.46,8.73 PR66.2 262.49,7.88 262.95,7.41 262.95,5.77 262.55,5.36 261.15,5.36 260.13,6.38 257.84,6.38 v2(256.43,4.96) ; PR710.1 v2(281.89,29.81) ; RE37.1 128.78,17.63 v2(129.04,17.89) 129.04,18.14 130.38,19.48 130.38,19.84 130.6,20.06 131.14,20.06 UE1.M3
  IN1 w0.102: v2(123.28,5.71) 123.66,6.09 124.07,6.09 124.4,5.75 125.65,5.75 127.98,3.42 129.57,3.42 129.82,3.17 129.82,2.85 130.91,1.75 138.05,1.75 139.49,3.19 139.49,6.03 140.86,7.4 141.35,7.4 142.09,8.14 142.09,9.25 142.27,9.43 148.7,9.43 148.89,9.24 158.03,9.24 161.01,6.26 164.89,6.26 165.69,7.06 169.5,7.06 172.61,3.95 172.61,2.48 173.31,1.78 191.44,1.78 192,2.34 203.58,2.34 204.1,1.82 210.28,1.82 211.56,3.1 211.56,5.67 212.59,6.7 212.59,7.9 213.4,8.72 215.72,8.72 217.14,10.14 219.59,10.14 220.51,11.05 227.97,11.05 228.54,10.49 236.43,10.49 237.88,9.04 251.91,9.04 255.53,5.43 255.96,5.43 v2(256.43,4.96) ; v2(270.09,16.58) 270.09,17.47 271.75,19.13 274.92,19.13 281.35,25.56 281.35,29.27 v2(281.89,29.81)
  BOTTOM w0.102: v2(123.28,5.71) 123.28,8.07 124.56,9.35 125.86,9.35 128.78,12.27 128.78,13.15 128.59,13.34 128.59,13.68
  BOTTOM w0.109: 128.59,13.68 129.19,14.28 129.19,14.86 v1(128.78,15.27) 128.78,17.63 v2(129.04,17.89)
PBAT_PRES#: length 196.6
  TOP w0.102: UE1.F9 v2(136.73,25.65)
  TOP w0.109: v2(270.98,16.24) 270.98,16.31 270.3,16.99 269.39,16.99 268.51,16.11 267.02,16.11 266.44,15.54 265.39,15.54 v2(263.77,13.91) 260.46,10.61 v1(260.46,10.2) 260.46,9.48 260.65,9.29 261.57,9.29 261.7,9.43 PR62.2 262.08,8.34 261.62,7.88 PR67.2 261.59,7.83 261.21,7.44 260.21,7.44 259.59,8.06 259.59,8.08 259.29,8.39 PD10.2 ; v2(283.16,24.1) 282.59,24.66 PR724.1
  IN1 w0.102: v2(270.98,16.24) 272.53,17.79 276.27,17.79 277.49,19.01 280.32,19.01 280.61,19.31 280.61,20.4 281.15,20.95 282.6,20.95 282.82,20.73 283.63,20.73 283.89,21 283.89,21.84 282.93,22.81 282.93,23.87 v2(283.16,24.1)
  IN2 w0.081: v2(263.77,13.91) 263.16,13.31 253.32,13.31 250.76,10.75 239.7,10.75 237.2,13.24 231.38,13.24 231.04,12.9 220.42,12.9 219.79,12.27 213.4,12.27 212.21,11.08 212.21,10.5 213.12,9.59 213.12,7.58 211.58,6.04 211.58,4.74 211.16,4.33 208.73,4.33 207.92,5.13 207.92,6.89 v2(208.66,7.63)
  IN4 w0.102: v2(208.66,7.63) 208.14,8.16 205.26,8.16 204.97,8.45 202,8.45 199.6,10.85 196.7,10.85 196.49,10.64 186.28,10.64 185.46,11.46 181.13,11.46 180.93,11.66 180.18,11.66 179.68,12.17 179.15,12.17 177.33,13.98 177.33,14.62 176.85,15.1 174.44,15.1 174.15,15.39 174.15,15.59 173.87,15.88 173.61,15.88 173.24,16.25 172.64,16.25 171.53,17.37 170.74,17.37 170.47,17.1 169.37,17.1 167.87,18.6 167.37,18.6 166.1,19.87 166.1,20.59 164.73,21.97 164.36,21.97 163.85,22.48 163.85,24.34 162.29,25.9 160.62,25.9 160.11,26.41 159.53,26.41 159.17,26.77 159.17,27.57 157.84,28.9 151.95,28.9 150.5,27.45 146.89,27.45 145.04,25.61 141.51,25.61 141.03,25.14 139.59,25.14 139.48,25.25 137.18,25.25 136.77,25.65 v2(136.73,25.65)
PCH_2_CPU_TRIGGER: length 83.2
  TOP w0.076: UC1.H23 v2(222.77,103.35)
  TOP w0.102: RH42.2 178.94,51.67 178.65,51.38 v2(178.65,50.96)
  IN4 w0.102: v2(222.77,103.35) 222.77,102.5 222.35,102.08 221.21,102.08 220.39,102.91 219.26,102.91 218.47,102.12 217.84,102.12 217.4,101.68 217.4,90.73 216.51,89.83 210.63,89.83 204.81,84.01 203.76,84.01 201.49,81.74 v2(201.49,80.52)
  BOTTOM w0.109: v2(201.49,80.52) 200.7,79.72 195.68,79.72 192.45,76.49 192.45,74.93 191.73,74.21 191.73,69.2 190.55,68.02 v3(190.55,67.15) 190.55,65.76 186.44,61.65 186.44,58.84 183.24,55.64 182.45,55.64 179.35,52.54 179.35,51.65 v2(178.65,50.96)
PCH_2_CPU_TRIGGER_R: length 10.1
  TOP w0.102: UH1.AK3 182.07,42.29 181.98,42.38 181.98,42.89 182.06,42.97 182.06,45.41 181.35,46.11 181.35,47.08 181.37,47.09 181.37,47.53 181.24,47.66 181.06,47.66 180.6,48.12 180.6,48.43 v1(180.21,48.82) 179.33,49.7 RH42.1
PCH_3.3V_TS_EN: length 132.2
  TOP w0.102: v2(166.44,28.09) 166.94,28.09 167.68,28.83 171.2,28.83 171.21,28.83 171.29,28.91 171.3,28.91 171.32,28.93 174.32,28.93 174.33,28.91 174.54,28.91 174.65,28.79 175.02,28.79 UH1.BD30
  TOP w0.109: v2(78.54,11.22) 78.37,11.05 77.73,11.05 77.14,11.65 77.14,13.67 76.24,14.57 v1(76.24,18.9) 75.43,19.71 75.43,23.31 74.63,24.11 74.63,26.79 75.83,28 75.83,28.8 RV324.1
  IN1 w0.102: v2(129.11,19.65) 129.11,19.73 130.72,21.34 130.72,22.47 130.57,22.62 130.57,24.12 130.87,24.42 133.66,24.42 134.5,25.26 139.39,25.26 139.55,25.1 143.42,25.1 143.74,24.77 144.17,24.77 144.97,25.57 146.15,25.57 146.87,26.3 148.06,26.3 149.41,27.65 150.39,27.65 151.77,26.27 154.33,26.27 155.74,27.68 157.13,27.68 158.74,29.29 159.74,29.29 160.24,28.79 164.68,28.79 164.97,28.5 166.02,28.5 v2(166.44,28.09)
  IN3 w0.081: v2(129.11,19.65) 128.96,19.49 127.11,19.49 125.88,18.27 122.3,18.27 121.85,18.72 121.85,18.99 121.67,19.17 120.54,19.17 118.55,17.18 116.22,17.18 115.12,16.08 104.03,16.08 103.77,15.82 94.86,15.82 93.96,14.91 84.81,14.91 83.82,13.92 80.72,13.92 78.61,11.81 78.61,11.28 v2(78.54,11.22)
  BOTTOM w0.102: v2(166.44,28.09) 166.07,27.72 RH375.2
PCH_BATLOW#: length 6.4
  TOP w0.089: UH1.BF44 174.04,22 173.76,21.73 172.04,21.73 171.27,20.95 170.46,20.95 v2(170.35,21.07)
  BOTTOM w0.109: v1(170.46,21.58) 170.35,21.47 v2(170.35,21.07) 170.13,20.85 169.33,20.85 RH94.1
PCH_CL_CLK1: length 181.2
  TOP w0.089: v2(178.5,45.49) 178.63,45.37 179.07,45.37 179.29,45.15 179.29,42.66 UH1.AR2
  IN1 w0.102: v2(327.84,14.67) 327.03,13.86 325.58,13.86 323.3,11.59 323.3,11.24 322.1,10.05 319.37,10.05 318.56,9.24 315.03,9.24 314.56,9.71 312.13,9.71 310.85,10.99 308.27,10.99 307.28,10 299.7,10 299.49,10.2 290.89,10.2 289.85,11.24 288.74,11.24 287.91,12.07 285.37,12.07 284.41,13.03 276,13.03 275.03,14 267.43,14 261.29,20.14 258.68,20.14 255.56,23.26 237.9,23.26 237.35,22.71 237.35,22.2 237.45,22.1 v2(237.51,22.1)
  IN3 w0.081: v2(237.51,22.1) 237.42,22.2 237.42,22.76 233.18,26.99 215.61,26.99 214.07,28.53 213.02,28.53 212.21,29.34 212.21,30.43 210,32.64 207.91,32.64 204.08,36.48 202.78,36.48 200.9,38.36 200.9,39.7 200.04,40.56 200.04,41.89 198.64,43.29 198.64,44.65 195.67,47.63 188,47.63 187.86,47.77 186.24,47.77 185.31,46.84 184.13,46.84 183.22,45.93 180.51,45.93 179.98,45.39 178.6,45.39 v2(178.5,45.49)
  BOTTOM w0.109: JNGFF1.34 327.15,16.47 327.84,15.78 v2(327.84,14.67)
PCH_CL_DATA1: length 182.2
  TOP w0.089: v2(178.82,44.99) 179.1,44.7 179.1,42.5 178.98,42.38 178.98,41.58 178.95,41.56 UH1.AT5
  TOP w0.109: v1(320.74,11.24) 320.74,12.36 v2(320.6,12.5)
  IN1 w0.102: v2(320.6,12.5) 321.05,12.05 321.05,10.93 320.65,10.53 319.17,10.53 318.36,9.72 315.23,9.72 314.76,10.19 312.33,10.19 311.05,11.47 308.07,11.47 307.08,10.48 300.04,10.48 299.83,10.69 291.09,10.69 290.05,11.73 288.94,11.73 288.11,12.55 285.57,12.55 284.61,13.52 276.2,13.52 275.23,14.48 267.63,14.48 261.49,20.62 258.88,20.62 255.76,23.74 237.7,23.74 236.87,22.91 236.87,22.19 v2(236.8,22.12)
  IN3 w0.081: v2(178.82,44.99) 178.89,44.91 180.18,44.91 180.71,45.44 183.42,45.44 184.33,46.36 185.51,46.36 186.44,47.29 187.66,47.29 187.8,47.15 195.47,47.15 198.16,44.45 198.16,43.09 199.56,41.69 199.56,40.36 200.42,39.5 200.42,38.16 202.58,36 203.88,36 207.71,32.16 209.8,32.16 211.72,30.23 211.72,29.14 212.82,28.05 213.87,28.05 215.41,26.51 232.98,26.51 236.93,22.56 236.93,22.25 v2(236.8,22.12)
  BOTTOM w0.109: v2(320.6,12.5) 322.01,12.5 323.07,13.56 325.58,13.56 326.65,14.63 JNGFF1.32
PCH_CL_RST1#: length 176
  TOP w0.089: UH1.AU4 178.74,41.58 178.62,41.47 178.62,41.21 v2(178.5,41.1)
  IN2 w0.081: v2(324.87,14.79) 323.34,13.25 322.77,13.25 320.95,11.42 320.95,10.31 318.61,7.97 313.23,7.97 312.59,8.62 309.4,8.62 308.72,9.29 298.88,9.29 298.41,9.76 290.28,9.76 287.45,12.59 278.53,12.59 275.52,15.59 275.52,16.65 270.29,21.88 244.16,21.88 242.53,20.24 233.59,20.24 231.16,22.68 219.73,22.68 v2(218.48,21.43)
  IN3 w0.081: v2(218.48,21.43) 217.2,22.71 211.06,22.71 209.56,24.21 208.48,24.21 206.53,26.16 201.01,26.16 199.97,27.2 199.97,30.89 196.8,34.06 196.8,36.06 195.37,37.48 195.37,39.3 194.93,39.74 194.02,39.74 192.88,40.88 192.88,41.32 192.1,42.1 180.03,42.1 179.03,41.1 v2(178.5,41.1)
  BOTTOM w0.109: v2(324.87,14.79) 326.15,16.06 JNGFF1.30
PCH_CPU_BCLK_D: length 9
  TOP w0.102: UH1.B8 195.84,39.94 196.73,39.94 197.74,40.95 197.74,41.32 198.07,41.65 198.43,41.65 200.09,43.31 v4(200.09,43.72) 200.09,44.35 200.64,44.9 200.64,44.97 200.78,45.12 201.15,45.12 201.28,44.99 201.28,44.87 RH161.2
PCH_CPU_BCLK_D#: length 9
  TOP w0.102: RH166.2 200.83,45.31 200.71,45.31 200.45,45.05 200.45,44.98 199.9,44.43 199.9,43.39 198.35,41.84 197.99,41.84 197.55,41.4 197.55,41.03 196.65,40.13 195.65,40.13 UH1.C8
PCH_CPU_BCLK_R_D: length 106.5
  TOP w0.102: RH161.1 202.42,45.09 202.55,45.09 202.87,45.42 202.98,45.42 v2(203.12,45.27) ; UC1.B31 218.47,110.14 218.17,110.14 218.11,110.2 217.6,110.2 v2(217.02,110.78)
  IN1 w0.102: v2(203.12,45.27) 202.45,45.27 202.06,45.67 202.06,46.23 199.56,48.72 199.56,51.84 198.23,53.17 198.23,55.29 196.94,56.58 196.02,56.58 195.1,57.49 195.1,58.48 194.06,59.51 193.58,59.51 193.26,59.19 188.6,59.19 186.85,60.93 186.85,68.97 192.03,74.14 192.03,75.89 200.16,84.02 200.16,85.85 200.7,86.38 204.62,86.38 208.46,90.23 208.46,96.65 216.1,104.29 218.22,104.29 218.37,104.44 222.97,104.44 223.56,105.03 223.56,107.1 221.32,109.33 220.47,109.33 219.97,109.83 219.27,109.83 218.9,110.2 217.61,110.2 v2(217.02,110.78)
PCH_CPU_BCLK_R_D#: length 106.5
  TOP w0.102: v2(203.12,45.93) 202.47,45.28 202.34,45.28 RH166.1 ; v2(218,110.81) 217.56,110.81 217.44,110.69 217.44,110.63 217.68,110.39 218.19,110.39 218.25,110.33 218.47,110.33 218.53,110.39 UC1.A32
  IN1 w0.102: v2(218,110.81) 217.56,110.81 217.45,110.7 217.45,110.62 217.69,110.38 218.98,110.38 219.35,110.01 220.05,110.01 220.54,109.52 221.4,109.52 223.75,107.17 223.75,104.95 223.05,104.25 218.45,104.25 218.3,104.1 216.18,104.1 208.65,96.58 208.65,90.15 204.7,86.2 200.78,86.2 200.35,85.77 200.35,83.95 192.22,75.81 192.22,74.06 187.04,68.89 187.04,61.01 188.68,59.38 193.18,59.38 193.5,59.7 194.14,59.7 195.29,58.55 195.29,57.57 196.09,56.77 197.02,56.77 198.41,55.37 198.41,53.25 199.75,51.92 199.75,48.8 201.95,46.6 202.25,46.3 202.25,45.74 202.53,45.46 202.73,45.46 203.12,45.85 v2(203.12,45.93)
PCH_CPU_NSSC_CLK_D: length 10.9
  TOP w0.102: RH169.2 200.89,47.14 200.75,47.14 200.32,46.7 200.32,45.56 200.05,45.29 200.01,45.29 199.67,44.95 199.67,44.92 199.11,44.35 199.11,44.06 197.05,42.01 197.05,41.08 196.49,40.52 195.65,40.52 195.41,40.76 195.14,40.76 UH1.D7
PCH_CPU_NSSC_CLK_D#: length 10.8
  TOP w0.102: UH1.C6 195.41,40.49 195.57,40.33 196.57,40.33 197.24,41 197.24,41.93 199.3,43.98 199.3,44.27 v4(200.04,45.01) 200.51,45.48 200.51,46.62 200.83,46.95 201.28,46.95 201.37,46.85 201.37,46.79 201.12,46.53 RH170.2
PCH_CPU_PCIBCLK_D: length 10.8
  TOP w0.102: UH1.A6 196.38,40.8 196.77,41.19 196.77,42.12 198.7,44.05 198.7,44.58 199.52,45.39 199.52,46.35 v4(199.88,46.71) 200.25,47.09 200.25,48.71 200.38,48.84 200.78,48.84 200.88,48.74 200.88,48.55 RH167.1
PCH_CPU_PCIBCLK_D#: length 10.8
  TOP w0.102: RH168.1 200.46,49.03 200.31,49.03 200.06,48.79 200.06,47.21 199.33,46.47 199.33,45.47 198.51,44.65 198.51,44.13 196.58,42.2 196.58,41.27 196.37,41.06 196.16,41.06 UH1.B6
PCH_CPU_PCIBCLK_R_D: length 103.6
  TOP w0.094: UC1.D35 220.51,112.35 220.66,112.35 220.8,112.21 v2(220.8,111.94)
  TOP w0.102: RH167.2 202,48.76 202.08,48.76 v2(202.31,48.53)
  IN1 w0.102: v2(220.8,111.94) 220.8,111.96 221.25,112.42 223,112.42 224.89,114.3 225.83,114.3 226.27,113.87 226.27,103.57 225.02,102.32 222.46,102.32 222.31,102.16 221.22,102.16 221.06,102.32 218.45,102.32 218.34,102.21 217.25,102.21 209.82,94.78 209.82,89.03 205.07,84.29 204.16,84.29 189.7,69.82 189.7,69.17 188.22,67.69 188.22,63.22 190.27,61.17 194.46,61.17 198.77,56.86 198.77,56.72 199.59,55.9 199.59,54.49 199.94,54.14 200.93,54.14 201.62,53.46 201.62,48.91 201.81,48.72 202.11,48.72 202.11,48.72 v2(202.31,48.53)
PCH_CPU_PCIBCLK_R_D#: length 103.6
  TOP w0.094: UC1.C36 220.68,112.73 v2(220.68,112.73)
  TOP w0.102: v2(202.31,49.19) 202.08,48.95 201.95,48.95 RH168.2
  IN1 w0.102: v2(202.31,49.19) 202.03,48.91 201.89,48.91 201.81,48.99 201.81,53.54 201.01,54.33 200.01,54.33 199.78,54.57 199.78,55.98 198.96,56.8 198.96,56.94 194.54,61.36 190.35,61.36 188.41,63.3 188.41,67.61 189.89,69.09 189.89,69.75 204.24,84.1 205.15,84.1 210,88.95 210,94.7 217.33,102.02 218.42,102.02 218.53,102.13 220.98,102.13 221.14,101.98 222.38,101.98 222.54,102.13 225.1,102.13 226.45,103.49 226.45,113.94 225.91,114.49 224.81,114.49 222.93,112.61 220.8,112.61 v2(220.68,112.73)
PCH_DPB_CTRL_CLK: length 9.3
  TOP w0.102: UH1.AL13 v2(181.08,37.06)
  BOTTOM w0.102: v2(181.08,37.06) 180.59,37.54 v1(180.59,37.99) 180.59,38.87 179.36,40.1 179.36,41.57 178.17,42.76 178.17,43.67 RH628.1
PCH_DPB_CTRL_DATA: length 8.6
  TOP w0.102: UH1.AR8 v2(178.87,39.91)
  BOTTOM w0.089: v2(178.87,39.91) 178.99,40.03 178.99,40.26 178.99,40.27 178.99,40.6 178.99,40.61 178.99,41.25
  BOTTOM w0.102: RH221.1 177.06,46.59 177.06,43.85 177.22,43.69 177.22,43.2 177.75,42.66 177.75,42.49 v1(178.34,41.9) 178.99,41.25
PCH_DPB_HPD: length 153.5
  TOP w0.089: v2(178.59,40.43) 178.62,40.43 178.88,40.7 UH1.AT6
  TOP w0.109: UV66.19 v2(64.06,37.05) ; RV902.1 60.66,36.06 v2(60.75,35.97)
  IN2 w0.081: v2(89.6,37.66) 89.99,38.05 91.65,38.05 97.92,31.77 97.92,30.19 100.03,28.08 100.03,27.33 100.63,26.73 100.98,26.73 101.56,26.15 101.97,26.15 105.21,22.92 105.37,22.92 105.75,22.53 112.66,22.53 113.04,22.15 113.04,21.44 114.24,20.24 115.34,20.24 115.59,20 116.77,20 117.18,19.59 118.61,19.59 118.94,19.92 119.2,19.92 119.5,19.61 119.5,19.35 119.71,19.15 119.71,18.25 120.16,17.79 120.92,17.79 121.6,17.12 126.02,17.12 126.06,17.08 129.43,17.08 130.1,17.74 131.71,17.74 132.4,18.43 135.19,18.43 136.09,17.53 136.9,17.53 137.33,17.96 137.33,18.78 138.16,19.61 139.47,19.61 139.72,19.87 139.72,21.57 140.33,22.18 140.68,22.18 140.84,22.34 140.94,22.34 141.67,23.07 144.59,23.07 145.31,23.78 145.31,23.95 147.69,26.33 148.16,26.33 148.87,27.04 152.42,27.04 153.23,27.85 154.36,27.85 154.6,28.09 157.14,28.09 157.58,28.52 157.89,28.52 158.77,29.4 159.76,29.4 160.14,29.02 160.95,29.02 161.86,29.93 162.37,29.93 163.39,30.95 163.39,33.02 164.45,34.09 167.32,34.09 168.26,35.02 168.26,35.61 168.72,36.07 170.18,36.07 170.44,36.33 170.44,37.09 170.88,37.52 173.37,37.52 174.4,38.55 174.4,39.31 174.94,39.85 176.17,39.85 176.89,40.58 176.89,40.99 177.03,41.13 177.66,41.13 178.36,40.43 v2(178.59,40.43)
  IN3 w0.081: v2(60.75,35.97) 61.16,35.55 61.8,35.55 63.3,37.05 v2(64.06,37.05) 64.28,37.05 64.65,36.67 66.14,36.67 66.39,36.42 68.38,36.42 68.74,36.79 68.74,37.71 69.37,38.34 69.73,38.34 70.38,38.99 70.38,39.37 70.69,39.67 71.94,39.67 72.6,40.33 76.43,40.33 76.97,39.78 78.37,39.78 78.64,39.52 78.64,38.05 79.06,37.63 84.28,37.63 85.16,38.51 86.89,38.51 86.9,38.51 87.22,38.51 87.23,38.51 88.08,38.51 88.93,37.66 v2(89.6,37.66)
PCH_DPC_CTRL_CLK: length 99
  TOP w0.102: UH1.AN13 180.54,37.02 v2(180.06,37.02)
  TOP w0.109: v2(193.73,122.95) 193.49,122.95 192.64,122.11 UV8.22
  IN3 w0.081: v2(194.58,77.03) 194.55,77.06 194.55,77.27 194.52,77.31 194.52,78.6 195.46,79.54 195.46,80.67 194.32,81.81 194.32,86.19 194.59,86.46 194.59,88.99 194.69,89.09 194.69,92.96 194.44,93.21 194.44,95.6 193.3,96.74 193.3,102.09 194.08,102.88 194.08,122.12 193.73,122.47 v2(193.73,122.95)
  BOTTOM w0.102: v2(180.06,37.02) 180.51,36.56 181.12,36.56 181.62,37.07
  BOTTOM w0.109: 181.62,37.07 181.71,37.15 181.71,40.91 182.05,41.25 182.05,41.77 181.84,41.98 RH222.1 182.48,42.93 182.48,43.96 182.03,44.41 182.03,45.26 181.71,45.57 181.71,45.76 181.71,45.77 181.71,47.25 183.39,48.94 183.39,49.99 185.53,52.13 185.53,55.31 189.94,59.72 189.94,61.83 191.54,63.42 192.32,63.42 192.69,63.79 192.69,68.46 193.08,68.85 v1(193.08,70.15) 193.08,73.82 194.58,75.32 v2(194.58,77.03)
PCH_DPC_CTRL_DATA: length 98
  TOP w0.102: UH1.AL10 v2(181.15,38.58)
  TOP w0.109: UV8.23 192.24,122.42 193.29,123.46 v2(194.01,123.46)
  IN3 w0.081: v2(194.01,123.46) 193.58,123.46 193.33,123.22 193.33,122.57 193.85,122.05 193.85,102.97 193.07,102.19 193.07,96.65 194.21,95.5 194.21,93.11 194.46,92.86 194.46,89.19 194.36,89.09 194.36,86.56 194.09,86.29 194.09,81.71 195.23,80.58 195.23,79.64 194.29,78.7 194.29,77.36 194.16,77.23 v2(194.16,76.6)
  BOTTOM w0.102: RH223.1 180.92,42.19 180.92,41.57 181.33,41.15 181.33,38.78 181.15,38.6 v2(181.15,38.58)
  BOTTOM w0.109: RH223.1 180.82,42.4 181.29,42.87 181.29,43.59 180.88,44 180.88,45.27 181.47,45.86 181.47,47.71 182.36,48.6 182.36,49.46 182.82,49.91 182.82,51.09 184.27,52.55 184.27,55.75 186.14,57.62 187.15,57.62 187.7,58.17 187.7,61.76 191.3,65.37 191.3,67.85 192.48,69.03 v1(192.48,71.91) 192.48,73.56 194.34,75.42 194.34,76.49 194.23,76.6 v2(194.16,76.6)
PCH_DPC_HPD: length 97.4
  TOP w0.089: UH1.AN10 v2(179.95,38.24)
  TOP w0.109: v2(195.46,113.88) 195.19,114.15 UV8.3
  IN2 w0.081: v2(179.09,45.82) 179.09,46.58 180.62,48.12 180.62,48.63 181.11,49.12 181.85,49.12 182.54,49.8 183.72,49.8 184.91,50.99 184.91,53.89 189.28,58.26 190.03,58.26 190.36,58.6 192.06,58.6 195.04,61.57 195.04,74.35 191.12,78.26 191.12,88.76 190.94,88.95 190.94,95.98 190.6,96.32 190.6,103.82 193.64,106.86 193.64,112.05 v2(195.46,113.88)
  IN4 w0.102: v2(179.09,45.82) 182.21,42.7 182.21,40.46 183.04,39.62 183.04,38.71 182.44,38.1 180.58,38.1 180.45,38.24 v2(179.95,38.24)
  BOTTOM w0.109: v1(180.75,46.35) 180.22,45.82 v2(179.09,45.82)
PCH_DPD_CTRL_CLK: length 7.2
  TOP w0.102: UH1.AL9 v2(180.91,39.31)
  BOTTOM w0.102: RH224.1 179.31,45.02 179.31,43.23 180.32,42.22 180.32,41.46 180.91,40.88 v1(180.91,40.29) v2(180.91,39.31)
PCH_DPD_CTRL_DATA: length 10.9
  TOP w0.102: RH225.1 175.83,50.26 v1(175.83,49.04) 175.83,48.64 176.37,48.1 176.82,48.1 177.28,47.64 177.78,47.64 179.48,45.95 179.48,42.88 179.59,42.77 179.59,42.32 UH1.AR3
PCH_DPD_HPD: length 130.6
  TOP w0.089: UH1.AP9 v2(179.44,39.31)
  TOP w0.109: JDGFF4.A10 171.67,137.29 v2(171.4,137.56) ; v2(191.23,103.85) v1(191.99,103.85)
  IN2 w0.081: v2(191.23,103.85) 190.83,103.44 190.83,96.42 191.17,96.08 191.17,89.04 191.35,88.86 191.35,78.4 195.33,74.43 195.33,61.54 192.58,58.8 192.58,58.26 191.77,57.44 188.79,57.44 185.17,53.82 185.17,50.89 184.33,50.05 184.33,49.66 183.56,48.89 181.21,48.89 180.85,48.53 180.85,48.02 179.53,46.7 179.53,44.62 179.18,44.27 179.18,41.69 180.33,40.54 180.33,40.05 179.59,39.31 v2(179.44,39.31)
  IN4 w0.102: v2(191.23,103.85) 189.53,105.54 186.41,105.54 181.12,110.84 180.28,110.84 178.14,112.98 173.82,112.98 173.55,113.25 171.36,113.25 171.19,113.07 170.36,113.07 169.72,113.71 169.72,135.89 v2(171.4,137.56)
  BOTTOM w0.109: RH630.2 179.15,39.03 v2(179.44,39.31)
PCH_DPWROK: length 69
  TOP w0.089: UH1.AW41 177.09,23.58 176.87,23.36 v2(176.87,23.32)
  TOP w0.109: v2(157.82,19.68) 157.52,19.68 157.12,19.28 157.12,18.65 157.39,18.37 158.17,18.37 158.4,18.13 158.4,17.65 158.03,17.28 157.43,17.28 156.99,16.84 155.12,16.84 153.58,18.38 153.58,18.91 151.3,21.18 151.3,21.66 150.51,22.45 146.48,22.45 v2(146.28,22.25)
  IN3 w0.081: v2(176.87,23.32) 176.06,23.32 175.43,22.69 173.36,22.69 172.74,23.31 167.74,23.31 167.08,23.97 166.27,23.97 166.12,24.12 164.16,24.12 163.24,25.05 162.87,25.05 162.52,24.7 162.52,23.88 160.39,21.75 159.92,21.75 157.85,19.68 v2(157.82,19.68)
  BOTTOM w0.109: RE536.1 142.76,32.1 144.21,32.1 144.39,31.92 v3(144.72,31.92) 145.17,31.92 146.1,30.99 146.1,28.24 147.11,27.24 147.11,26.13 145.45,24.48 145.45,23.08 v2(146.28,22.25) ; v2(176.87,23.32) 176.27,23.32 176.02,23.07 175.05,23.07 174.82,23.3 172.67,23.3 RH308.1 171.9,22.52 171.9,21.45 172.79,20.57 CH266.1 172.32,19.09 171.69,19.71 170.39,19.71 RH215.1
PCH_DPWROK_EC: length 10.5
  TOP w0.102: UE1.F8 v2(135.93,25.65)
  BOTTOM w0.109: v2(135.93,25.65) 136.33,26.04 136.33,26.6 136.59,26.86 136.95,26.86 137.14,27.05 137.14,27.42 137.38,27.66 137.83,27.66 139.54,29.37 139.54,29.83 139.79,30.08 140.25,30.08 140.49,30.08 140.84,30.42 v1(140.84,31.07) 140.84,31.48 141.39,32.03 RE536.2
PCH_INTRUDER_HDR#: length 2.7
  TOP w0.102: UH1.BB44 176.29,22.26 v2(176.29,21.84)
  BOTTOM w0.109: v1(175.38,21.85) 175.38,21.84 v2(176.29,21.84) 176.41,21.73 RH198.2
PCH_JTAG_TCK: length 157.8
  TOP w0.102: UH1.AJ3 182.58,42.19 182.66,42.27 182.66,45.71 182.58,45.79 182.58,45.8 182.13,46.26 v2(182.13,46.78)
  TOP w0.109: JXDP1.55 283.87,95.45 v2(283.79,95.53)
  BOTTOM w0.109: RH313.1 182.13,46.17 v2(182.13,46.78) 183.88,48.53 183.88,49.79 186.06,51.96 186.06,55.14 190.46,59.54 191.67,59.54 193.57,61.44 193.57,63.14 192.93,63.78 192.93,68.36 193.57,69.01 193.57,73.98 197.53,77.94 v3(197.53,78.3) 197.86,78.63 203.22,78.63 208.66,73.19 252.2,73.19 252.83,72.56 275.32,72.56 278.25,75.49 284.3,75.49 285.08,76.27 285.08,94.24 v2(283.79,95.53)
PCH_JTAG_TDI: length 177.9
  TOP w0.102: UH1.AH2 183.08,42.96 183.04,42.99 183.04,45.89 182.71,46.23 182.71,46.92 182.81,47.02 182.81,47.73 182.31,48.22 182.31,48.3 181.82,48.78 181.82,50.04 v2(181.92,50.14)
  TOP w0.109: RC229.2 278.53,95.98 CC304.1 278.14,96.56 277.71,97 277.71,100.54 278.5,101.33 v2(278.77,101.33)
  IN2 w0.081: v2(192.93,75.42) 193.74,74.61 193.74,65.76 194.47,65.03 194.47,61.88 191.65,59.05 190.17,59.05 189.84,58.72 187.82,58.72 187.3,58.2 187,58.2 184.28,55.48 183.33,55.48 182.73,54.88 182.73,53.33 v2(182.06,52.66) ; v2(283.16,88.37) 283.16,88.4 284.48,89.73 284.48,99.9 282.86,101.53 278.96,101.53 v2(278.77,101.33)
  BOTTOM w0.102: RH314.1 v2(182.06,52.66)
  BOTTOM w0.109: v2(181.92,50.14) 181.92,52.52 v2(182.06,52.66) ; v2(283.16,88.37) 283.16,88.11 284.46,86.81 284.46,76.54 283.97,76.05 277.59,76.05 274.66,73.13 253.59,73.13 252.95,73.77 208.95,73.77 203.47,79.25 v3(199.42,79.25) 195.79,79.25 192.93,76.38 v2(192.93,75.42)
PCH_JTAG_TDO: length 151.7
  TOP w0.102: 182.5,47.68 182.62,47.57 182.62,47.15 182.5,47.03 182.5,46.15 182.78,45.87 182.78,45.86 182.85,45.79 182.85,42.47 183.05,42.27 UH1.AH3
  TOP w0.109: v2(267.23,93.1) 267.28,93.1 267.76,92.62 267.76,92.01 267.46,91.71 267.46,83.59 258.84,74.97 215.57,74.97 205.9,84.64 199.42,84.64 195.72,80.93 194.76,80.93 191.7,77.87 189.92,77.87 189.15,77.1 189.15,71.77 189.72,71.2 189.72,68.76 185.19,64.22 183.59,64.22 180.49,61.12 180.49,55.43 180.47,55.41 180.47,51.68 RH315.1 181.5,50.61 181.5,48.71 182.06,48.16 182.06,48.12 182.5,47.68 ; RC230.2 CC303.1 275.2,94.6 v2(274.87,94.27)
  IN3 w0.081: v2(274.87,94.27) 274.61,94.27 274.02,94.86 272.95,94.86 272.24,95.57 270.08,95.57 267.61,93.1 v2(267.23,93.1)
  BOTTOM w0.109: v3(267.68,93.54) 267.24,93.1 v2(267.23,93.1)
PCH_JTAG_TMS: length 166.5
  TOP w0.102: v2(181.4,48.29) 181.8,47.88 181.8,46.98 181.74,46.92 181.74,46.36 182.47,45.63 182.47,42.34 182.35,42.22 182.35,41.82 UH1.AJ4
  TOP w0.109: CC336.1 278.28,97.51 RC228.2 278.28,98.28 278.65,98.64 279.74,98.64 v2(280.95,97.43)
  BOTTOM w0.109: v2(181.4,48.29) 180.97,48.29 RH312.1 181.52,49.32 181.77,49.32 182.51,50.06 182.51,51.15 184.04,52.68 184.04,55.85 186.05,57.86 187.05,57.86 187.43,58.24 187.43,62.04 v3(188.07,62.68) 188.07,62.69 190.97,65.58 190.97,67.84 192.15,69.03 192.15,73.77 193.61,75.24 193.61,76.73 195.74,78.86 203.47,78.86 208.82,73.51 252.5,73.51 253.14,72.88 275.3,72.88 278.18,75.76 284.09,75.76 284.69,76.37 284.69,93.99 283.37,95.31 283.37,96.92 282.87,97.43 v2(280.95,97.43)
PCH_JTAGX: length 164.5
  TOP w0.089: UH1.AH4 183.13,41.83 183.3,42 183.3,42.86 183.3,42.86 183.49,43.05 183.49,46.56 183.11,46.95 183.11,47.98
  TOP w0.109: 183.11,47.98 182.41,48.69 182.41,50.53 181.52,51.42 181.52,54.31 180.8,55.03 180.8,60.89 183.64,63.73 185.1,63.73 189.96,68.59 189.96,71.3 189.39,71.87 189.39,77 190.02,77.64 192.75,77.64 199.45,84.33 205.45,84.33 215.3,74.48 259.04,74.48 267.95,83.39 267.95,91.5 268.25,91.8 268.25,92.91 268.17,93 268.17,94.29 v2(267.81,94.65) ; v2(283.28,101.73) 283.34,101.67 CC305.1 RC166.2 283.99,100.84 RC143.2
  IN3 w0.081: v2(283.28,101.73) 282.85,102.16 275.98,102.16 268.47,94.65 v2(267.81,94.65)
  BOTTOM w0.109: v2(283.28,101.73) 283.3,101.73 v3(283.92,101.11)
PCH_PCIE_WAKE#: length 229
  TOP w0.109: v2(151.16,18.36) 151.16,18.79 151.66,19.28 152.72,19.28 153.33,18.67 153.33,18.15 154.89,16.59 157.08,16.59 157.44,16.95 160.37,16.95 160.85,17.44 163.21,17.44 163.73,16.92 164.84,16.92 165.69,16.06 168.92,16.06 169.31,16.45 RH92.1 174.55,17.17 175.83,18.45 175.83,19.88 UH1.BB47 ; v2(133.98,10.66) 133.98,10.68 132.76,11.9 128.3,11.9 128.07,12.12 128.07,13.21 127.74,13.54 125.97,13.54 124.2,15.32 124.2,18.6 124.72,19.12 v1(124.72,19.64) 124.72,19.67 124.95,19.9 127.34,19.9 127.74,20.3 RE274.2 127.74,20.34 127.85,20.45 129.19,20.45 129.93,21.2 UE1.L1 ; v2(39.3,44.32) 39.3,44.33 39.42,44.45 RT445.1
  IN2 w0.081: v2(82.79,7.52) 82.79,7.76 83.36,8.34 83.36,9.16 82.87,9.65 80.92,9.65 79.82,10.75 79.82,16.49 80.41,17.08 82.6,17.08 83.45,17.93 83.45,23.81 83.58,23.94 83.58,24.98 83.45,25.12 83.45,25.53 83.21,25.76 81.1,25.76 80.54,25.2 74.46,25.2 72.77,26.89 72.77,28.85 74.15,30.24 74.15,30.96 73.58,31.54 73.58,32.31 73.36,32.53 73.36,34.68 71.44,36.61 66.88,36.61 65.77,37.72 65.77,39 66.27,39.51 67.51,39.51 70.25,42.24 v2(70.25,42.48)
  IN3 w0.081: v2(70.25,42.48) 69.93,42.48 67.15,39.71 66.6,39.71 65.9,39.01 58.04,39.01 57.33,38.3 56.4,38.3 56.05,38.65 53.82,38.65 53.52,38.95 49.78,38.95 49.15,38.32 46.9,38.32 46.61,38.62 45.74,38.62 45.05,39.31 44.4,39.31 44.25,39.46 44.25,40.35 40.52,44.07 39.55,44.07 v2(39.3,44.32) ; v2(133.98,10.66) 133.58,11.06 132.79,11.06 132.69,10.96 132.69,10.34 132.46,10.11 129.33,10.11 129.24,10.02 122.06,10.02 121.01,11.08 119.33,11.08 118.88,10.63 111.4,10.63 109.78,12.26 96.13,12.26 92.77,8.9 92.46,8.9 92.23,8.66 92.23,8.55 91.11,7.43 82.89,7.43 v2(82.79,7.52)
  BOTTOM w0.109: v2(133.98,10.66) 134.85,10.66 135.42,10.08 139.97,10.08 141.56,11.67 142.98,11.67 143.66,12.35 143.66,13.77 147.5,17.61 147.5,18.25 148.25,19 150.75,19 151.16,18.58 v2(151.16,18.36)
PCH_PECI: length 12.4
  TOP w0.089: 183,49.84 183.8,49.03 183.8,47.37 183.89,47.29 183.89,42.91 183.76,42.78 UH1.AF2
  TOP w0.102: 183,49.84 183,50.74 182.28,51.46 RH74.1
  TOP w0.109: v1(181.87,53.5) 182.23,53.5 RH73.1 182.8,52.54 182.28,52.02 RH74.1
PCH_PLTRST#: length 167.3
  TOP w0.076: UH1.AV29 177.91,29.75 176.56,29.75 176.21,29.4 175.34,29.4 175.08,29.28 174.51,29.28 174.5,29.3 171.16,29.3 171.15,29.28 171.14,29.28 171.11,29.25 171.07,29.21 167.52,29.21 167.1,28.8 165.94,28.8
  TOP w0.109: 165.94,28.8 165.42,28.8 165.2,28.58 164.52,28.58 162.93,27 160.98,27 160.62,26.64 159.6,26.64 159.39,26.84 159.39,27.95 160.07,28.63 160.07,30.6 159.77,30.9 159.28,30.9 159.06,30.67 159.06,30.52 158.85,30.31 157.95,30.31 157.69,30.58 RH626.1 157.69,31.77 157.71,31.79 157.71,32.76 RH623.2 RH625.2 157.66,33.75 RH624.2 157.58,34.69 v1(156.73,34.69) 156.63,34.6 156.63,34.36 v2(156.94,34.05)
  IN3 w0.081: v2(156.94,34.05) 156.78,34.21 156.78,38.22 153.4,41.6 151.09,41.6 150.71,41.98 150.28,41.98 150.01,42.26 141.69,42.26 140.1,43.85 139.39,43.85 138.66,44.59 138.01,44.59 137.43,44.01 136.88,44.01 136.32,43.44 125.55,43.44 123.9,41.79 117.57,41.79 114.83,44.53 107.06,44.53 106.27,45.32 95.82,45.32 92.03,41.53 91.54,41.53 90.99,40.98 88.34,40.98 88.13,40.78 81.49,40.78 80.14,42.13 77.06,42.13 75.4,43.79 71.21,43.79 70.56,43.14 69.99,43.14 66.98,40.12 66.43,40.12 65.89,39.59 65.73,39.42 57.86,39.42 57.16,38.72 56.57,38.72 56.22,39.07 53.99,39.07 53.1,39.96 50.2,39.96 48.98,38.74 47.11,38.74 46.79,39.06 45.95,39.06 45.56,39.45 45.56,39.83 v2(44.31,41.08)
  BOTTOM w0.109: RH641.1 CH349.1 156.47,33.58 156.72,33.84 156.72,33.84 v2(156.94,34.05) ; UH7.1 UH7.2 44.46,40.93 v2(44.31,41.08)
PCH_PLTRST#_AND: length 5.5
  BOTTOM w0.109: UH7.4 45.09,40.28 45.26,40.1 45.26,39.64 44.99,39.36 RH619.1 RH65.1 45.7,38.22 RH622.1 45.96,37.95 45.96,37.29 v1(45.82,37.15) 45.24,37.15 CH350.1
PCH_PLTRST#_R: length 476
  TOP w0.109: v2(339.98,5.36) 339.74,5.59 338.52,5.59 337.02,7.09 337.02,7.68 337.63,8.28 337.63,10.25 v2(337.52,10.36) ; v2(85.04,34.34) 84.62,33.92 84.62,30 84.5,29.88 84.5,29.29 83.58,28.36 83.58,25.79 83.77,25.6 83.77,22.97 83.33,22.53 83.33,19.35 83.53,19.15 v1(83.53,13) 83.53,12.94 v2(82.66,12.07) ; RT499.1 RT612.1 117.33,15.04 v2(117.05,14.76) ; v2(152.53,18.35) 152.53,18.13 154.54,16.12 157.27,16.12 157.51,16.36 158.55,16.36 159.5,15.41 160.15,15.41 160.38,15.64 160.38,15.9 161.2,16.73 162.91,16.73 165.34,14.3 165.34,13.69 167.99,11.03 172.51,11.03 175.1,13.62 v2(175.1,14.39)
  IN1 w0.102: v2(93.18,37.8) 92.67,38.31 89.23,38.31 87.16,40.38 v2(82.37,40.38)
  IN2 w0.081: v2(253.9,18.97) 255.06,17.81 265.81,17.81 267.8,15.82 268.52,15.82 270.02,14.32 270.02,12.58 270.31,12.28 270.65,12.28 271.57,11.36 274.09,11.36 277.54,7.9 285.33,7.9 v2(285.9,7.34) 286.33,6.91 286.33,6.33 287.27,5.39 289.99,5.39 290.97,6.38 305.54,6.38 306.69,5.22 308.72,5.22 308.95,4.99 312.85,4.99 313.53,4.31 320.57,4.31 323.87,7.62 325.03,7.62 326.88,9.47 328.45,9.47 328.92,9.94 334.33,9.94 334.8,10.42 337.46,10.42 v2(337.52,10.36)
  IN3 w0.081: v2(44.64,39.7) 45.01,39.7 45.88,38.83 46.69,38.83 46.99,38.53 49.06,38.53 49.69,39.16 53.61,39.16 53.9,38.86 56.13,38.86 56.48,38.51 57.25,38.51 57.95,39.21 65.81,39.21 66.51,39.92 67.06,39.92 70.04,42.89 70.61,42.89 71.3,43.58 75.29,43.58 76.95,41.92 80.04,41.92 81.57,40.38 v2(82.37,40.38) ; v2(253.9,18.97) 251.84,16.91 232.45,16.91 228.4,12.86 212.69,12.86 208.09,8.25 208.09,7.62 v2(208.66,7.05) ; v2(85.04,34.34) 84.47,34.91 84.47,36.47 85.03,37.02 91.32,37.02 92.09,37.8 v2(93.18,37.8)
  IN4 w0.076: JNGFF4.50 350.65,7.56
  IN4 w0.102: 350.65,7.56 350.65,7.84 350.05,8.44 345.9,8.44 345.15,9.2 342.28,9.2 341.26,8.18 341.26,5.9 340.72,5.36 v2(339.98,5.36) ; v2(175.1,14.39) 175.16,14.39 175.64,14.88 176.75,14.88 177.1,14.52 177.1,13.89 179.05,11.94 179.58,11.94 180.12,11.4 180.77,11.4 180.97,11.21 185.39,11.21 186.19,10.41 196.58,10.41 196.79,10.62 199.51,10.62 201.91,8.22 204.88,8.22 205.17,7.93 206.87,7.93 207.75,7.05 v2(208.66,7.05)
  BOTTOM w0.109: v2(82.66,12.07) 82.83,11.9 JNGFF5.50 91.81,11.9 93.11,13.2 109.08,13.2 109.57,13.69 116.33,13.69 116.87,14.22 116.87,14.58 v2(117.05,14.76) 117.6,14.21 117.6,13.4 118.22,12.78 118.22,12.21 120.56,9.87 122.85,9.87 123.76,10.77 124.21,10.77 125.07,11.64 125.07,12.4 125.21,12.6 125.21,12.61 126.3,13.71 126.3,15.16 126.5,15.35 127.03,15.35 127.34,15.05 127.34,14.33 128.12,13.55 128.12,13.14 128.31,12.95 128.31,12.46 125.67,9.82 124.2,9.82 122.48,8.1 122.48,4.95 122.75,4.69 124.88,4.69 125.32,4.24 127.67,4.24 129,5.58 129,6.57 130.86,8.43 130.86,9.14 131.37,9.65 132.99,9.65 133.57,10.23 133.57,11.15 133.81,11.4 134.44,11.4 135.52,10.32 138.16,10.32 138.93,11.08 139.42,11.08 139.61,10.89 140.44,10.89 141.46,11.91 142.88,11.91 143.43,12.45 143.43,13.87 147.22,17.66 147.22,18.3 148.26,19.34 151.53,19.34 v2(152.53,18.35) ; JNGFF2.42 301.75,9.26 300.85,8.36 294.47,8.36 293.61,9.22 293.61,10.81 293.49,10.93 291.39,10.93 290.91,11.4 288.97,11.4 288.04,10.47 285.88,10.47 285.35,9.94 285.35,7.89 v2(285.9,7.34) ; v2(82.37,40.38) 82.92,39.84 82.92,37.24 83.21,36.95 JNGFF3.50 ; RH619.2 44.07,39.13 v2(44.64,39.7) ; v2(337.52,10.36) 337.63,10.48 337.63,11.93 337.09,12.47 333.88,12.47 333.2,13.15 333.2,15.67 332.68,16.19 330.08,16.19 329.65,16.62 JNGFF1.44
PCH_PRIM_EN: length 293.5
  TOP w0.109: v2(164.72,22.83) 164.72,23.37 RH441.2 ; v2(128.1,8.42) 128.33,8.19 PR901.2 ; v2(154.86,14.51) 152.17,17.2 v1(151.82,17.2) 151.19,17.2 150.7,17.69 150.7,19.18 151.7,20.18 v2(151.7,20.2) ; v2(163.86,40.12) 163.45,39.71 163.1,39.71 161.24,41.57 161.24,44.58 171.86,55.2 172.53,55.2 176.42,59.09 176.42,63.22 181.28,68.08 182.8,68.08 186.53,71.81 186.53,73.65 187.62,74.73 187.62,77.65 189.32,79.35 191.2,79.35 198.52,86.67 199.92,86.67 200.53,86.06 206.45,86.06 216.14,76.36 258.26,76.36 266.07,84.17 266.07,92.6 v2(266.32,92.86) ; v2(280.78,81.23) 280.78,81.73 280.14,82.36 UZ34.1
  IN2 w0.081: v2(151.7,20.2) 152.79,20.2 153.47,20.89 155.32,20.89 156.16,20.05 157.6,20.05 157.73,20.18 158,20.18 158.3,19.88 158.3,19.41 158.7,19.01 v2(158.86,19.01)
  IN3 w0.081: v2(133.08,10.66) 133.08,10.34 132.62,9.87 129.56,9.87 v2(128.1,8.42) ; v2(164.72,22.83) 162.96,21.07 161.85,21.07 159.79,19.01 v2(158.86,19.01)
  IN4 w0.102: v2(280.78,81.23) 280.18,81.83 280.18,83.44 278.5,85.11 278.5,85.42 278,85.92 276.92,85.92 275.43,87.41 273.51,87.41 273.03,86.93 270.69,86.93 266.32,91.29 v2(266.32,92.86) ; v2(164.72,22.83) 164.72,22.85 165.05,23.18 165.05,25 164.33,25.72 163.76,25.72 163.15,26.34 163.15,27.22 163.91,27.98 163.91,28.85 161.36,31.4 161.36,32.99 160.1,34.25 160.1,35.77 163.86,39.53 v2(163.86,40.12) ; v2(104.83,21.75) 104.83,17.41 105.66,16.58 115.69,16.58 116.27,17.15 117.82,17.15 118.25,16.72 118.25,15.7 125.54,8.42 v2(128.1,8.42) ; v2(154.86,14.51) 154.69,14.69 153.56,14.69 151.93,16.31 148.14,16.31 146.25,14.42 146.25,13.72 146.6,13.36 146.6,12.81 145.33,11.53 141.46,11.53 140.65,10.72 139.79,10.72 139.23,11.28 134.27,11.28 134.05,11.07 133.49,11.07 v2(133.08,10.66)
  BOTTOM w0.109: RH442.2 151.7,21.53 v2(151.7,20.2) ; v2(104.83,21.75) 104.83,22.13 RZ509.1 ; PR803.1 154.83,14.48 v2(154.86,14.51)
PCH_PWROK: length 210.3
  TOP w0.089: UH1.AY42 177.02,22.83 176.55,22.83 176.54,22.82 v2(176.53,22.82)
  TOP w0.109: PU1100.45 263.78,149.51 v2(263.67,149.62) 263.89,149.84 PR1114.2
  IN1 w0.102: v2(200.64,117.89) 200.47,118.06 200.47,119.18 205.86,124.58 205.86,131.67 208.38,134.19 213.24,134.19 214.09,135.04 216.24,135.04 222.6,141.4 226.66,141.4 234.87,149.61 239.34,149.61 241.29,151.55 v2(241.29,152.75)
  IN2 w0.081: v2(176.53,22.82) 176.41,22.94 176.41,23.64 176.53,23.77 176.99,23.77 177.09,23.86 177.57,23.86 178.83,25.12 179.31,25.12 179.72,25.53 179.72,26.83 179.42,27.14 179.42,28.01 178.87,28.55 178.87,29.51 179.03,29.67 180.02,29.67 180.28,29.92 180.28,30.66 180.08,30.86 180.08,32.81 181.11,33.84 181.11,36.3 181.45,36.63 181.45,37.91 181.7,38.17 181.7,40.83 181.19,41.35 181.19,42.97 185.05,46.82 185.05,46.96 185.28,47.2 185.28,49.71 186.08,50.51 186.08,53.45 188.13,55.49 192.21,55.49 192.9,56.18 195.38,56.18 195.81,56.61 195.81,59.03 196.91,60.13 196.91,61.09 197.32,61.5 197.32,62.12 196.91,62.53 196.91,65.73 197.6,66.43 197.6,79.03 193.8,82.83 193.8,85.86 192.06,87.6 192.06,89.11 191.89,89.29 191.89,96.32 191.52,96.7 191.52,102.21 191.89,102.59 191.89,103.55 194.61,106.26 194.61,110.25 195.11,110.75 195.11,111.84 196.38,113.11 196.38,114.25 200.02,117.89 v2(200.64,117.89)
  IN4 w0.102: v2(241.29,152.75) 244.8,149.23 261.7,149.23 262.37,148.57 263.4,148.57 263.67,148.83 v2(263.67,149.62)
  BOTTOM w0.102: RH424.1 176.86,19.98 v3(176.86,21.85) 176.86,22.5 176.55,22.81 176.54,22.81 v2(176.53,22.82)
PCH_RSMRST#: length 39.7
  TOP w0.109: v2(136.25,17.94) 136.53,17.66 136.53,14.58 136.97,14.14 137.84,14.14 138.04,13.94 RZ1413.1 ; UZ6.1 118.62,11.64 118.4,11.85 117.54,11.85 116.91,12.49 114.67,12.49 RE342.1 114.53,13.05 114.78,13.29 v1(114.78,13.71) 114.78,14.2 114.48,14.5 v2(114.48,14.73) ; v2(131.93,18.47) 132.65,19.19 132.65,19.96 UE1.M5
  IN2 w0.081: v2(136.25,17.94) 135.58,18.6 132.06,18.6 v2(131.93,18.47)
  IN3 w0.081: v2(114.48,14.73) 114.9,14.3 119.23,14.3 119.46,14.53 121.54,14.53 122.58,15.57 126.06,15.57 127.21,16.73 129.79,16.73 130.44,17.38 131.41,17.38 132.13,18.09 132.13,18.27 v2(131.93,18.47)
PCH_RSMRST#_AND: length 274.4
  TOP w0.102: UH1.BA47 176.03,20.26 176.03,18.37 174.55,16.89 171.22,16.89 v2(170.99,16.67)
  TOP w0.109: v2(133.85,8.77) 133.85,9.2 133.58,9.47 131.32,9.47 130.91,9.06 129.05,9.06 128.86,9.25 126.95,9.25 126.49,8.79 125.28,8.79 123.05,6.56 v1(121.87,6.56) 121.4,6.56 120.18,7.77 120.18,10.33 119.98,10.53 118.2,10.53 117.71,10.04 117.5,10.04 117.32,9.86 UZ6.4 ; v2(151.76,18.38) 151.76,18.45 152.08,18.77 152.81,18.77 153.09,18.49 153.09,18.01 154.74,16.36 157.18,16.36 157.54,16.72 160.47,16.72 160.95,17.2 163.1,17.2 164.52,15.79 169.04,15.79 170.11,16.86 170.8,16.86 v2(170.99,16.67)
  IN3 w0.081: v2(181.55,60.59) 180.4,60.59 174.05,54.23 172.82,54.23 166.36,47.78 166.36,46.73 164.41,44.78 164.41,43.89 163.78,43.26 163.78,40.95 164.58,40.15 164.58,38.45 165.01,38.02 165.01,35.21 167.23,33 167.23,32.24 168.85,30.62 169.36,30.62 171.64,28.34 171.64,26.95 172.22,26.37 173.07,26.37 174.02,25.41 175.77,25.41 177.26,26.9 179.09,26.9 179.49,26.51 179.49,24.55 179.05,24.11 179.05,23.61 179.29,23.37 179.29,21.92 178.63,21.27 178.1,21.27 177.69,21.68 177.2,21.68 176.61,22.27 176.13,22.27 175.7,21.83 175.26,21.83 174.14,20.71 173.19,20.71 v2(171.44,18.96)
  BOTTOM w0.109: v2(133.85,8.77) 134.23,9.15 137.7,9.15 138.19,9.64 139.86,9.64 141.66,11.43 143.08,11.43 143.9,12.26 143.9,13.68 148.14,17.92 151.36,17.92 151.76,18.31 v2(151.76,18.38) ; v2(181.55,60.59) 182.63,60.59 187.56,65.51 187.56,70.15 189.3,71.89 189.3,76.92 194.66,82.28 197.2,82.28 198.94,84.02 204.79,84.02 211.88,76.93 257.15,76.93 257.89,76.19 272.56,76.19 276.51,80.15 277.54,80.15 278.51,81.12 278.51,81.84 277.95,82.41 277.95,83.43 278.2,83.69 278.2,84.35 277.37,85.18 277.37,85.78 278.53,86.93 RC124.1 ; v2(171.44,18.96) 170.8,18.96 170.33,18.5 RH215.2 169.74,18.15 169.74,17.39 RC75.1 170.46,16.67 v2(170.99,16.67)
PCH_RTCRST#: length 217.7
  TOP w0.109: v2(165.96,18.9) 165.96,18.76 165.63,18.44 165.63,18.28 RH200.2 165.65,17.78 165.25,17.39 CH40.2 ; v2(175.19,20.21) 174.86,20.54 UH1.BE47 ; JAPS1.9 v2(17.36,4.35) ; v2(153.18,38.83) 154.13,37.88 v3(154.13,37.14) 154.13,35.82 153.74,35.43 152.34,35.43 151.46,34.55 RE94.2
  IN1 w0.102: v2(99.23,34.05) 99.88,34.69 99.88,35.93 102.26,38.32 102.26,39.23 101.93,39.56 101.93,41.06 v2(103.21,42.35)
  IN2 w0.081: v2(175.19,20.21) 174.45,19.47 170.5,19.47 170.23,19.21 168.63,19.21 168.26,18.84 166.02,18.84 v2(165.96,18.9) ; v2(17.36,4.35) 17.64,4.06 18.45,4.06 18.67,4.29 18.67,5.88 19.14,6.34 19.14,7.53 20.67,9.06 25.94,9.06 28.33,11.45 31.36,11.45 32.23,12.32 33.29,12.32 33.86,11.75 35.46,11.75 37.43,13.72 42.78,13.72 46.51,17.45 46.51,18.55 46.92,18.96 47.7,18.96 48,18.66 53.3,18.66 54.64,19.99 57.17,19.99 58.34,21.17 58.34,21.92 58.7,22.27 59.09,22.27 59.31,22.27 59.67,21.92 59.67,21.82 60.54,20.95 63.4,20.95 63.86,21.41 75.87,21.41 76.65,22.19 76.65,23.72 77.61,24.68 80.23,24.68 81.21,23.7 82.25,23.7 v2(82.84,24.29)
  IN3 w0.081: v2(103.21,42.35) 103.63,42.77 106.77,42.77 108.57,40.97 116.93,40.97 117.08,41.11 124.4,41.11 125.99,42.7 137.55,42.7 137.64,42.61 140.39,42.61 141.43,41.57 149.38,41.57 149.81,41.14 149.81,40.86 150.13,40.54 152.31,40.54 152.92,39.93 152.92,39.33 153.18,39.06 v2(153.18,38.83) 153.2,38.81 153.82,38.81 156,36.63 156,33.8 158.87,30.93 158.87,25.01 v2(160.17,23.7) ; v2(99.23,34.05) 98.07,32.88 97.11,32.88 94.77,30.54 88.26,30.54 87.41,29.69 87.41,27.54 87.88,27.08 87.88,26.63 87.46,26.22 87.46,25.5 86.89,24.92 84.58,24.92 83.98,24.32 82.88,24.32 v2(82.84,24.29)
  IN4 w0.102: v2(160.17,23.7) 160.55,23.7 161.87,22.38 162.25,22.38 162.5,22.13 162.5,21.38 162.97,20.92 163.49,20.92 164.03,20.37 164.03,19.78 164.86,18.95 165.91,18.95 v2(165.96,18.9)
  BOTTOM w0.109: v2(165.96,18.9) 165.43,18.37 CMOS1.2
PCH_RTCX1: length 7
  TOP w0.102: 173.01,15.36 173.7,16.04 v1(173.97,16.04) 174.24,16.04 176.56,18.36 176.56,19.51 UH1.BA49
  TOP w0.109: RH43.2 172.18,15.32 RH44.1 173.01,15.36
PCH_RTCX1_R: length 3.5
  TOP w0.109: YH1.1 171.2,12.92 170.88,13.24 170.88,13.96 170.83,14.01 CH4.2 171.3,14.44 171.32,14.43 RH43.1
PCH_RTCX2: length 13
  TOP w0.102: UH1.BA48 176.25,19.91 176.25,18.32 174.31,16.39 173.7,16.39 173.55,16.23 RH44.2
  TOP w0.109: YH1.2 169.87,12.92 170.12,13.17 170.12,14.05 CH5.2 169.74,14.43 170.21,14.9 170.21,15.79 170.45,16.03 171.51,16.03 171.75,16.28 v1(171.78,16.28) 172.55,16.28 172.59,16.23 RH44.2
PCH_SMB_ALERT#: length 9
  TOP w0.102: UH1.BE25 174.35,31.7 173.43,31.7 173.4,31.74 170.36,31.74 170.31,31.79 169.64,31.79 169.57,31.85 167.6,31.85 167.54,31.79 v1(167.13,31.79) 167,31.79 166.89,31.69 166.04,31.69 RH61.2
PCH_SPI_CLK: length 89.6
  TOP w0.089: 177.74,19.54 177.74,19.96 177.59,20.11 177.59,20.47 177.67,20.55 UH1.AW47
  TOP w0.109: v2(175.12,12.04) 177.18,14.1 177.18,14.47 177.74,15.03 177.74,17.05 177.31,17.48 v1(177.31,17.54) 177.31,17.64 177.59,17.92 177.59,18.9 177.74,19.05 177.74,19.54
  BOTTOM w0.109: 168.64,62.13 168.87,61.89 169.66,61.89 JSPI1.8 172.75,58.8 172.75,57.89 173.51,57.13 173.51,56.03 170.89,53.42 169.94,53.42 169.53,53 169.53,50.07 164.36,44.9 164.36,44.26 161.23,41.13 161.23,39.47 157.65,35.88 157.65,33.25 157.37,32.97 157.37,31.39 157.06,31.08 157.06,30.13 156.74,29.81 156.74,27.03 158.73,25.05 158.73,23.45 158.38,23.1 158.38,20.37 RH640.1 158.29,20.26 158.29,18.99 158.94,18.34 159.44,18.34 159.87,18.77 160.05,18.77 160.18,18.64 160.18,18.46 159.75,18.03 159.75,17.85 161.94,15.66 162.12,15.66 162.39,15.93 162.57,15.93 162.7,15.8 162.7,15.62 162.43,15.35 162.43,15.17 162.55,15.05 162.79,15.05 163.11,15.37 163.31,15.37 163.98,14.7 163.98,12.31 163.89,12.21 163.89,11.84 164.79,10.94 166.04,10.94 166.8,11.71 174.79,11.71 v2(175.12,12.04)
PCH_SPI_CLK_0_R: length 12.2
  BOTTOM w0.109: RH724.2 134.38,37.58 135.45,37.58 136.38,38.51 136.58,38.51 136.93,38.86 136.93,39.29 136.85,39.38 136.85,40.43 137.33,40.91 138.27,40.91 138.75,41.38 v3(138.75,42.04) 138.75,42.3 138.39,42.65 137.69,42.65 RH29.1 137.01,42.9 136.79,43.12 136.79,43.54 136.6,43.73 UC5.6
PCH_SPI_CLK_1_R: length 14.3
  TOP w0.109: RH728.2 127.5,34.13 127.03,34.6 v1(125.35,34.6) 122.62,34.6 119.56,31.54 UC6.6 117.16,31.54 116.25,32.45 RH28.1
PCH_SPI_CLK_2_R: length 3
  TOP w0.109: UZ12.19 123.43,22.91 v1(123.5,22.98) 123.56,22.98 123.61,23.03 RZ63.2 RZ60.2
PCH_SPI_CLK_R1: length 102
  TOP w0.109: RH728.1 129.59,34.56 129.59,35.65 129.43,35.81 129.43,38.09 130.27,38.93 132.37,38.93 v2(133.27,39.83) ; v2(125.94,24.33) 125.55,23.94 RZ60.1
  IN2 w0.081: v2(173.26,58.49) 173.04,58.49 171.2,56.65 171.2,55.78 170.62,55.2 169.71,55.2 169.04,54.53 169.04,52.7 168.83,52.49 168.83,52.07 162,45.24 160.94,45.24 158.48,42.78 157.08,42.78 154.07,39.77 154.07,38.86 153.46,38.25 149.88,38.25 149.15,37.53 147.77,37.53 145.73,39.57 144.01,39.57 142.31,37.87 134.68,37.87 133.27,39.27 v2(133.27,39.83) 133.27,40.04 132.63,40.68 130.9,40.68 129.28,39.05 129.28,35.93 128.86,35.51 124.77,35.51 123.85,34.58 123.85,33.27 122.58,32 121.91,32 119.81,29.89 v2(119.81,28.69) 120.8,27.69 122.07,27.69 123.55,26.22 124.05,26.22 v2(125.94,24.33)
  BOTTOM w0.109: v2(173.26,58.49) 173.26,59.2 170.98,61.47 170.79,61.47 JSPI1.7 170.06,62.2 169.27,62.2 168.69,62.78 RH181.1 ; RH724.1 133.9,39.13 133.27,39.76 v2(133.27,39.83)
PCH_SPI_CS#0: length 89.6
  TOP w0.089: 177.53,19.49 177.53,19.9 177.45,19.98 177.45,19.99 177.4,20.03 177.4,20.48 UH1.AY47
  TOP w0.109: 177.53,19.49 177.53,19.21 177.34,19.03 177.34,18 176.95,17.61 176.95,17.26 177.18,17.04 177.45,17.04 177.54,16.94 177.54,15.17 176.95,14.57 176.95,14.2 175.28,12.53 175.03,12.53 172.79,10.29 166.63,10.29 166.01,10.91 166.01,11.52 164.63,12.9 164.63,14.01 163.07,15.56 v2(161.37,15.56)
  BOTTOM w0.109: RH182.2 168.34,61.22 168.92,61.22 JSPI1.10 169.91,60.23 170.1,60.23 171.86,58.47 171.86,57.26 172.89,56.24 172.89,55.75 172.47,55.33 172.29,55.33 171.68,55.94 171.5,55.94 171.37,55.81 171.37,55.63 171.98,55.02 171.98,54.84 170.8,53.65 169.76,53.65 169.29,53.18 169.29,50.17 165,45.88 v1(164.45,45.88) 164.2,45.88 162.88,44.55 162.88,43.4 160.94,41.47 160.94,39.56 157.41,36.04 157.41,33.51 157.14,33.24 157.14,31.48 156.82,31.16 156.82,30.22 156.51,29.91 156.51,26.89 158.49,24.91 158.49,23.55 158.15,23.2 158.15,20.95 157.91,20.71 157.91,20.36 157.41,19.85 157.41,19.36 158.73,18.04 159.23,18.04 161.37,15.89 v2(161.37,15.56)
PCH_SPI_CS#0_R1: length 80.7
  TOP w0.109: v2(127.67,30.26) 127.47,30.06 RH352.1
  IN2 w0.081: v2(127.67,30.26) 127.42,30.01 125.94,30.01 125.11,30.83 125.11,33.81 125.46,34.16 126.44,34.16 126.75,33.85 v2(126.75,33.66) 127.35,33.66 127.68,33.99 129.3,33.99 130.85,35.55 130.85,36.71 130.94,36.79 131.42,36.79 131.54,36.91 131.54,37.06 131.66,37.18 131.83,37.18 131.95,37.06 131.95,36.91 132.07,36.79 132.24,36.79 132.36,36.91 132.36,37.11 132.47,37.22 132.64,37.22 132.76,37.1 132.76,36.91 132.88,36.79 137.37,36.79 137.69,37.12 144.8,37.12 145.08,36.84 150.52,36.84 150.62,36.93 150.62,37.31 150.74,37.43 150.91,37.43 151.03,37.31 151.03,36.93 151.14,36.81 152.24,36.81 152.36,36.93 152.36,37.17 152.48,37.29 152.65,37.29 152.76,37.17 152.76,36.93 152.88,36.81 153.12,36.81 155.76,39.46 156.21,39.46 157.43,40.68 157.43,41.75 157.64,41.96 158.74,41.96 161.25,44.47 162.2,44.47 169.52,51.78 169.52,52.2 169.79,52.47 169.79,53.15 172.02,55.38 172.02,56.05 172.72,56.75 v2(173.1,56.75)
  BOTTOM w0.109: RH182.1 167.46,62.17 167.92,62.17 168.58,61.51 169.33,61.51 170.07,60.78 170.26,60.78 172.26,58.78 172.26,57.58 v2(173.1,56.75) ; RH37.1 127.45,34.37 v3(127.24,34.16) v2(126.75,33.66)
PCH_SPI_CS#0_R2: length 5.2
  BOTTOM w0.109: RH37.2 v3(127.45,37.41) 127.45,37.46 127.48,37.49 127.48,40.74 UC5.1
PCH_SPI_CS#0_R3: length 5.6
  TOP w0.109: RH352.2 126.66,29.6 126.66,29.78 126.54,29.9 126.54,30.08 126.67,30.21 126.85,30.21 126.97,30.09 127.15,30.09 127.26,30.2 127.26,30.45 v1(127.19,30.51) 127.19,30.57 127.06,30.71 126.7,30.71 126.54,30.87 126.36,30.87 126.16,30.67 126.16,29.93 125.91,29.67 125.6,29.67 125.47,29.55 125.47,29.12 125.34,29 UC6.1
PCH_SPI_CS#1: length 89.1
  TOP w0.109: UH1.AW48 177.94,20.18 177.94,18.95 177.8,18.81 177.8,17.91 177.94,17.77 177.94,14.53 178.02,14.44 178.02,14.09 173.97,10.04 166.55,10.04 165.77,10.81 165.77,11.42 165.18,12.01 v2(164.3,12.01)
  BOTTOM w0.109: RH177.2 171.4,64.39 172.44,63.35 173.19,63.35 176.19,60.36 176.19,54.33 171.8,49.94 170.96,49.94 165.55,44.53 165.55,42.42 165.23,42.1 164.61,42.1 162.51,39.99 162.51,36.85 161.54,35.88 160.64,35.88 158.88,34.12 158.88,32.94 158.55,32.6 158.55,26.07 159.34,25.28 v1(159.34,24.38) 159.34,23.59 159.6,23.32 159.6,20.9 160.51,19.99 160.51,19.03 160.7,18.84 160.7,18.32 164.3,14.72 v2(164.3,12.01)
PCH_SPI_CS#1_R1: length 1.3
  BOTTOM w0.109: RH177.1 171.9,65.01 171.9,64.61 JSPI1.1
PCH_SPI_CS#2: length 180.2
  TOP w0.089: UH1.AT40 v2(178.63,24.22)
  TOP w0.109: v2(125.99,24.93) 125.37,24.93 RZ61.1
  IN1 w0.102: v2(178.63,24.22) 177.46,24.22 177.07,24.61 176.85,24.61 176.72,24.74 176.72,25.19 176.81,25.28 177.33,25.28 177.42,25.37 177.42,25.58 177.35,25.66 176.88,25.66 176.67,25.86 176.37,25.86 176.25,25.74 176.25,24.15 176.16,24.06 175.95,24.06 175.87,24.13 175.87,24.41 175.78,24.5 175.57,24.5 175.48,24.41 175.48,24.13 175.41,24.07 175.2,24.07 175.07,24.2 175.07,26.03 174.95,26.15 174.77,26.15 174.65,26.03 174.65,23.57 174.53,23.45 174.36,23.45 174.24,23.57 174.24,26.03 174.13,26.15 173.96,26.15 173.84,26.03 173.84,23.53 173.72,23.41 173.55,23.41 173.43,23.53 173.43,26.03 173.31,26.15 173.14,26.15 173.03,26.03 173.03,24.18 172.91,24.06 172.72,24.06 172.6,24.18 172.6,25.92 172.45,26.06 171.57,26.06 171.39,26.24 171.39,28.14 171.62,28.36 173.29,28.36 173.41,28.48 173.41,28.67 173.32,28.75 171.52,28.75 171.4,28.87 171.4,29.1 171.52,29.21 173.33,29.21 173.43,29.32 173.43,29.58 173.32,29.7 171.67,29.7 171.58,29.79 171.58,30.09 171.71,30.22 172.34,30.22 172.43,30.31 172.43,30.58 172.3,30.71 171.16,30.71 170.99,30.55 170.99,30.38 170.87,30.26 168.49,30.26 168.39,30.15 168.39,29.94 168.49,29.84 170.89,29.84 170.99,29.74 170.99,29.47 170.87,29.34 168.52,29.34 168.39,29.21 168.39,29 168.52,28.87 170.88,28.87 170.99,28.76 170.99,28.46 170.89,28.36 168.81,28.36 168.72,28.27 168.72,27.98 168.82,27.88 170.85,27.88 170.99,27.74 170.99,25.82 170.87,25.7 170.57,25.7 170.46,25.82 170.46,26.51 170.34,26.62 170.16,26.62 170.05,26.51 170.05,26.12 169.93,26 169.76,26 169.64,26.12 169.64,26.5 169.54,26.6 169.33,26.6 169.24,26.5 169.24,26.12 169.12,26 168.8,26 168.68,26.12 168.68,26.53 168.56,26.65 168.34,26.65 168.23,26.53 168.23,25.96 168.06,25.8 165.54,25.8 165.03,26.32 164,26.32 161.95,26.32 161.16,27.11 160.76,27.11 160.01,26.36 159.48,26.36 159.41,26.42 159.24,26.42 159.02,26.2 158.85,26.2 158.73,26.32 158.73,26.49 158.96,26.71 158.96,27.02 159.15,27.21 159.15,28.65 159.03,28.77 158.83,28.77 158.73,28.67 158.73,28.23 158.61,28.11 157.98,28.11 157.86,27.99 157.86,27.82 157.98,27.7 158.61,27.7 158.73,27.58 158.73,27.35 158.64,27.26 157.74,27.26 157.61,27.13 157.61,26.42 157.45,26.26 157.2,26.26 157.08,26.38 157.08,27.3 156.96,27.42 156.79,27.42 156.67,27.3 156.67,26.47 156.55,26.34 156.37,26.34 156.22,26.48 156.22,27.3 156.11,27.41 155.91,27.41 155.78,27.28 155.78,26.86 155.65,26.74 155.12,26.74 154.43,26.04 151.55,26.04 151.25,26.34 151.08,26.34 150.78,26.04 150.62,26.04 150.47,26.19 150.47,26.36 150.79,26.68 150.79,26.85 150.67,26.97 150.5,26.97 150.18,26.65 150.01,26.65 149.89,26.77 149.89,27.32 149.79,27.43 149.57,27.43 149.46,27.31 149.46,26.97 149.34,26.85 149,26.85 148.22,26.07 146.98,26.07 146.25,25.34 146.07,25.34 145.82,25.08 145.65,25.08 145.45,25.28 145.28,25.28 145.16,25.16 145.16,25 145.36,24.8 145.36,24.63 145.24,24.51 145.07,24.51 144.87,24.71 144.7,24.71 144.59,24.59 144.59,24.42 144.78,24.22 144.78,24.05 144.4,23.67 143.27,23.67 143.13,23.8 143.13,24.5 143.03,24.6 142.79,24.6 142.69,24.5 142.69,23.8 142.55,23.67 142.38,23.67 142.23,23.81 142.23,24.49 142.11,24.61 139.48,24.61 138.97,24.1 136.79,24.1 136.46,24.43 134.04,24.43 133.76,24.14 131.2,24.14 v2(131.07,24.01)
  BOTTOM w0.109: v2(131.07,24.01) 131.29,23.8 132.57,23.8 132.73,23.95 132.73,24.28 132.53,24.47 130.64,24.47 130.5,24.33 130.5,23.29 130.4,23.19 130.16,23.19 130.04,23.31 130.04,24.27 129.92,24.39 129.56,24.39 128.9,23.74 128.1,23.74 127.98,23.86 v1(127.07,23.86) 125.18,23.86 124.06,22.74 124.06,22.58 124.22,22.42 124.48,22.42 125.47,23.42 127.76,23.42 127.89,23.29 127.89,23.11 127.77,22.99 125.57,22.99 124.39,21.81 122.94,21.81 122.77,21.98 122.77,22.29 124.4,23.92 124.4,24.1 124.5,24.2 125.34,24.2 125.43,24.29 125.43,24.54 125.36,24.62 124.54,24.62 124.4,24.75 124.4,24.96 124.5,25.06 124.94,25.06 125.05,25.17 125.05,25.37 124.92,25.5 123.86,25.5 123.26,26.1 123.26,26.34 123.43,26.51 123.61,26.51 124.19,25.94 124.88,25.94 125.01,26.06 125.01,26.31 124.87,26.45 124.56,26.45 124.41,26.6 124.41,26.86 124.56,27.01 125.12,27.01 125.21,27.11 125.21,27.39 125.08,27.52 124.59,27.52 124.45,27.66 124.45,27.89 124.58,28.02 125.07,28.02 125.2,28.15 125.2,28.33 125.07,28.46 124.27,28.46 124.17,28.55 124.17,28.81 124.26,28.89 125.07,28.89 125.2,29.02 125.2,29.2 125.07,29.33 123.93,29.33 123.83,29.43 123.83,29.64 123.96,29.77 125.08,29.77 125.19,29.88 125.19,30.08 125.07,30.2 124.44,30.2 124.32,30.31 124.32,31.07 124.42,31.18 124.57,31.18 125.64,30.1 125.64,26.63 125.37,26.36 125.37,25.54 v2(125.99,24.93)
