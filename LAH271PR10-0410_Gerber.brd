# Allegro board LAH271PR10-0410_Gerber.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+2.8V_FHV0 on BOTTOM (solid shape): 184.94,28.76 184.94,28.54 185.17,28.31 185.17,20.47 185.36,20.29 185.36,19.75 185.32,19.71 184.7,19.71 184.69,19.73 184.69,20.32 184.72,20.34 184.72,28.09 184.23,28.57 184.23,28.86 184.26,28.89 184.33,28.97 184.74,28.97
+2.8V_FHV1 on BOTTOM (solid shape): 184.08,28.84 184.08,28.44 184.59,27.93 184.59,20.4 184.56,20.37 184.56,19.76 184.51,19.71 183.79,19.71 183.76,19.74 183.76,20.55 184.08,20.87 184.08,21.07 184.14,21.26 184.1,21.42 184.08,21.45 184.08,23.3 184.18,23.55 184.08,23.8 184.08,24.83 184.14,24.89 184.14,27.31 184.14,27.36 184.14,27.49 184.05,27.58 184,27.62 183.47,28.16 183.47,28.83 183.61,28.97 183.95,28.97
+3.3V_1.8V_AZIO on BOTTOM (solid shape): 171.47,34.51 171.89,34.51 172,34.39 172,34.36 171.99,34.28 172,34.19 172,33.8 171.96,33.8 171.96,33.17 171.45,33.17 171.37,33.25 171.37,33.57 170.74,34.2 170.72,34.2 170.61,34.31 169.84,34.31 169.84,34.84 169.89,34.89 171.09,34.89
+3.3V_1.8V_AZIO on IN3: 171.56,34.02 171.15,34.43 171.15,35.19 170.24,36.09 169.58,36.09 169.52,36.15 169.5,36.25 169.58,36.32 169.78,36.93 169.18,36.72 169.11,36.64 169.01,36.67 168.41,37.26 168.41,37.8 168.83,38.22 170.6,38.22 172.34,36.48 172.34,34.34 172.02,34.02
+3.3V_1.8V_GPPA on BOTTOM (solid shape): outline of 218 points within 171.91,24.96 180.96,28.56
+3.3V_ALW on TOP (solid shape): 196.47,11.12 196.47,10.36 196.19,10.07 193.89,10.07 193.77,10.19 193.77,10.71 193.92,10.86 194.72,10.86 195.16,11.3 196.29,11.3
+3.3V_ALW on TOP (solid shape): 120,10.21 120,8.79 119.53,8.79 119.36,8.97 118.43,8.97 118.34,9.06 118.34,9.8 118.51,9.96 119.26,9.96 119.56,10.27 119.94,10.27
+3.3V_ALW on TOP (solid shape): 35.72,47.28 35.72,46.53 35.77,46.49 35.77,45.71 35.6,45.71 35.38,45.93 34.72,45.93 34.47,46.18 34.47,47.11 34.72,47.36 35.64,47.36
+3.3V_ALW on TOP (solid shape): 100.94,23.09 100.94,21.32 100.84,21.21 100.84,21.21 99.96,20.33 98.43,20.33 98.27,20.49 98.27,20.83 98.68,21.24 98.68,23.17 98.98,23.46 100.57,23.46
+3.3V_ALW on TOP (solid shape): 109.93,25.22 109.93,24.25 109.73,24.06 109.73,23.69 109.56,23.52 107.48,23.52 107.24,23.76 107.24,24.26 107.91,24.93 108.83,24.93 109.18,25.28 109.86,25.28
+3.3V_ALW on TOP (solid shape): 123.75,4.69 123.75,3.59 123.22,3.59 123.22,3.15 123.75,3.15 123.75,2.86 123.55,2.66 121.01,2.66 120.86,2.81 120.86,4.61 121.05,4.81 123.64,4.81
+3.3V_ALW on TOP (solid shape): 88.6,26.08 88.6,25.49 88.62,25.48 88.62,25.4 89.63,25.4 90,25.04 90,24.79 89.39,24.19 88.34,24.19 87.9,24.62 87.9,24.62 87.31,25.21 87.31,25.95 87.51,26.15 88.53,26.15
+3.3V_ALW on TOP (solid shape): 135.66,36.79 135.66,36.29 135.76,36.19 135.76,36.16 135.79,36.16 135.8,36.15 136.1,36.15 136.17,36.07 136.17,35.69 135.98,35.5 135.31,35.5 134.91,35.89 134.91,36.81 135.02,36.91 135.54,36.91
+3.3V_ALW on TOP (solid shape): 90.68,28.65 90.68,28.4 90.56,28.28 88.69,28.28 88.6,28.19 88.6,27.57 88.54,27.51 87.86,27.51 87.34,28.03 86.69,28.03 86.61,28.12 86.61,28.72 86.7,28.82 87.63,28.82 88.15,29.34 89.99,29.34
+3.3V_ALW on TOP (solid shape): 129.73,13.74 130.49,13.74 130.49,13.75 130.66,13.75 131.06,13.35 131.06,12.74 130.81,12.49 129.26,12.49 129.02,12.73 129.02,13.15 128.74,13.43 128.74,13.61 128.87,13.74 129.58,13.74 129.58,13.75 129.73,13.75
+3.3V_ALW on TOP (solid shape): 146.52,21.49 146.52,18.77 146.31,18.57 142.51,18.57 142.45,18.62 142.45,19.16 142.56,19.28 143.55,19.28 144.19,19.91 144.19,20.37 144.2,20.37 144.73,20.37 144.75,20.39 144.75,20.83 144.72,20.85 144.2,20.85 144.19,20.86 144.19,21.24 144.14,21.29 142.51,21.29 142.39,21.41 142.39,21.88 142.55,22.04 145.97,22.04
+3.3V_ALW on TOP (solid shape): 115.07,29.67 115.07,28.91 114.88,28.72 114.22,28.72 114.21,28.72 114.02,28.72 113.99,28.69 113.99,28.62 113.99,28.62 113.99,28.45 113.99,28.45 113.99,28.19 113.97,28.17 113.81,28.17 113.79,28.19 113.79,28.72 113.78,28.72 113.74,28.72 113.68,28.72 113.67,28.73 113.41,28.73 113.4,28.72 113.18,28.72 113.18,28.72 112.31,28.72 112.19,28.84 112.19,29.62 112.54,29.97 114.77,29.97
+3.3V_ALW on TOP (solid shape): 100.04,10.03 100.04,8.92 100.06,8.9 100.06,8.57 100.06,8.56 100.06,7.56 99.18,6.68 98.09,6.68 98.08,6.69 98.08,7.2 98.05,7.22 97.35,7.22 97.34,7.21 97.34,6.7 97.31,6.67 96.89,6.67 96.87,6.69 96.87,7.21 96.86,7.22 96.16,7.22 96.14,7.2 96.14,6.7 96.11,6.67 95.47,6.67 95.3,6.84 95.3,7.36 95.31,7.36 95.31,8.26 95.51,8.47 96.41,8.47 96.58,8.64 98.3,8.64 98.41,8.75 98.41,10.27 98.7,10.55 99.52,10.55
+3.3V_ALW on BOTTOM (solid shape): 64.35,5.51 64.35,4.4 64.22,4.12 64.35,3.85 64.35,3.22 64.3,3.16 64.3,2.78 64.31,2.76 64.33,2.71 64.35,2.66 64.35,1.68 64.2,1.53 62.88,1.53 62.78,1.63 62.78,3.26 62.83,3.31 62.91,3.32 62.97,3.34 63.04,3.34 63.17,3.48 63.21,3.52 63.21,4.53 63.07,4.67 63.07,6.04 63.16,6.13 63.74,6.13
+3.3V_ALW on BOTTOM (solid shape): 90.86,28.73 90.86,27.12 90.84,27.1 90.8,27.07 90.77,27.02 90.74,26.98 90.72,26.93 90.71,26.88 90.7,26.82 90.71,26.77 90.72,26.72 90.74,26.67 90.77,26.62 90.8,26.58 90.84,26.54 90.86,26.53 90.86,24.2 90.56,23.9 89.26,23.9 88.09,25.07 88.09,26.02 87.84,26.26 87.84,26.82 88.88,26.82 88.89,26.77 88.9,26.72 88.92,26.67 88.94,26.62 88.98,26.58 89.02,26.54 89.06,26.51 89.11,26.49 89.16,26.48 89.21,26.47 89.26,26.47 89.32,26.48 89.37,26.49 89.42,26.51 89.46,26.54 89.5,26.58 89.53,26.62 89.56,26.67 89.58,26.72 89.59,26.77 89.59,26.82 89.59,26.88 89.58,26.93 89.56,26.98 89.53,27.02 89.5,27.07 89.46,27.1 89.42,27.13 89.37,27.16 89.32,27.17 89.26,27.18 89.21,27.18 89.16,27.17 89.11,27.16 89.06,27.13 89.02,27.1 88.98,27.07 88.94,27.02 88.92,26.98 88.9,26.93 88.89,26.88 88.88,26.82 87.84,26.82 87.84,29.05 88.12,29.32 90.27,29.32
+3.3V_ALW on BOTTOM (solid shape): 138.8,17.27 138.9,17.22 138.92,17.11 139.1,16.72 139.52,16.78 139.6,16.81 139.69,16.79 139.98,16.76 140.13,17.02 140.13,17.08 140.11,17.14 140.15,17.23 140.24,17.27 142.35,17.27 142.58,17.04 142.58,16.11 142.69,16 142.69,15.44 142.42,15.17 139.71,15.17 139.61,15.22 139.58,15.32 139.28,15.74 138.88,15.41 138.79,15.3 138.66,15.33 138.06,15.94 138.06,17.12 138.21,17.27
+3.3V_ALW on BOTTOM (solid shape): outline of 227 points within 98.55,19.04 111.57,24.54
+3.3V_ALW on IN2 (solid shape): outline of 177 points within 180.65,4.18 197.23,11.39
+3.3V_ALW on IN2 (solid shape): outline of 394 points within 92.64,1.42 124.78,10.58
+3.3V_ALW on IN3 (solid shape): outline of 483 points within 275.68,79.37 281.39,89.27
+3.3V_ALW on IN4 (solid shape): outline of 333 points within 127.65,11.78 146.15,16.58
+3.3V_ALW on IN4 (solid shape): outline of 453 points within 115.61,2.76 124.13,16.9
+3.3V_ALW on IN4 (solid shape): outline of 997 points within 88.01,6.62 103.58,25.51
+3.3V_ALW on VCC: 198.57,9.5 197.3,10.77 166.82,10.77 164.43,13.17 164.43,13.52 164.3,13.64 164.3,13.75 163.29,14.77 162.33,14.77 162.13,14.96 162.06,14.96 161.94,15.09 159.12,15.09 157.21,13.19 146.8,13.19 146.42,12.81 144.49,12.81 144.49,13.49 146.73,15.73 156.91,15.73 158.15,16.96 162.42,16.96 162.82,16.56 162.82,16.09 164.19,14.71 165.05,14.71 165.18,14.58 168.51,14.58 169.91,13.19 197.98,13.19 199.5,11.66 215.89,11.66 216.24,11.3 216.24,9.5
+3.3V_ALW on IN3: outline of 248 points within 88.32,10.08 154.38,37.38
+3.3V_ALW_PCH on TOP (solid shape): 154.72,23.96 154.72,20.39 154.57,20.24 154.08,20.24 153.96,20.37 153.96,23.98 154.08,24.11 154.57,24.11
+3.3V_ALW_PCH on TOP (solid shape): 131.27,10.78 131.27,10.52 131.31,10.48 131.32,10.47 131.38,10.4 131.45,10.34 131.47,10.32 131.57,10.29 131.57,9.75 131.55,9.72 131.06,9.72 130.8,9.98 130.17,9.98 130.1,10.05 130.1,10.53 130.12,10.55 130.72,10.55 130.79,10.62 130.79,10.79 130.89,10.89 131.17,10.89
+3.3V_ALW_PCH on BOTTOM (solid shape): 191.78,16.35 192.07,16.35 192.37,16.04 193,16.04 193.13,15.92 193.13,15.35 192.93,15.14 189.3,15.14 188.98,14.82 188.6,14.82 188.49,14.93 188.49,15.98 188.85,16.35 191.78,16.35
+3.3V_ALW_PCH on BOTTOM (solid shape): 110.41,28.15 110.76,28.15 111.19,27.72 111.19,27.64 111.18,27.55 111.19,27.47 111.19,26.13 110.86,25.8 109.3,25.8 109.17,25.93 109.17,26.55 109.15,26.58 109.11,26.58 108.63,26.58 108.62,26.59 108.62,26.83 109.16,26.83 109.17,26.84 109.17,27.38 109.16,27.39 109.06,27.39 109.06,27.38 108.63,27.38 108.61,27.4 108.61,27.63 108.62,27.64 109.15,27.64 109.16,27.65 109.16,28.13 109.19,28.16 110.4,28.16
+3.3V_ALW_PCH on BOTTOM (solid shape): 168.49,33.94 168.49,33.38 168.66,33.21 169.13,33.21 169.18,33.15 169.18,32.69 169.37,32.5 169.45,32.5 169.45,32.49 170.04,32.49 170.45,32.08 170.46,32.07 170.49,32.03 171.05,32.03 171.1,31.98 171.1,30.66 171.04,30.6 170.49,30.6 170.32,30.77 170.32,31.44 169.99,31.77 169.68,31.77 169.41,31.5 169.41,31.12 169.3,31 168.83,31 168.69,31.15 168.69,31.7 168.42,31.97 168.42,32.44 168.25,32.6 167.8,32.6 167.71,32.69 167.71,34.02 167.81,34.12 168.31,34.12
+3.3V_ALW_PCH on BOTTOM (solid shape): 172,26.61 172,25.68 171.87,25.55 171.72,25.55 171.53,25.6 171.34,25.55 171.05,25.55 170.66,25.55 170.5,25.2 170.51,25.17 170.33,24.99 169.05,24.99 168.83,25.22 168.83,25.91 168.9,25.99 169.6,25.99 170.28,26.66 171.94,26.66
+3.3V_ALW_PCH on BOTTOM (solid shape): 165.84,36.34 165.84,35.76 165.81,35.67 165.72,35.63 165.36,35.63 165.19,35.31 165.23,35.15 165.35,35.02 165.4,34.92 165.36,34.82 165.24,34.7 165.24,33.6 164.83,33.18 164.69,33.18 164.14,33.02 164.47,32.54 164.55,32.5 164.59,32.41 164.59,31.52 164.42,31.35 163.47,31.35 163.27,31.55 163.27,34.48 163.51,34.72 163.67,34.81 163.77,34.97 163.85,35.06 163.85,35.62 164.24,36.01 164.24,36.46 164.51,36.73 165.46,36.73
+3.3V_ALW_PCH on VCC: outline of 82 points within 66.89,18.37 173.69,33.65
+3.3V_ALW_PCH_PWR on BOTTOM (solid shape): 109.03,28.13 109.03,27.78 109.02,27.77 108.9,27.77 108.89,27.77 108.5,27.77 108.49,27.76 108.49,27.68 108.48,27.68 108.48,27.35 108.49,27.35 108.49,27.27 108.52,27.24 109.01,27.24 109.02,27.23 109.02,27.01 109,26.99 108.49,26.99 108.48,26.97 108.48,26.45 108.49,26.44 109.01,26.44 109.02,26.43 109.02,25.94 108.74,25.65 106.05,25.65 105.99,25.71 105.99,26.69 106.27,26.97 106.27,27.58 106.41,27.72 107.08,27.72 107.55,28.19 108.97,28.19
+3.3V_ALW_PCHRES on BOTTOM (solid shape): 168.18,41.94 170.37,41.94 171.04,41.27 171.04,41.12 170.53,40.61 170.14,40.61 169.82,40.93 168.98,40.93 168.66,41.24 166.85,41.24 166.72,41.37 166.72,42.05 166.81,42.14 167.98,42.14
+3.3V_ALW_PCHRES on BOTTOM (solid shape): 173.76,34.36 173.76,33.26 173.67,33.17 172.35,33.17 172.32,33.2 172.32,33.92 172.67,34.11 172.62,34.51 173.61,34.51
+3.3V_ALW_PCHRES on BOTTOM (solid shape): 172.51,29.12 173.26,29.12 173.46,28.92 173.46,27.34 173.36,27.25 173.21,27.25 173.14,27.18 173.08,27.15 173.03,27.11 172.99,27.07 172.99,27.03 172.96,27 172.96,26.86 172.96,26.76 172.8,26.6 172.29,26.6 172.09,26.8 172.09,26.89 171.99,26.99 171.99,28.24 171.97,28.24 171.97,28.29 170.24,28.29 170.2,28.33 170.2,29.35 170.31,29.46 172.17,29.46
+3.3V_ALW_PCHRES on IN1 (solid shape): outline of 3943 points within 171.82,18.29 188.11,35.94
+3.3V_ALW_PCHRES on IN2 (solid shape): 174.89,34.02 174.89,31.68 174.82,31.48 174.89,31.27 174.89,27.06 174.42,26.59 173.67,26.59 173.64,26.59 173.61,26.6 173.56,26.64 173.59,26.69 173.28,27.22 172.96,26.7 172.97,26.68 172.97,26.6 172.9,26.6 172.88,26.59 172.85,26.59 170.38,26.59 170.27,26.64 170.27,26.77 170.36,26.89 170.4,27.05 170.26,27.34 169.94,27.4 169.83,27.42 169.77,27.52 169.77,27.81 169.78,27.81 169.78,30.83 170.26,31.31 170.26,32.81 170.49,33.04 170.53,33.01 170.91,32.98 171.1,33.31 171.09,33.41 171.05,33.5 171.03,33.54 171.5,34.01 171.54,33.98 171.65,33.93 171.76,33.92 171.89,33.94 172.01,34.01 172.05,34.03 172.09,34.01 172.21,33.94 172.34,33.92 172.65,34.08 172.67,34.43 172.71,34.51 172.79,34.54 174.38,34.54
+3.3V_ALW_PCHRES on IN2 (solid shape): outline of 3341 points within 179.35,14.85 193.63,35.37
+3.3V_ALW_PCHRES on IN3: 172.78,33.91 172.47,34.23 172.47,36.54 170.54,38.47 170.09,38.47 170.01,38.51 170,38.6 169.94,38.89 169.68,39.04 169.61,39.08 169.59,39.15 169.59,39.21 169.6,39.28 169.66,39.32 169.88,39.85 169.31,39.9 169.2,39.88 169.14,39.97 169.14,41.3 169.3,41.46 170.54,41.46 171.37,40.63 171.37,40.21 171.39,40.1 171.29,40.04 171.17,40.04 170.51,39.86 171.17,39.68 171.68,39.68 171.79,39.79 172.01,39.57 171.98,39.53 172.03,39.08 172.48,39.04 172.51,39.06 172.73,38.84 172.73,38.79 172.75,38.78 172.74,38.76 172.85,38.42 173.19,38.35 173.22,38.36 174.38,37.2 174.38,34.31 174,33.94 173.41,33.94 173.38,33.91
+3.3V_ALW_R on TOP (solid shape): 206.73,125.97 207.13,125.97 207.52,125.58 207.52,125.11 207.41,124.99 205.72,124.99 205.55,125.16 205.55,125.98 205.63,126.06 206.64,126.06
+3.3V_ALW_R on TOP (solid shape): 344.06,42.63 344.06,40.64 343.5,40.08 340.95,40.08 340.71,40.31 340.71,41.98 340.64,42.06 340.64,42.72 340.7,42.78 343.91,42.78
+3.3V_ALW_R on TOP (solid shape): 325.3,22.88 325.3,22.03 325.22,21.95 325.22,21.93 324.59,21.29 323.99,21.29 323.51,21.77 323.51,22.2 323.62,22.31 323.94,22.31 324.6,22.96 325.22,22.96
+3.3V_ALW_R on TOP (solid shape): 296.97,30.54 296.97,30.02 296.43,30.02 296.43,29.26 296.97,29.26 296.97,28.82 296.42,28.82 296.42,28.07 296.97,28.07 296.97,26.3 296.81,26.14 294.87,26.14 294.71,26.31 294.71,30.4 294.92,30.61 296.91,30.61
+3.3V_ALW_R on TOP (solid shape): 328,22.7 328,22.02 328.01,22.01 328.01,21.67 328.02,21.66 328.02,21.29 327.96,21.24 327.1,21.24 326.91,21.43 326.91,21.7 326.68,21.93 326.68,22.88 326.76,22.96 327.41,22.96 327.41,22.97 327.74,22.97
+3.3V_ALW_R on TOP (solid shape): 287.25,42.72 287.25,42.22 287.27,42.21 287.85,42.21 287.97,42.09 287.97,41.17 287.87,41.07 284.17,41.07 283.91,41.33 283.91,42.4 283.99,42.48 284.89,42.48 285.16,42.22 286.18,42.22 286.2,42.23 286.2,42.76 286.2,42.76 286.44,42.76 286.44,42.75 286.44,42.22 286.46,42.21 287,42.21 287,42.22 287,42.75 287.01,42.76 287.25,42.76
+3.3V_ALW_R on TOP (solid shape): 320.2,12.73 320.2,12.5 320.24,12.45 320.25,12.43 320.31,12.29 320.42,12.19 320.42,11.09 319.99,10.66 319,10.66 318.99,10.69 318.96,10.73 318.92,10.76 318.92,10.97 319.09,11.33 318.81,11.63 318.76,11.64 318.76,11.91 318.89,12.04 319.25,12.04 319.25,12.06 319.38,12.19 319.38,12.75 319.45,12.82 320.11,12.82
+3.3V_ALW_R on BOTTOM (solid shape): 181.88,90.8 181.88,89.32 181.9,89.29 182.21,88.98 182.21,88.27 182.17,88.23 181.46,88.23 181.21,88.47 180.96,88.47 180.42,89.02 179.65,89.02 179.38,89.29 179.38,90.77 180.59,90.77 180.59,90.71 180.6,90.66 180.62,90.61 180.65,90.56 180.68,90.52 180.72,90.49 180.77,90.46 180.81,90.43 180.86,90.42 180.92,90.41 180.97,90.41 181.02,90.42 181.07,90.43 181.12,90.46 181.17,90.49 181.21,90.52 181.24,90.56 181.27,90.61 181.28,90.66 181.3,90.71 181.3,90.77 181.3,90.82 181.28,90.87 181.27,90.92 181.24,90.97 181.21,91.01 181.17,91.04 181.12,91.07 181.07,91.1 181.02,91.11 180.97,91.12 180.92,91.12 180.86,91.11 180.81,91.1 180.77,91.07 180.72,91.04 180.68,91.01 180.65,90.97 180.62,90.92 180.6,90.87 180.59,90.82 180.59,90.77 179.38,90.77 179.38,91.63 179.64,91.9 180.78,91.9
+3.3V_ALW_R on BOTTOM (solid shape): outline of 851 points within 319.57,21.19 330.98,34.54
+3.3V_ALW_R on IN3 (solid shape): outline of 1112 points within 198.24,39.01 288.27,85.96
+3.3V_ALW_R on IN3 (solid shape): outline of 1173 points within 325.61,20.59 333.15,34.9
+3.3V_ALW_R on VCC: 327.37,23.36 326.36,22.35 326.36,19.54 319.14,12.33 318.27,12.33 317.68,11.74 317.68,10.63 318.71,9.6 318.71,9.19 318.97,8.93 327.04,8.93 331.07,12.95 331.07,22.56 331.06,22.56 331.06,27.84 328.63,30.28 325.69,30.28 325.59,30.18 325.59,26.62 327.37,24.85
+3.3V_ALW_R on VCC: 217.79,108.56 219.42,106.93 219.42,95.79 219.24,95.67 219.17,95.47 217.12,93.41 217.12,92.31 215.15,90.34 212.2,90.34 211.29,89.44 211.29,87.59 203.74,80.03 202,81.77 188.41,81.77 184.6,85.58 182.72,85.58 182.72,87.71 181.68,88.75 180.66,88.75 180.28,89.13 179.77,89.13 179.54,89.37 179.54,91.57 180.16,92.18 192.6,92.18 205.58,105.16 205.58,125.22 206.83,126.47 211.44,126.47 211.82,126.09 210.78,125.05 210.78,111.76 213.98,108.56
+3.3V_ALW_R on IN4: outline of 141 points within 279.62,22.44 344.66,43.02
+3.3V_ALW_RP on TOP (solid shape): 302.32,32.15 302.32,25.16 302.08,24.92 299,24.92 298.87,25.05 298.87,26.11 298.44,26.54 297.31,26.54 297.13,26.72 297.13,28.22 296.58,28.22 296.58,28.67 297.13,28.67 297.13,29.42 296.58,29.42 296.58,29.87 297.13,29.87 297.13,30.73 296.93,30.93 293.91,30.93 293.78,31.06 293.78,32.5 293.92,32.64 301.83,32.64
+3.3V_ALW_UE1 on TOP (solid shape): 144.05,21.14 144.05,20.73 144.06,20.71 144.6,20.71 144.61,20.7 144.61,20.52 144.59,20.51 144.09,20.51 144.08,20.5 144.07,20.5 144.07,20.48 144.07,19.99 143.57,19.49 142.49,19.49 142.45,19.54 142.45,20.85 142.74,21.15 144.03,21.15
+3.3V_ALW_UE1 on IN3 (solid shape): outline of 186 points within 134.7,24.56 136.56,28.32
+3.3V_ALW_UE1 on VCC: 136.85,19.47 136.6,19.72 136.51,19.72 136.51,20.34 136.46,20.39 136.46,20.57 135.8,21.22 132.89,21.22 131.71,20.04 128.01,20.04 128.01,22.21 126.11,24.11 126.11,26.83 126.33,27.05 126.87,27.05 128.79,25.13 140.73,25.13 143.71,22.14 143.71,20.92 143.84,20.79 143.84,20.54 143.61,20.31 142.77,20.31 142.64,20.44 142.24,20.44 142.06,20.62 140.15,20.62 139,19.47
+3.3V_ALW_UZ12 on TOP (solid shape): 113.65,28.57 113.65,28.05 113.66,28.03 114.1,28.03 114.12,28.04 114.12,28.5 114.11,28.5 114.11,28.56 114.13,28.58 114.43,28.58 114.44,28.58 117.18,28.58 117.23,28.56 117.29,28.55 117.77,28.07 117.77,25.33 117.72,25.28 116.92,25.28 116.83,25.36 116.83,25.69 117.02,25.87 117.02,26.4 116.78,26.63 114.53,26.63 114.24,26.34 113.54,26.34 113.41,26.48 113.41,28.55 113.47,28.6 113.62,28.6
+3.3V_ALWP on TOP (solid shape): 104.36,8.04 104.36,5.41 103.59,4.65 101.61,4.65 101.16,4.19 101.16,3.56 100.96,3.36 93.8,3.36 93.5,3.67 93.5,5.25 93.53,5.27 93.75,5.51 93.67,5.84 93.64,5.87 94.31,6.54 95.42,6.54 95.42,6.54 96.16,6.54 96.17,6.54 96.26,6.54 96.27,6.56 96.27,7.07 96.27,7.08 96.72,7.08 96.73,7.07 96.73,6.56 96.74,6.54 97.44,6.54 97.47,6.57 97.47,7.08 97.92,7.08 97.93,7.07 97.93,6.55 97.94,6.54 99.29,6.54 100.24,7.49 100.24,8.85 100.51,9.12 103.28,9.12
+3.3V_DGFF on TOP (solid shape): 181.85,93.32 181.93,93.32 182.01,93.31 182.08,93.31 182.1,93.32 182.27,93.15 182.27,92.56 182.73,92.1 182.73,91.95 182.56,91.78 181.72,91.78 180.7,92.8 180.7,93.29 180.84,93.43 181.75,93.43
+3.3V_DGFF on TOP (solid shape): 170.42,99.3 170.81,99.2 171.19,99.31 172.16,99.31 172.48,98.99 172.48,98.48 172.35,98.35 171.49,98.35 171.28,98.15 170.28,98.15 170.17,98.27 170.17,99.19 170.29,99.31 170.41,99.31
+3.3V_DGFF on TOP (solid shape): 170.29,83.7 170.8,83.5 171.31,83.7 172.16,83.7 172.49,83.36 172.49,82.73 172.44,82.67 171.55,82.67 171.23,82.36 170.35,82.36 170.09,82.62 170.09,83.51 170.28,83.7
+3.3V_DGFF on BOTTOM (solid shape): outline of 1876 points within 169.62,78.31 191.36,99.23
+3.3V_DGFF on IN1 (solid shape): outline of 239 points within 177.72,102.16 182.54,111.8
+3.3V_DGFF on IN3 (solid shape): outline of 317 points within 180.54,88.71 185.64,102.71
+3.3V_DGFF on IN3 (solid shape): outline of 1443 points within 169.65,98.14 179.57,112.14
+3.3V_DGFF_PWR on BOTTOM (solid shape): 183.77,91.67 183.77,91.14 184.27,91.14 184.27,91.67 184.29,91.69 184.54,91.69 184.57,91.67 184.57,91.15 185.07,91.15 185.07,91.59 185.07,91.68 185.09,91.7 185.42,91.7 185.49,91.63 185.49,91.43 185.6,91.32 187.14,91.32 187.23,91.23 187.23,90.63 187.11,90.52 186.46,90.52 186.41,90.47 186.4,90.47 186.4,90.45 186.23,90.28 186.23,89.04 186.07,88.88 185.56,88.88 185.32,88.64 184.68,88.64 184.27,88.22 183.55,88.22 183.49,88.28 183.49,88.9 182.98,89.4 182.98,91.41 183.28,91.71 183.73,91.71
+3.3V_DSW on TOP (solid shape): 174.83,20.2 174.85,20.1 174.9,20.01 174.91,19.99 174.91,19.91 174.68,19.68 174.68,19.08 173.69,18.09 170.45,18.09 170.44,18.1 170.31,18.12 170.18,18.1 170.17,18.09 170.13,18.09 170.12,18.09 170.08,18.09 169.62,17.63 169.12,17.63 168.91,17.43 168.91,16.64 168.56,16.28 168.15,16.28 167.91,16.52 167.91,17.41 167.91,17.41 167.91,18.38 167.91,18.39 167.96,18.56 167.91,18.72 167.91,18.74 167.91,19.03 167.98,19.25 167.91,19.47 167.91,19.98 168.04,20.11 168.33,20.11 168.49,19.95 168.49,19.09 168.61,18.97 168.61,18.95 168.7,18.86 168.7,18.58 168.84,18.44 170.21,18.44 170.28,18.51 170.9,18.51 171.01,18.39 171.89,18.39 172.05,18.55 172.84,18.55 172.84,18.55 173.71,18.55 174.29,19.12 174.29,19.71 174.3,19.74 174.42,19.87 174.42,20.12 174.5,20.2 174.82,20.2
+3.3V_DSW on BOTTOM (solid shape): outline of 136 points within 167.53,19.56 171.62,23.36
+3.3V_DSW on VCC: 131.64,10.39 131.28,10.75 131.28,12.7 131.6,13.02 138.94,13.02 141.97,16.05 143.88,16.05 145.66,17.84 163.28,17.84 163.81,17.31 163.81,16.84 163.93,16.72 163.93,16.19 164.2,15.92 166.65,15.92 167.48,16.75 168.59,16.75 168.79,16.56 168.79,15.47 168.49,15.17 168.49,15.09 165.18,15.09 165.05,14.96 164.3,14.96 163.07,16.19 163.07,16.68 162.51,17.25 157.72,17.25 156.7,16.23 146.51,16.23 143.98,13.7 143.98,12.81 141.84,12.81 139.69,10.65 132.32,10.65 132.07,10.39
+3.3V_FUSE on BOTTOM (solid shape): 179.81,22.57 179.81,22.09 179.99,21.91 179.99,20.37 179.79,20.17 178.69,20.17 178.68,20.18 178.68,20.55 178.66,20.57 178.66,20.95 178.66,21.25 179.11,21.25 179.11,21.22 179.12,21.18 179.13,21.13 179.16,21.08 179.19,21.04 179.22,21.01 179.26,20.98 179.31,20.96 179.35,20.94 179.4,20.93 179.45,20.93 179.5,20.94 179.55,20.96 179.59,20.98 179.63,21.01 179.67,21.04 179.7,21.08 179.72,21.13 179.74,21.18 179.75,21.22 179.75,21.27 179.74,21.32 179.72,21.37 179.7,21.42 179.67,21.46 179.63,21.49 179.59,21.52 179.55,21.54 179.5,21.56 179.45,21.57 179.4,21.57 179.35,21.56 179.31,21.54 179.26,21.52 179.22,21.49 179.19,21.46 179.16,21.42 179.13,21.37 179.12,21.32 179.11,21.27 179.11,21.25 178.66,21.25 178.66,21.42 178.72,21.45 178.76,21.48 178.79,21.52 178.82,21.56 178.84,21.61 178.85,21.65 178.86,21.7 178.86,21.75 178.85,21.8 178.83,21.85 178.81,21.89 178.77,21.93 178.74,21.97 178.7,21.99 178.66,22.01 178.59,22.08 178.59,22.31 178.73,22.45 179.03,22.45 179.06,22.48 179.11,22.48 179.39,22.76 179.63,22.76
+3.3V_LAN on TOP (solid shape): 197,135.23 197,135.02 196.37,134.38 195.32,134.38 195.18,134.52 195.18,134.98 195.26,135.07 196.18,135.07 196.48,135.37 196.86,135.37
+3.3V_LAN on TOP (solid shape): 204.23,125.96 204.23,124.44 203.9,124.11 202.4,124.11 202.15,124.36 202.15,125.69 202.4,125.94 203.06,125.94 203.19,126.06 204.12,126.06
+3.3V_LAN on BOTTOM (solid shape): 182.6,124.84 182.66,124.84 182.96,124.53 182.96,123.89 183.05,123.8 183.53,123.8 183.67,123.66 183.67,122.81 183.5,122.65 181.94,122.65 181.54,123.05 181.54,124.57 181.7,124.73 181.7,125.59 181.9,125.79 182.6,125.79
+3.3V_LAN on BOTTOM (solid shape): outline of 319 points within 195.35,124.06 204.71,135.37
+3.3V_LAN on IN1 (solid shape): outline of 88 points within 185.4,130.66 197.66,135.36
+3.3V_LAN on IN2 (solid shape): outline of 405 points within 179.95,122.69 205.02,135.35
+3.3V_LAN on IN3 (solid shape): outline of 213 points within 180.84,118.01 186.98,124.11
+3.3V_LAN_OUT on BOTTOM (solid shape): 187.15,127 187.15,126.47 187.08,126.41 186.27,126.41 185.59,125.72 185.59,125.69 185.58,125.69 185.58,124.92 185.51,124.85 183.35,124.85 183.3,124.9 183.3,125.85 183.36,125.91 184.29,125.91 184.62,126.24 185.2,126.24 185.43,126.47 185.46,126.49 185.49,126.52 185.66,126.62 185.75,126.79 186.02,127.06 187.08,127.06
+3.3V_LAN_OUT on IN4 (solid shape): outline of 264 points within 184.73,126.18 193.92,132.44
+3.3V_MMI_AUX on BOTTOM (solid shape): 26.34,14.06 27.35,14.06 27.55,13.86 27.55,13.75 28.29,13.75 28.4,13.63 28.4,12.44 28.39,12.35 28.4,12.25 28.4,12.14 28.8,11.74 29.89,11.74 29.99,11.84 29.99,12.13 30.1,12.24 30.68,12.24 30.81,12.11 30.81,12.06 30.8,12.05 30.76,11.86 30.8,11.66 30.81,11.65 30.81,10.73 30.81,10.72 28.46,10.72 27.67,11.51 27.67,11.64 27.66,11.65 27.66,12.94 27.66,12.97 27.26,13.38 26.99,13.64 26.33,13.64 25.87,14.1 24.76,14.1 24.69,14.17 24.69,14.26 24.76,14.32 26.08,14.32
+3.3V_MV on BOTTOM (solid shape): 30.84,9.99 30.84,8.85 30.72,8.73 29.87,8.73 29.74,8.87 29.74,9.92 29.85,10.02 30.81,10.02
+3.3V_MV on BOTTOM (solid shape): 19.99,12.55 19.99,11.77 19.92,11.71 19.32,11.71 17.81,10.2 15.21,10.2 15.08,10.33 15.08,10.69 15.19,10.8 17.66,10.8 19.48,12.62 19.93,12.62
+3.3V_MV on BOTTOM (solid shape): 28.4,18.32 28.4,18.09 28.09,17.79 28.09,16.78 28.23,16.64 28.55,16.64 28.61,16.58 28.61,16.25 28.56,16.19 27.37,16.19 27.29,16.11 24.76,16.11 24.69,16.17 24.69,16.66 24.77,16.74 26.24,16.74 27.05,17.55 27.05,18.07 27.43,18.45 28.27,18.45
+3.3V_MV on BOTTOM (solid shape): 17.95,14.59 17.95,14.39 17.86,14.3 17.83,14.3 17.51,14.2 17.42,13.88 17.4,13.79 17.32,13.75 14.42,13.75 14.31,13.86 14.31,13.95 14.33,14.05 14.31,14.15 14.31,14.29 14.42,14.4 15.14,14.4 15.35,14.61 16.63,14.61 16.74,14.51 16.88,14.51 16.9,14.5 17,14.47 17.1,14.46 17.26,14.49 17.4,14.58 17.64,14.58 17.67,14.62 17.92,14.62
+3.3V_MV on BOTTOM: 32.13,10.93 31.67,11.39 31.67,13.86 31.13,14.4 31.13,14.77 30.78,15.12 30.21,15.12 30.21,15.12 30.21,15.9 30.32,16.02 31.19,16.02 32.6,14.61 33.7,14.61 34.03,14.28 34.03,13.61 33.49,13.61 33.49,13.11 34.03,13.11 34.03,12.81 33.49,12.81 33.49,12.31 34.03,12.31 34.03,11.53 33.43,10.93
+3.3V_MV on IN1: outline of 116 points within 13.13,8.76 37.79,20.12
+3.3V_PGPPBC on BOTTOM (solid shape): 180.23,30.36 180.81,30.36 180.92,30.25 180.92,29.1 180.77,28.95 180.43,28.95 180.41,28.99 180.12,29.2 179.82,28.99 179.8,28.95 179.66,28.95 179.65,29 179.34,29.23 179.03,29 179.02,28.95 178.3,28.95 178.28,29 177.97,29.25 177.66,29 177.65,28.95 177.57,28.95 177.55,28.97 177.3,29.08 177.06,28.95 176.58,28.95 176.27,28.64 176.23,28.65 176.06,28.64 175.91,28.54 175.39,28.54 175.01,28.16 173.87,28.16 173.8,28.22 173.8,28.91 174.12,29.23 174.82,29.23 175.23,29.64 176.32,29.64 176.6,29.92 176.88,29.92 176.93,29.93 176.97,29.94 177.35,29.94 177.43,29.93 177.51,29.93 177.62,29.92 177.73,29.94 177.96,29.94 178.06,29.93 178.15,29.94 178.23,29.94 178.36,29.92 178.49,29.94 178.99,29.94 179.14,29.92 179.28,29.96 179.45,30.09 179.5,30.29 179.49,30.32 179.68,30.5 180.08,30.5
+3.3V_PGPPEF on BOTTOM (solid shape): 184.01,26.35 184.01,25.55 184.01,25.49 183.93,25.4 183.88,25.36 183.81,25.35 183.5,25.19 183.53,24.83 183.53,23.75 183.52,23.74 183.47,23.55 183.52,23.36 183.53,23.35 183.53,22.55 183.49,22.45 183.38,22.42 183.03,22.23 183.14,21.85 183.14,21.64 183.07,21.58 183.07,20.68 182.48,20.68 182.4,20.76 182.4,24.42 182.75,24.77 182.75,26.12 182.96,26.33 183.49,26.33 183.64,26.49 183.87,26.49
+3.3V_PGPPG on BOTTOM (solid shape): 180.93,34.06 180.93,33.54 180.89,33.52 180.77,33.4 180.74,33.23 180.74,33.2 180.57,33.02 180.54,33 180.52,32.99 180.44,32.91 179.65,32.91 179.5,33.07 178.97,33.07 178.76,33.19 178.53,33.09 178.05,33.09 177.99,33.15 177.98,33.15 177.92,33.22 174.8,33.22 174.76,33.18 174.16,33.18 174.12,33.22 174.12,33.87 174.2,33.94 175.31,33.94 175.38,33.87 176.02,33.87 176.09,33.94 176.92,33.94 176.93,33.9 177.23,33.7 177.53,33.9 177.54,33.94 178.57,33.94 178.77,33.74 178.77,33.74 179.05,33.6 179.33,33.74 179.6,33.74 180.01,33.63 180.24,33.99 180.24,34.01 180.41,34.19 180.81,34.19
+3.3V_PGPPHK on BOTTOM (solid shape): 186.39,26.36 186.39,26.25 186.42,26.22 186.95,26.22 187.05,26.13 187.05,25.85 187.07,25.83 187.07,25.1 187.19,24.97 187.2,24.95 187.24,24.82 187.34,24.73 187.34,24.56 187.33,24.55 187.28,24.38 187.33,24.21 187.34,24.19 187.34,23.42 187.61,23.14 187.61,23.11 187.64,22.94 187.76,22.82 187.79,22.8 187.79,22.42 187.79,22.34 187.79,22.27 187.79,21.2 188.39,20.6 188.39,19.23 188.21,18.99 188.28,18.69 188.28,17.58 188.26,17.54 188.03,17.3 187.37,17.3 187.26,17.42 187.26,17.88 186.9,18.24 186.9,18.89 187.21,19.2 186.9,19.52 186.9,20.9 186.49,21.31 186.48,21.33 186.42,21.46 186.3,21.55 186.26,21.56 186.26,21.72 186.37,21.83 186.43,21.96 186.77,22.24 186.51,22.59 186.44,22.64 186.42,22.72 186.43,22.76 186.47,22.8 186.49,22.8 186.75,23.07 186.59,23.4 186.55,23.43 186.53,23.49 186.69,23.78 186.54,24.07 186.49,24.16 186.53,24.26 186.62,24.55 186.44,24.78 186.39,24.84 186.4,24.92 186.36,25.29 186.01,25.42 185.98,25.42 185.83,25.56 185.83,26.45 185.92,26.53 186.22,26.53
+3.3V_PHVC on BOTTOM (solid shape): 171.83,40.35 172.87,40.35 173.29,39.92 174.79,39.92 174.91,39.8 174.91,39.16 174.78,39.03 173.92,39.03 173.53,39.42 173.53,39.43 172.65,39.43 172.62,39.45 172.61,39.47 172.39,39.67 172.09,39.64 172.08,39.63 171.68,39.63 170.87,40.45 171.3,40.88
+3.3V_PHVLDO on BOTTOM: 170.27,43.24 170.27,43.19 170.58,42.77 171.07,42.96 171.15,43.01 171.23,42.98 172.15,42.06 172.35,42.06 172.71,42.43 172.8,42.43 173.14,42.1 173.14,41.91 173.79,41.25 173.79,41.24 173.99,40.99 174.31,41 174.43,41 174.66,40.77 174.66,40.76 174.89,40.47 175.24,40.53 175.28,40.56 175.34,40.5 175.34,40.48 175.57,40.16 175.96,40.25 177.72,40.25 177.74,40.22 177.74,40.2 177.81,40.13 177.81,39.93 177.51,39.63 175.85,39.63 175.62,39.86 175.14,39.86 174.86,40.14 173.29,40.14 172.79,40.65 172.13,40.65 172.06,40.71 172.04,41.16 171.59,41.23 171.56,41.21 170.63,42.15 170.12,42.15 170.03,42.19 170.02,42.28 169.68,42.74 169.34,42.28 169.32,42.19 169.24,42.15 168.78,42.15 168.13,42.8 166.91,42.8 166.83,42.87 166.73,42.92 166.71,42.94 166.71,43.51 166.99,43.79 169.72,43.79
+3.3V_PRTC on TOP (solid shape): 175.62,19.69 175.62,19.47 175.5,19.35 175.5,19.34 175.39,19.23 175.39,18.64 174.93,18.58 175.02,18.12 174.32,17.43 170.18,17.43 170.06,17.55 170.06,17.84 170.18,17.97 173.77,17.97 174.82,19.01 174.82,19.63 174.94,19.75 175.56,19.75
+3.3V_PRTC on IN2 (solid shape): outline of 144 points within 165.84,16.83 170.47,18.58
+3.3V_PUSB2 on BOTTOM (solid shape): 191.52,34.1 191.52,33.43 191.39,33.3 191.31,33.3 191.3,33.31 190.96,33.24 190.89,32.89 190.89,32.88 190.89,32.8 190.79,32.7 190.45,32.7 190.43,32.73 190.16,32.89 189.88,32.74 189.8,32.7 189.72,32.74 189.4,32.85 189.15,32.61 189.15,32.6 188.08,31.53 187.52,31.53 187.38,31.66 187.38,32.13 187.5,32.25 187.79,32.25 189.18,33.64 189.22,33.62 189.34,33.59 189.47,33.6 189.58,33.65 189.66,33.73 190.11,33.73 190.24,33.86 190.25,33.86 190.33,33.92 190.39,34 190.39,34.01 190.55,34.17 191.46,34.17
+3.3V_RUN on TOP (solid shape): 172.48,129.52 172.48,128.66 171.95,128.12 170.6,128.12 170.22,128.5 170.22,129.54 170.3,129.62 172.38,129.62
+3.3V_RUN on TOP (solid shape): 187.39,81.81 187.39,80.5 187.16,80.27 185.43,80.27 185.33,80.37 185.33,81.59 185.78,82.04 187.16,82.04
+3.3V_RUN on TOP (solid shape): 172.53,133.71 172.53,132.29 172.33,132.08 171.06,132.08 170.78,132.36 170.78,133.68 170.93,133.84 172.4,133.84
+3.3V_RUN on TOP (solid shape): 73.89,36.93 73.89,34.8 73.78,34.7 72.82,34.7 72.64,34.88 72.64,36.47 72.94,36.77 72.94,36.96 73.04,37.06 73.76,37.06
+3.3V_RUN on TOP (solid shape): 154.4,47.22 154.4,46.71 154.01,46.33 153.38,46.33 153.25,46.21 153.25,44.68 153.13,44.56 152.24,44.56 151.56,45.23 151.56,45.91 153,47.35 154.27,47.35
+3.3V_RUN on TOP (solid shape): 333.7,20.62 333.7,20.08 333.72,20.07 334.17,20.07 334.18,20.08 334.18,20.62 334.19,20.63 334.86,20.63 334.94,20.54 334.94,19.36 334.79,19.2 333.5,19.2 333.27,19.44 333.27,20.54 333.37,20.64 333.69,20.64
+3.3V_RUN on TOP (solid shape): 347.01,46.46 347.01,43.43 346.75,43.18 345.45,43.18 345.28,43.34 345.28,44.96 345.26,44.98 344.73,44.98 344.72,44.99 344.72,45.21 344.73,45.22 345.26,45.22 345.28,45.24 345.28,45.75 345.27,45.77 344.73,45.77 344.72,45.78 344.72,46.02 344.73,46.03 345.24,46.03 345.28,46.07 345.28,46.5 345.34,46.55 346.91,46.55
+3.3V_RUN on TOP (solid shape): 43.83,31.61 43.83,29.23 43.51,28.91 42.65,28.91 42.35,29.2 42.35,29.38 42.5,29.52 42.52,29.52 42.52,29.54 42.56,29.58 42.56,30 43.07,30 43.07,30.01 43.1,30.04 43.1,30.57 43.09,30.57 43.03,30.57 42.55,30.57 42.53,30.59 42.53,30.8 43.07,30.8 43.07,30.8 43.09,30.83 43.09,31.37 43.09,31.38 42.54,31.38 42.54,31.38 42.54,31.58 42.57,31.66 42.66,31.68 42.76,31.68 42.87,31.71 42.88,31.71 43.72,31.71
+3.3V_RUN on TOP (solid shape): 277.03,3.8 277.03,2.87 276.09,1.93 272.98,1.93 272.97,1.99 272.56,2.29 272.27,1.87 272.25,1.76 272.15,1.71 269.34,1.71 269.24,1.82 269.24,3.3 269.81,3.88 276.17,3.88 276.17,3.33 276.17,3.33 276.62,3.33 276.64,3.34 276.64,3.89 276.64,3.89 276.94,3.89
+3.3V_RUN on TOP (solid shape): 178.17,132.54 178.17,130.2 177.74,129.77 176.39,129.77 176.24,129.93 176.24,130.69 176.47,130.92 176.47,131.56 176.56,131.56 176.58,131.53 177.23,131.75 176.56,131.92 176.43,131.92 176.22,132.13 176.22,132.77 176.37,132.92 177.79,132.92
+3.3V_RUN on TOP (solid shape): 66.19,28.93 66.19,25.77 66.11,25.69 66.1,25.69 66.03,25.65 65.96,25.59 65.92,25.58 65.64,25.65 65.42,25.55 65.37,25.53 65.33,25.55 65,25.64 64.74,25.42 64.74,25.4 64.06,24.72 61.34,24.72 61.22,24.85 61.22,25.35 61.36,25.5 63.74,25.5 63.86,25.61 63.86,25.87 64,26.02 64.76,26.02 65.09,26.36 65.38,26.36 65.51,26.49 65.51,28.88 65.66,29.04 66.09,29.04
+3.3V_RUN on TOP (solid shape): outline of 416 points within 54.57,25 60.3,36.19
+3.3V_RUN on BOTTOM (solid shape): 35.7,13.97 35.7,11.89 35.5,11.69 34.3,11.69 34.15,11.84 34.15,12.43 33.62,12.43 33.62,12.68 34.15,12.68 34.15,13.23 33.62,13.23 33.62,13.48 34.15,13.48 34.15,14.14 34.22,14.2 35.47,14.2
+3.3V_RUN on BOTTOM (solid shape): 73.92,35.83 73.92,33.73 73.64,33.45 73.64,31.49 73.75,31.38 73.75,31.26 73.87,31.26 74.24,30.89 74.24,30.79 74.07,30.63 73.86,30.63 73.85,30.66 73.72,30.81 73.53,30.87 73.46,30.89 73.43,30.96 73.3,31.17 73.06,31.23 73.03,31.22 72.88,31.38 72.88,32.07 72.24,32.7 72.24,36.05 72.39,36.2 73.55,36.2
+3.3V_RUN on BOTTOM (solid shape): 112.12,17.85 112.12,17.21 112.48,16.84 114.23,16.84 114.94,17.56 115.12,17.56 115.19,17.53 115.22,17.46 115.22,17.42 115.22,17.38 114.8,16.84 115.43,17.13 115.5,17.11 115.57,17.1 115.81,17.18 115.94,17.39 115.94,17.45 116.41,17.45 116.5,17.36 116.5,15.17 116.36,15.03 116.36,14.61 116.21,14.46 115.65,14.46 114.96,15.15 110.76,15.15 110.47,15.45 110.47,17.7 110.82,18.05 111.91,18.05
+3.3V_RUN on BOTTOM (solid shape): 336.8,32.44 337.72,31.88 338.64,32.44 341.26,32.44 341.86,31.84 341.86,28.5 341.78,28.43 341.67,28.43 341.63,28.39 341.61,28.38 341.37,28.21 341.42,27.92 341.45,27.86 341.42,27.79 341.35,27.64 341.39,27.47 341.39,27.46 341.39,25.67 341.3,25.58 340.17,25.58 340.08,25.67 340.08,26.4 340.56,26.88 340.56,27.27 340.61,27.33 340.61,27.35 340.7,27.44 340.7,27.95 341.1,28.35 341.1,28.86 340.83,29.12 340.83,30.27 340.14,30.97 339.02,30.97 338.6,30.55 336.23,30.55 335.89,30.89 335.89,32.22 336.11,32.44
+3.3V_RUN on BOTTOM (solid shape): outline of 102 points within 231.64,1.65 239.53,21.33
+3.3V_RUN on BOTTOM (solid shape): 154.13,46.89 154.13,45.34 154.06,45.27 152.62,45.27 152.09,44.74 152.09,44.46 152.06,44.44 151.83,44.11 152.06,43.78 152.09,43.77 152.09,43.54 152.76,42.87 152.74,42.84 152.82,42.39 153.27,42.38 155.97,42.38 156.77,41.58 156.77,41.18 156.24,40.65 155.97,40.65 155.85,40.72 155.72,40.75 154.94,40.75 154.37,41.32 153.1,41.32 152.64,41.78 151.95,41.78 150.48,43.26 150.48,43.98 150.51,43.99 150.73,44.32 150.51,44.65 150.48,44.66 150.48,44.97 151.26,45.75 151.27,45.75 151.35,45.83 151.36,45.84 151.57,46.09 151.49,46.41 151.49,47 151.57,47.08 153.94,47.08
+3.3V_RUN on IN2 (solid shape): outline of 574 points within 236.27,1.24 272.23,5.38
+3.3V_RUN on IN2 (solid shape): outline of 1034 points within 169.67,126.86 179.1,136.09
+3.3V_RUN on IN4 (solid shape): outline of 452 points within 106.47,17.25 115.62,25.9
+3.3V_RUN on IN4 (solid shape): outline of 855 points within 180.43,80.61 187.86,108.28
+3.3V_RUN on IN4 (solid shape): outline of 935 points within 193.54,52.88 200.6,67.98
+3.3V_RUN on IN4 (solid shape): outline of 1716 points within 290.85,43.22 346.86,58.98
+3.3V_RUN on VCC: 266.66,1.22 266.66,1.52 270.07,4.93 314.65,4.93 318.1,8.38 327.23,8.38 331.59,12.74 331.59,22.77 331.58,22.78 331.58,28.09 328.88,30.79 327.63,30.79 327.5,30.93 327.5,47.45 345.49,47.45 347.12,45.81 347.12,41.08 333.92,27.88 333.92,22.64 333.48,22.21 333.48,20.95 334.32,20.11 334.75,20.11 334.88,19.97 334.88,17.16 334.79,17.06 333.88,17.06 333.19,16.37 333.19,14.4 334.29,13.29 339.88,13.29 341.32,11.85 344.48,11.85 345.96,10.36 343.58,7.97 343.58,7.28 342.34,6.78 341.83,5.56 341.83,1.22
+3.3V_RUN on VCC: outline of 194 points within 34.03,8.74 250.58,140.77 ; 1 cut-out
+3.3V_RUN on VCC: 314.69,30.33 316.15,30.33 316.34,30.14 316.34,28.19 316.05,27.9 316.06,27.89 309.97,21.8 309.97,13.42 308.72,12.17 258.05,12.17 255.38,9.5 216.75,9.5 216.75,11.51 216.1,12.17 199.71,12.17 198.19,13.69 170.12,13.69 168.75,15.07 169.05,15.36 169.05,16.66 168.7,17.01 167.37,17.01 166.54,16.18 164.31,16.18 164.19,16.3 164.19,16.71 164.32,16.84 164.32,17.31 164.69,17.68 169.17,17.68 169.81,17.04 197.99,17.04 200.23,14.79 210.91,14.79 211.25,14.45 212.28,14.45 212.59,14.76 246.87,14.76 251.91,19.8 281.25,19.8 288.02,26.57 288.02,43.14 296.29,51.4 296.29,51.4 304.66,43.03 312.28,43.03 313.78,41.53 313.78,31.24
+3.3V_RUN_AUDIO on TOP (solid shape): 334.93,22.12 334.93,21.88 334.47,21.41 334.47,20.79 334.43,20.76 334.06,20.76 334.05,20.74 334.05,20.2 334.04,20.19 333.87,20.19 333.86,20.2 333.86,20.75 333.85,20.76 333.46,20.76 333.43,20.8 333.43,22.39 333.57,22.53 334.53,22.53
+3.3V_RUN_AUDIO on VCC: 346.32,10.72 344.69,12.35 341.55,12.35 340.11,13.8 339.61,13.8 339.56,13.85 339.56,13.89 339.56,15.73 338.22,17.07 335.49,17.07 335.4,17.17 335.4,20.2 334.98,20.63 334.53,20.63 333.99,21.16 333.99,21.99 334.28,22.28 340.59,22.28 344.77,18.11 345.51,18.11 345.51,16.32 345.51,15.99 346.18,15.32 346.47,15.33 346.53,15.31 346.57,15.33 346.62,15.33 348.82,15.33 349.01,15.14 350.34,15.14 350.52,15.33 350.77,15.33 350.77,13.73 349.45,12.41 348.02,12.41
+3.3V_RUN_DIMM2 on BOTTOM (solid shape): outline of 182 points within 201.73,42.38 206.04,46.05
+3.3V_RUN_DIMM4 on TOP (solid shape): 209.76,62.83 209.76,62.82 210.09,62.49 210.09,59.09 210.01,59.01 209.81,59.01 209.76,59.07 209.76,60.77 209.55,60.97 205.12,60.97 203.25,59.1 203.25,57.36 203.02,57.13 203.01,57.13 202.96,57.08 202.26,57.08 202.17,57.17 202.17,63.15 202.91,63.89 208.69,63.89
+3.3V_RUN_PWR on TOP (solid shape): 345.14,46.57 345.14,46.17 345.13,46.17 344.59,46.17 344.58,46.16 344.58,45.65 344.61,45.63 345.13,45.63 345.13,45.62 345.13,45.38 345.12,45.37 344.59,45.37 344.59,44.83 344.59,44.83 345.13,44.83 345.13,44.82 345.13,44.38 344.81,44.06 340.68,44.06 340.63,44.11 340.63,45.06 340.87,45.3 340.87,46.54 341.12,46.79 344.92,46.79
+3.3V_SPI on VCC: 134.82,41.25 136.55,41.25 139.43,44.14 158.88,44.14 169.44,54.7 170.31,54.7 171.35,53.66 171.35,53.14 160.15,41.94 140.92,41.94 138.22,39.25 135.3,39.25 134.59,39.96 134.59,41.02
+3.3V_SSD3 on TOP (solid shape): 95.04,40 95.04,36.38 94.74,36.08 93.98,36.08 93.63,35.73 93.63,32.79 92.34,31.5 89.31,31.5 89.11,31.7 89.11,33.1 89.33,33.33 90.01,33.33 90.34,33.67 90.34,35.18 90.35,35.18 90.35,35.83 90.64,36.12 91.42,36.12 91.94,36.64 91.94,37.83 92.83,37.83 92.83,37.77 92.83,37.72 92.85,37.67 92.87,37.62 92.9,37.58 92.94,37.54 92.98,37.5 93.03,37.48 93.08,37.46 93.13,37.45 93.18,37.44 93.24,37.45 93.29,37.46 93.34,37.48 93.38,37.5 93.42,37.54 93.46,37.58 93.49,37.62 93.51,37.67 93.53,37.72 93.54,37.77 93.54,37.83 93.53,37.88 93.51,37.93 93.49,37.98 93.46,38.02 93.42,38.06 93.38,38.09 93.34,38.12 93.29,38.14 93.24,38.15 93.18,38.16 93.13,38.15 93.08,38.14 93.03,38.12 92.98,38.09 92.94,38.06 92.9,38.02 92.87,37.98 92.85,37.93 92.83,37.88 92.83,37.83 91.94,37.83 91.94,38.38 92.33,38.77 92.33,39.65 92.51,39.83 92.77,39.83 93.12,40.18 93.12,40.47 93.26,40.61 94.43,40.61
+3.3V_SSD3 on BOTTOM (solid shape): 74.29,50.38 74.29,49.76 73.69,49.16 73.69,48.24 73.51,48.06 72.68,48.06 72.58,48.16 72.58,50.16 72.88,50.4 73.15,50.66 73.17,50.68 73.99,50.68
+3.3V_SSD3 on BOTTOM (solid shape): 90.26,32.74 90.26,30.54 90,30.28 86.1,30.28 85.81,29.99 84.08,29.99 83.16,30.9 83.14,30.97 83.14,31.47 83.14,32.08 83.22,32.16 84.58,32.16 84.8,31.94 86.07,31.94 86.27,31.86 86.48,31.94 88.51,31.94 88.6,32.03 88.62,32.03 88.62,32.06 88.69,32.12 88.69,32.49 89.09,32.9 90.1,32.9
+3.3V_SSD3 on BOTTOM (solid shape): 82.61,51.39 82.9,51.24 83.19,51.39 83.76,51.39 85.03,50.12 85.03,48.37 84.86,48.2 84.68,48.2 84.61,48.22 84.55,48.23 83.3,48.23 83.24,48.22 83.17,48.2 83.08,48.2 82.94,48.07 82.94,48.02 82.89,47.93 82.78,47.94 82.23,47.81 82.49,47.31 82.5,47.31 82.94,46.87 82.94,46.86 83.15,46.65 84.61,46.65 84.72,46.54 84.72,46.47 86.44,44.76 90.46,44.76 90.65,44.56 90.65,43.73 90.48,43.56 89.96,43.56 89.96,43.4 89.91,43.35 89.91,43.11 89.64,42.84 86.66,42.84 86.34,43.17 85.79,43.17 85.77,43.18 85.05,43.18 84.85,43.39 84.85,44.53 84.79,44.59 84.75,44.65 84.69,44.69 84.61,44.77 82.47,44.77 81.59,45.65 81.59,46.22 81.55,46.26 81.55,47.39 81.73,47.72 81.58,48.06 81.56,48.1 81.58,48.13 81.65,48.36 81.56,48.59 82.78,49.81 82.78,50.02 81.87,50.93 81.87,51.15 82.11,51.39
+3.3V_SSD3 on IN1 (solid shape): outline of 450 points within 81.48,38.52 94.23,51.38
+3.3V_SSD3 on IN3: 81.91,51.72 82.76,50.87 83.12,50.87 83.48,50.51 83.48,48.63 83.16,48.31 81.65,48.31 81.65,48.37 81.41,48.69 81.02,48.58 80.94,48.54 80.86,48.58 80.79,48.65 80.7,48.69 80.63,48.75 80.63,48.83 80.15,49.28 80.19,48.62 80.25,48.56 80.25,48.48 80.24,48.43 80.23,48.37 80.23,48.31 79.06,48.31 77.28,50.08 73.14,50.08 72.85,50.37 72.85,51.45 74.04,52.64 75.07,52.64 75.12,52.63 75.17,52.64 78.27,52.64 78.35,52.59 78.36,52.49 78.68,51.99 79.01,52.49 79.01,52.59 79.1,52.64 80.28,52.64 81.2,51.72
+3.3V_SSD3_PWR on TOP (solid shape): 90.2,31.34 90.75,31.34 90.75,30.82 91.26,30.82 91.26,31.34 91.55,31.34 91.55,30.82 92.06,30.82 92.06,31.34 92.4,31.34 92.42,31.29 92.45,31.21 92.5,31.13 92.61,31.05 92.74,31.02 92.82,30.98 92.85,30.91 93.14,30.6 93.52,30.78 94.07,30.78 94.26,30.58 94.26,28.85 94.01,28.6 92.91,28.6 92.09,27.78 91.77,27.78 91.47,27.47 89.96,27.47 89.88,27.55 89.88,28.07 89.94,28.13 90.55,28.13 90.62,28.14 90.82,28.33 90.82,28.74 89.64,29.91 89.64,31.21 89.77,31.34 90.19,31.34
+3.3V_SSD4 on TOP (solid shape): outline of 1383 points within 333.84,6.17 369.57,15.76
+3.3V_SSD4 on BOTTOM (solid shape): 339.55,15.14 339.55,14.85 340.27,14.13 341.92,14.13 341.97,14.08 341.97,11.56 341.56,11.14 338.9,11.14 337.25,12.79 334.06,12.79 333.53,13.31 333.53,15.28 333.71,15.45 335.02,15.45 335.1,15.37 336.25,14.2 337.16,15.57 337.32,15.73 338.96,15.73
+3.3V_SSD4 on BOTTOM (solid shape): 363.03,7.88 363.03,6.36 362.8,6.13 362.46,6.13 362.22,6.37 362.22,6.64 362.08,6.78 361.93,6.94 361.72,7.01 361.64,7.06 361.63,7.15 361.15,7.82 360.67,7.15 360.66,7.06 360.59,7.01 360.37,6.94 360.22,6.78 360.04,6.6 360.04,6.33 359.85,6.13 358.47,6.13 358.26,6.34 358.26,6.71 358.35,6.8 358.38,6.8 358.48,6.91 358.49,6.93 358.51,6.95 358.65,7.4 358.31,7.84 358.34,7.93 358.58,8.18 362.74,8.18
+3.3V_SSD4 on IN1 (solid shape): outline of 1073 points within 310.24,12.72 339.12,20.52
+3.3V_SSD4 on TOP: 311.86,12.68 311.75,12.78 311.75,15.65 311.83,15.73 312.9,15.73 312.91,15.68 313.02,15.48 313.22,15.39 313.31,15.35 313.34,15.27 313.34,14.7 313.89,14.7 313.89,14.7 313.89,14.45 313.88,14.44 313.33,14.44 313.33,13.89 313.88,13.89 313.89,13.88 313.89,13.65 313.89,13.65 313.74,13.65 313.73,13.65 313.34,13.65 313.34,12.8 313.22,12.68
+3.3V_SSD4 on VCC: 334.58,13.8 334.41,13.96 334.4,13.96 333.7,14.66 333.7,16.15 334.09,16.54 338.03,16.54 339.03,15.54 339.03,13.91 338.92,13.8
+3.3V_SSD4_PWR on TOP: 317.4,14.9 316.64,14.15 316.64,13.33 317.17,12.81 317.88,12.81 317.99,12.7 317.99,12.12 317.69,11.83 314.77,11.83 314.28,12.32 313.7,12.32 313.49,12.54 313.49,13.5 314.04,13.5 314.04,13.5 314.04,14.04 314.03,14.05 313.49,14.05 313.49,14.3 314.03,14.3 314.04,14.31 314.04,14.85 314.03,14.85 313.47,14.85 313.47,15.23 313.56,15.32 314.08,15.32 314.51,15.75 314.51,16.32 314.88,16.69 317.29,16.69 317.41,16.58 317.41,15.28 317.4,15.28
+3.3V_SSD5 on TOP (solid shape): 86.67,6.24 86.67,5.11 86.35,4.79 84.63,4.79 84.18,5.25 84.18,6.11 84.46,6.39 86.53,6.39
+3.3V_SSD5 on TOP (solid shape): 88.65,23.34 88.65,22.35 88.84,22.16 88.86,22.14 89.41,22.14 89.43,22.17 89.43,22.68 89.69,22.68 89.69,22.14 90.24,22.14 90.24,22.69 90.48,22.69 90.48,22.13 91.07,22.13 91.07,20.28 90.88,20.09 87.29,20.09 86.95,19.75 86.95,19.26 86.7,19.01 84.45,19.01 83.61,19.85 83.61,22.53 84.01,22.93 84.01,24.45 84.26,24.7 87.28,24.7
+3.3V_SSD5 on BOTTOM (solid shape): 86.71,6.99 86.71,5.18 86.35,4.82 84.44,4.82 84.23,5.03 84.23,5.5 84.04,5.69 83.77,5.69 83.72,5.69 83.23,5.69 83.06,5.86 83.06,6.98 83.19,7.1 86.61,7.1
+3.3V_SSD5 on BOTTOM (solid shape): outline of 154 points within 81.85,16.69 86.87,24.55
+3.3V_SSD5 on IN2 (solid shape): outline of 666 points within 81.6,4.78 87.29,23.81
+3.3V_SSD5_PWR on TOP (solid shape): 91.14,25.81 92.56,25.81 92.62,25.75 92.62,24.73 92.83,24.52 92.83,23.67 93.16,23.35 93.16,22.45 92.98,22.28 90.65,22.28 90.65,22.28 90.65,22.83 90.63,22.84 90.11,22.84 90.1,22.83 90.1,22.3 90.09,22.29 89.84,22.29 89.84,22.29 89.84,22.84 89.3,22.84 89.3,22.29 89.29,22.28 88.97,22.28 88.95,22.29 88.95,23.59 89.05,23.68 89.06,23.68 89.44,24.06 89.44,24.06 89.9,24.52 89.98,24.58 90.04,24.66 90.12,24.74 90.12,24.75 90.15,24.77 90.15,25.1 89.87,25.38 89.87,26.05 89.94,26.12 90.83,26.12
+3.3V_TBT on TOP (solid shape): 41.06,32.46 41.06,31.95 41.18,31.83 41.2,31.81 41.23,31.78 41.38,31.63 42.39,31.63 42.39,31.18 42.93,31.18 42.94,31.17 42.94,30.93 42.39,30.93 42.39,30.37 42.94,30.37 42.94,30.13 42.39,30.13 42.39,29.65 42.36,29.62 41.24,29.62 40.96,29.89 40.96,31.58 40.85,31.7 40.27,31.7 40.18,31.8 40.18,32.55 40.26,32.63 40.9,32.63
+3.3V_TBT_S0 on TOP (solid shape): 31.98,47.01 31.98,46.55 31.81,46.38 29.47,46.38 29.18,46.09 29.18,45.2 28.87,44.89 28.87,44.07 28.79,43.99 28.58,43.99 28.46,44.12 28.46,44.29 28.36,44.38 28.36,44.75 28.05,45.06 27.73,45.06 27.68,45.11 27.68,45.73 28.31,46.36 28.31,47.01 28.4,47.1 28.41,47.1 28.48,47.16 31.82,47.16
+3.3V_TBT_S0 on TOP (solid shape): 39.58,32.63 39.7,32.5 39.87,32.45 39.91,32.43 39.93,32.38 39.93,31.86 40.21,31.58 40.71,31.58 40.75,31.53 40.75,29.19 40.75,29.18 40.73,29.05 40.75,28.92 40.75,28.91 40.75,28.67 40.66,28.57 40,28.57 39.91,28.66 39.91,31.15 39.75,31.32 39.49,31.32 39.45,31.31 39.3,31.31 39.19,31.43 39.19,31.68 39.12,31.74 39,31.74 38.86,31.89 38.86,32.57 38.91,32.61 38.96,32.67 39.56,32.67
+3.3V_TBT_S0 on BOTTOM (solid shape): 28.81,44.94 28.81,44.67 28.89,44.67 28.89,43.9 28.89,43.49 29.01,43.37 29.18,43.37 29.28,43.28 29.28,43.16 29.23,43.11 29.19,43.09 29.16,43.07 28.62,43.07 28.5,43.2 28.5,43.8 28.49,43.82 28.43,43.88 28.43,45.01 28.51,45.09 28.66,45.09
+3.3V_TBT_S0 on VCC: 31.57,49.31 31.57,49.3 31.65,49.3 40.36,40.59 40.36,35.77 40.35,35.76 40.35,34.75 39.83,34.23 39.83,31.49 39.55,31.21 38.58,31.21 38.35,31.45 32.86,31.45 31.06,29.65 31.06,27.52 31.02,27.48 29.7,27.48 24.69,32.49 24.69,42.43 ; 1 cut-out
+3.3V_TBT_SX on TOP (solid shape): 36.39,48.78 36.39,48.18 36.46,48.1 36.78,48.1 37.03,47.85 37.03,44.91 36.81,44.69 36.78,44.69 36.68,44.69 36.58,44.66 36.57,44.66 36.17,44.66 36.11,44.6 36.09,44.6 35.83,44.41 35.82,44.09 35.83,44.08 35.83,44.01 36.26,43.58 36.27,43.58 36.29,43.55 36.59,43.41 36.88,43.58 37.91,43.58 37.99,43.5 37.99,42.98 37.96,42.96 37.43,42.96 37.24,42.77 37.19,42.77 37.19,42.71 37.13,42.71 37.13,42.17 37.07,42.1 35.83,42.1 35.77,42.16 35.77,42.69 35.64,42.82 35.07,42.82 34.93,42.96 34.93,43.37 34.92,43.38 34.92,43.44 34.77,43.59 34.51,43.59 34.37,43.73 34.37,45.04 34.52,45.19 35.22,45.19 35.55,45.52 35.83,45.52 35.89,45.58 35.89,46.18 36.44,46.18 36.44,46.62 35.89,46.62 35.89,47.35 35.67,47.57 35.67,48.76 35.82,48.91 36.26,48.91
+3.3V_TBT_SX on IN1: 37.63,50.35 37.63,48.25 37.17,47.8 37.17,47.6 36.89,47.31 36.18,47.31 36.17,47.32 35.89,47.32 35.64,47.57 35.64,50.1 35.42,50.32 33.66,50.32 33.53,50.44 33.53,51.5 33.82,51.79 36.19,51.79
+3.3V_TBT_SX on IN2: outline of 175 points within 24.38,36.01 37.04,51.34 ; 1 cut-out
+3.3V_TP on TOP (solid shape): 279.37,6.39 279.37,5.03 278.37,4.03 276.49,4.03 276.49,3.47 276.31,3.47 276.31,4.03 273.96,4.03 273.47,4.52 273.47,5.59 273.53,5.65 274.13,5.65 274.22,5.56 274.22,5.02 274.44,4.8 277.81,4.8 278.07,5.06 278.07,6.74 278.21,6.88 278.88,6.88
+3.3V_VDD_PIC on TOP (solid shape): 42.64,27.04 42.67,26.96 42.67,26.79 42.9,26.57 43.26,26.57 43.53,26.31 43.53,25.79 43.3,25.56 42.56,25.56 42.56,25.55 41.79,25.55 41.77,25.57 41.77,27.08 42.6,27.08
+3.3V_WLAN on TOP (solid shape): outline of 205 points within 315.38,16.93 322.23,26.86
+3.3V_WLAN on BOTTOM (solid shape): 319.56,20.4 319.56,19.39 319.01,18.84 318.06,18.84 317.81,18.58 317.81,16.77 317.71,16.67 315.63,16.67 315.46,16.84 315.46,20.34 315.59,20.48 319.48,20.48
+3.3V_WLAN on BOTTOM (solid shape): 337.11,20.98 337.11,20.38 337.02,20.26 336.99,20.11 336.99,20.08 336.88,19.97 336.88,19.29 336.83,19.21 336.73,19.2 336.21,18.88 336.73,18.57 336.83,18.56 336.88,18.48 336.88,17.36 336.22,16.7 334.6,16.7 334.49,16.81 334.49,19.15 334.53,19.23 334.62,19.25 335.07,19.59 334.62,19.93 334.53,19.95 334.49,20.03 334.49,20.39 334.91,20.81 334.93,20.81 335.14,20.88 335.27,21.06 335.28,21.09 337,21.09
+3.3V_WLAN on IN1 (solid shape): outline of 1335 points within 314.36,17.79 336.82,24.51
+3.3V_WLAN_PWR on TOP (solid shape): 324.06,26.71 324.06,26.31 324.26,26.12 324.26,25.53 324.58,25.21 324.97,25.21 325.29,24.89 325.29,24.27 325.23,24.21 324.57,24.21 324.38,24.02 324.38,22.99 323.85,22.46 322.81,22.46 322.71,22.56 322.71,23.84 322,24.55 321.51,24.55 321.45,24.6 321.18,24.6 321.11,24.68 321.11,25.07 321.12,25.08 321.47,25.08 321.48,25.08 321.64,25.08 321.66,25.1 321.66,25.63 321.65,25.63 321.11,25.63 321.11,25.88 321.11,25.89 321.46,25.89 321.46,25.89 321.65,25.89 321.66,25.9 321.66,26.43 321.65,26.44 321.11,26.44 321.11,26.44 321.11,26.77 321.17,26.83 323.95,26.83
+3.3V_WWAN on TOP (solid shape): 289.47,10.32 289.47,9.56 288.96,9.05 288.06,9.05 287.85,8.83 283.6,8.83 283.32,9.11 283.32,10.02 283.48,10.18 285.3,10.18 285.38,10.09 286.81,10.09 286.89,10.18 286.9,10.18 287.31,10.59 289.21,10.59
+3.3V_WWAN on TOP (solid shape): 331.29,24.7 331.29,23.13 331.16,23 330.79,23 330.53,22.75 330.53,22.41 330.38,22.26 329.75,22.26 329.74,22.27 329.74,22.73 329.73,22.74 329.2,22.74 329.2,22.75 329.2,22.99 329.21,22.99 329.74,22.99 329.75,23 329.75,23.53 329.74,23.54 329.19,23.54 329.19,23.79 329.2,23.79 329.74,23.79 329.75,23.8 329.75,24.54 330.07,24.86 331.12,24.86
