# Allegro board LAH271PR10-0410_Gerber.brd (continued)
## Nets (continued)
PCH_PLTRST#_R: JNGFF1.44 JNGFF2.42 JNGFF3.50(PERST#) JNGFF4.50(PERST#) JNGFF5.50(PERST#) RH619.2 RT499.1 RT612.1
PCH_PRIM_EN: PR803.1 PR901.2 RH441.2 RH442.2 RZ509.1 UZ34.1(IN1)
PCH_PWROK: PR1114.2 PU1100.45(VR_RDY) RH424.1 UH1.AY42(PCH_PWROK)
PCH_RSMRST#: RE342.1 RZ1413.1 UE1.M5(GPIO055/PWM2/SHD_CS#/(RSMRST#)) UZ6.1(IN1)
PCH_RSMRST#_AND: RC75.1 RC124.1 RH215.2 UH1.BA47(RSMRST#) UZ6.4(OUT)
PCH_RTCRST#: CH40.2 CMOS1.2 JAPS1.9 RE94.2 RH200.2 UH1.BE47(RTCRST#)
PCH_RTCX1: RH43.2 RH44.1 UH1.BA49(RTCX1)
PCH_RTCX1_R: CH4.2 RH43.1 YH1.1
PCH_RTCX2: CH5.2 RH44.2 UH1.BA48(RTCX2) YH1.2
PCH_SMB_ALERT#: RH61.2 UH1.BE25(GPP_C2/SMBALERT#)
PCH_SPI_CLK: JSPI1.8 RH181.2 RH640.1 UH1.AW47(SPI0_CLK)
PCH_SPI_CLK_0_R: RH29.1 RH724.2 UC5.6(CLK)
PCH_SPI_CLK_1_R: RH28.1 RH728.2 UC6.6(SCLK)
PCH_SPI_CLK_2_R: RZ60.2 RZ63.2 UZ12.19(LCLK/SCLK)
PCH_SPI_CLK_R1: JSPI1.7 RH181.1 RH724.1 RH728.1 RZ60.1
PCH_SPI_CS#0: JSPI1.10 RH182.2 UH1.AY47(SPI0_CS0#)
PCH_SPI_CS#0_R1: JSPI1.9 RH37.1 RH182.1 RH352.1
PCH_SPI_CS#0_R2: RH37.2 UC5.1(CS#)
PCH_SPI_CS#0_R3: RH352.2 UC6.1(CS#)
PCH_SPI_CS#1: JSPI1.2 RH177.2 UH1.AW48(SPI0_CS1#)
PCH_SPI_CS#1_R1: JSPI1.1 RH177.1
PCH_SPI_CS#2: RZ61.1 UH1.AT40(SPI0_CS2#)
PCH_SPI_CS#2_R: RZ61.2 UZ12.20(LFRAME#/SCS#)
PCH_SPI_D0: JSPI1.4 RC128.1 RH178.2 RH600.2 UH1.AU41(SPI0_MOSI)
PCH_SPI_D0_0_R: RH723.2 UC5.5(DI)
PCH_SPI_D0_1_R: RH727.2 UC6.5(SI/SIO0)
PCH_SPI_D0_2_R: RZ59.2 UZ12.21(LAD1/MOSI)
PCH_SPI_D0_R1: JSPI1.3 RH178.1 RH723.1 RH727.1 RZ59.1
PCH_SPI_D1: JSPI1.6 RH179.2 UH1.BA45(SPI0_MISO)
PCH_SPI_D1_0_R: RH722.2 UC5.2(DO)
PCH_SPI_D1_1_R: RH726.2 UC6.2(SO/SIO1)
PCH_SPI_D1_2_R: RZ58.2 UZ12.24(LAD0/MISO)
PCH_SPI_D1_R1: JSPI1.5 RH179.1 RH722.1 RH726.1 RZ58.1
PCH_SPI_D2: JSPI1.12 RH30.2 RH180.2 RH183.2 UH1.AY48(SPI0_IO2)
PCH_SPI_D2_0_R: RH351.2 UC5.3(IO2)
PCH_SPI_D2_1_R: RH353.2 UC6.3(WP#/SIO2)
PCH_SPI_D2_R1: JSPI1.11 RH183.1 RH351.1 RH353.1
PCH_SPI_D2_XDP: RC127.2 RH180.1
PCH_SPI_D3: JSPI1.14 RH184.2 RH334.2 RH335.2 UH1.BA46(SPI0_IO3)
PCH_SPI_D3_0_R: RH725.2 UC5.7(IO3)
PCH_SPI_D3_1_R: RH729.2 UC6.7(RESET#/SIO3)
PCH_SPI_D3_R1: JSPI1.13 RH184.1 RH725.1 RH729.1
PCH_TBT_PERST#: RT500.1 RT615.2 RT616.2 RT621.1 RT644.2 UH1.AM48(GPP_F4/SATAXPCIE7/SATAGP7)
PCH_THERMTRIP#: RH75.1 UH1.AD3(THRMTRIP#)
PCH_XDP_CLK_DN: JXDP1.42 RH154.2
PCH_XDP_CLK_DN_R: RH154.1 UH1.Y3(CLKOUT_ITPXDP#)
PCH_XDP_CLK_DP: JXDP1.40 RH155.2
PCH_XDP_CLK_DP_R: RH155.1 UH1.Y4(CLKOUT_ITPXDP_P)
PCH_XDP_PRDY#: CC337.1 RC314.2 UH1.AM5(PRDY#)
PCH_XDP_PREQ#: CC338.1 RC315.2 UH1.AL2(PREQ#)
PCI_CLK_LPC1: RH99.1 UH1.BB34(GPP_A10/CLKOUT_LPC1)
PCIE_PRX_C_DTX_N5: CL2.1 UL1.39(PETN)
PCIE_PRX_C_DTX_N6: CR206.2 UR1.11(HSON)
PCIE_PRX_C_DTX_P5: CL1.1 UL1.38(PETP)
PCIE_PRX_C_DTX_P6: CR204.2 UR1.10(HSOP)
PCIE_PRX_C_TTX_N1: CT7.2 UT1.V22(PCIE_TX0_N)
PCIE_PRX_C_TTX_N2: CT9.2 UT1.P22(PCIE_TX1_N)
PCIE_PRX_C_TTX_N3: CT128.2 UT1.K22(PCIE_TX2_N)
PCIE_PRX_C_TTX_N4: CT130.2 UT1.F22(PCIE_TX3_N)
PCIE_PRX_C_TTX_P1: CT6.2 UT1.V23(PCIE_TX0_P)
PCIE_PRX_C_TTX_P2: CT8.2 UT1.P23(PCIE_TX1_P)
PCIE_PRX_C_TTX_P3: CT127.2 UT1.K23(PCIE_TX2_P)
PCIE_PRX_C_TTX_P4: CT129.2 UT1.F23(PCIE_TX3_P)
PCIE_PRX_DTX_N5: CL2.2 UH1.F20(PCIE5_RXN)
PCIE_PRX_DTX_N6: CR206.1 UH1.K21(PCIE6_RXN)
PCIE_PRX_DTX_N7: JNGFF1.35 UH1.L24(PCIE7_RXN)
PCIE_PRX_DTX_N8: JNGFF2.35 UH1.F24(PCIE8_RXN)
PCIE_PRX_DTX_N9: JNGFF3.5(PERN3) UH1.G36(PCIE9_RXN)
PCIE_PRX_DTX_N10: JNGFF3.17(PERN2) UH1.K37(PCIE10_RXN)
PCIE_PRX_DTX_N11: JNGFF3.29(PERN1) UH1.G38(PCIE11_RXN/SATA0A_RXN)
PCIE_PRX_DTX_N12: JNGFF3.43(PERP0/SATA-B-) UH1.H42(PCIE12_RXN/SATA1A_RXN)
PCIE_PRX_DTX_N17: JNGFF4.43(PERP0/SATA-B-) UH1.K43(PCIE17_RXN/SATA4_RXN)
PCIE_PRX_DTX_N18: JNGFF4.29(PERN1) UH1.P41(PCIE18_RXN/SATA5_RXN)
PCIE_PRX_DTX_N19: JNGFF4.17(PERN2) UH1.M44(PCIE19_RXN/SATA6_RXN)
PCIE_PRX_DTX_N20: JNGFF4.5(PERN3) UH1.R35(PCIE20_RXN/SATA7_RXN)
PCIE_PRX_DTX_N21: JNGFF5.41(PERN0/SATA-B+) UH1.T43(PCIE21_RXN)
PCIE_PRX_DTX_N22: JNGFF5.29(PERN1) UH1.U40(PCIE22_RXN)
PCIE_PRX_DTX_N23: JNGFF5.17(PERN2) UH1.W43(PCIE23_RXN)
PCIE_PRX_DTX_N24: JNGFF5.5(PERN3) UH1.Y40(PCIE24_RXN)
PCIE_PRX_DTX_P5: CL1.2 UH1.G20(PCIE5_RXP)
PCIE_PRX_DTX_P6: CR204.1 UH1.J21(PCIE6_RXP)
PCIE_PRX_DTX_P7: JNGFF1.33 UH1.J24(PCIE7_RXP)
PCIE_PRX_DTX_P8: JNGFF2.33 UH1.G24(PCIE8_RXP)
PCIE_PRX_DTX_P9: JNGFF3.7(PERP3) UH1.F36(PCIE9_RXP)
PCIE_PRX_DTX_P10: JNGFF3.19(PERP2) UH1.J37(PCIE10_RXP)
PCIE_PRX_DTX_P11: JNGFF3.31(PERP1) UH1.F39(PCIE11_RXP/SATA0A_RXP)
PCIE_PRX_DTX_P12: JNGFF3.41(PERN0/SATA-B+) UH1.J41(PCIE12_RXP/SATA_1A_RXP)
PCIE_PRX_DTX_P17: JNGFF4.41(PERN0/SATA-B+) UH1.K44(PCIE17_RXP/SATA4_RXP)
PCIE_PRX_DTX_P18: JNGFF4.31(PERP1) UH1.R40(PCIE18_RXP/SATA5_RXP)
PCIE_PRX_DTX_P19: JNGFF4.19(PERP2) UH1.N42(PCIE19_RXP/SATA6_RXP)
PCIE_PRX_DTX_P20: JNGFF4.7(PERP3) UH1.R37(PCIE20_RXP/SATA7_RXP)
PCIE_PRX_DTX_P21: JNGFF5.43(PERP0/SATA-B-) UH1.R44(PCIE21_RXP)
PCIE_PRX_DTX_P22: JNGFF5.31(PERP1) UH1.U41(PCIE22_RXP)
PCIE_PRX_DTX_P23: JNGFF5.19(PERP2) UH1.W44(PCIE23_RXP)
PCIE_PRX_DTX_P24: JNGFF5.7(PERP3) UH1.Y41(PCIE24_RXP)
PCIE_PRX_TTX_N1: CT7.1 UH1.G17(PCIE1_RXN/USB31_7_RXN)
PCIE_PRX_TTX_N2: CT9.1 UH1.R21(PCIE2_RXN/USB31_8_RXN)
PCIE_PRX_TTX_N3: CT128.1 UH1.K18(PCIE3_RXN/USB31_9_RXN)
PCIE_PRX_TTX_N4: CT130.1 UH1.N18(PCIE4_RXN/USB31_10_RXN)
PCIE_PRX_TTX_P1: CT6.1 UH1.F16(PCIE1_RXP/USB31_7_RXP)
PCIE_PRX_TTX_P2: CT8.1 UH1.P21(PCIE2_RXP/USB31_8_RXP)
PCIE_PRX_TTX_P3: CT127.1 UH1.J18(PCIE3_RXP/USB31_9_RXP)
PCIE_PRX_TTX_P4: CT129.1 UH1.R18(PCIE4_RXP/USB31_10_RXP)
PCIE_PTX_C_DRX_N5: CL6.2 UL1.42(PERN)
PCIE_PTX_C_DRX_N6: CR205.2 UR1.5(HSIN)
PCIE_PTX_C_DRX_N7: CZ13.2 JNGFF1.29
PCIE_PTX_C_DRX_N8: CZ10.2 JNGFF2.39
PCIE_PTX_C_DRX_N9: CN65.2 JNGFF3.11(PETN3)
PCIE_PTX_C_DRX_N10: CN67.2 JNGFF3.23(PETN2)
PCIE_PTX_C_DRX_N11: CN69.2 JNGFF3.35(PETN1)
PCIE_PTX_C_DRX_N12: CN71.2 JNGFF3.47(PETN0/SATA-A-)
PCIE_PTX_C_DRX_N17: CN186.2 JNGFF4.47(PETN0/SATA-A-)
PCIE_PTX_C_DRX_N18: CN184.2 JNGFF4.35(PETN1)
PCIE_PTX_C_DRX_N19: CN182.2 JNGFF4.23(PETN2)
PCIE_PTX_C_DRX_N20: CN180.2 JNGFF4.11(PETN3)
PCIE_PTX_C_DRX_N21: CN200.2 JNGFF5.47(PETN0/SATA-A-)
PCIE_PTX_C_DRX_N22: CN198.2 JNGFF5.35(PETN1)
PCIE_PTX_C_DRX_N23: CN196.2 JNGFF5.23(PETN2)
PCIE_PTX_C_DRX_N24: CN194.2 JNGFF5.11(PETN3)
PCIE_PTX_C_DRX_P5: CL5.2 UL1.41(PERP)
PCIE_PTX_C_DRX_P6: CR203.2 UR1.4(HSIP)
PCIE_PTX_C_DRX_P7: CZ12.2 JNGFF1.27
PCIE_PTX_C_DRX_P8: CZ11.2 JNGFF2.41
PCIE_PTX_C_DRX_P9: CN66.2 JNGFF3.13(PETP3)
PCIE_PTX_C_DRX_P10: CN68.2 JNGFF3.25(PETP2)
PCIE_PTX_C_DRX_P11: CN70.2 JNGFF3.37(PETP1)
PCIE_PTX_C_DRX_P12: CN72.2 JNGFF3.49(PETP0/SATA-A+)
PCIE_PTX_C_DRX_P17: CN187.2 JNGFF4.49(PETP0/SATA-A+)
PCIE_PTX_C_DRX_P18: CN185.2 JNGFF4.37(PETP1)
PCIE_PTX_C_DRX_P19: CN183.2 JNGFF4.25(PETP2)
PCIE_PTX_C_DRX_P20: CN181.2 JNGFF4.13(PETP3)
PCIE_PTX_C_DRX_P21: CN201.2 JNGFF5.49(PETP0/SATA-A+)
PCIE_PTX_C_DRX_P22: CN199.2 JNGFF5.37(PETP1)
PCIE_PTX_C_DRX_P23: CN197.2 JNGFF5.25(PETP2)
PCIE_PTX_C_DRX_P24: CN195.2 JNGFF5.13(PETP3)
PCIE_PTX_C_TRX_N1: CT3.1 UT1.Y22(PCIE_RX0_N)
PCIE_PTX_C_TRX_N2: CT5.1 UT1.T22(PCIE_RX1_N)
PCIE_PTX_C_TRX_N3: CT124.1 UT1.M22(PCIE_RX2_N)
PCIE_PTX_C_TRX_N4: CT126.1 UT1.H22(PCIE_RX3_N)
PCIE_PTX_C_TRX_P1: CT2.1 UT1.Y23(PCIE_RX0_P)
PCIE_PTX_C_TRX_P2: CT4.1 UT1.T23(PCIE_RX1_P)
PCIE_PTX_C_TRX_P3: CT123.1 UT1.M23(PCIE_RX2_P)
PCIE_PTX_C_TRX_P4: CT125.1 UT1.H23(PCIE_RX3_P)
PCIE_PTX_DRX_N5: CL6.1 UH1.B21(PCIE5_TXN)
PCIE_PTX_DRX_N6: CR205.1 UH1.D21(PCIE6_TXN)
PCIE_PTX_DRX_N7: CZ13.1 UH1.C23(PCIE7_TXN)
PCIE_PTX_DRX_N8: CZ10.1 UH1.B24(PCIE8_TXN)
PCIE_PTX_DRX_N9: CN65.1 UH1.C34(PCIE9_TXN)
PCIE_PTX_DRX_N10: CN67.1 UH1.C35(PCIE10_TXN)
PCIE_PTX_DRX_N11: CN69.1 UH1.B36(PCIE11_TXN/SATA0A_TXN)
PCIE_PTX_DRX_N12: CN71.1 UH1.D38(PCIE12_TXN/SATA1A_TXN)
PCIE_PTX_DRX_N17: CN186.1 UH1.A42(PCIE17_TXN/SATA4_TXN)
PCIE_PTX_DRX_N18: CN184.1 UH1.C42(PCIE18_TXN/SATA5_TXN)
PCIE_PTX_DRX_N19: CN182.1 UH1.C44(PCIE19_TXN/SATA6_TXN)
PCIE_PTX_DRX_N20: CN180.1 UH1.A44(PCIE20_TXN/SATA7_TXN)
PCIE_PTX_DRX_N21: CN200.1 UH1.G47(PCIE21_TXN)
PCIE_PTX_DRX_N22: CN198.1 UH1.H47(PCIE22_TXN)
PCIE_PTX_DRX_N23: CN196.1 UH1.G49(PCIE23_TXN)
PCIE_PTX_DRX_N24: CN194.1 UH1.G46(PCIE24_TXN)
PCIE_PTX_DRX_P5: CL5.1 UH1.A22(PCIE5_TXP)
PCIE_PTX_DRX_P6: CR203.1 UH1.C21(PCIE6_TXP)
PCIE_PTX_DRX_P7: CZ12.1 UH1.B23(PCIE7_TXP)
PCIE_PTX_DRX_P8: CZ11.1 UH1.C24(PCIE8_TXP)
PCIE_PTX_DRX_P9: CN66.1 UH1.D34(PCIE9_TXP)
PCIE_PTX_DRX_P10: CN68.1 UH1.B35(PCIE10_TXP)
PCIE_PTX_DRX_P11: CN70.1 UH1.C36(PCIE11_TXP/SATA0A_TXP)
PCIE_PTX_DRX_P12: CN72.1 UH1.E37(PCIE12_TXP/SATA1A_TXP)
PCIE_PTX_DRX_P17: CN187.1 UH1.B42(PCIE17_TXP/SATA4_TXP)
PCIE_PTX_DRX_P18: CN185.1 UH1.D42(PCIE18_TXP/SATA5_TXP)
PCIE_PTX_DRX_P19: CN183.1 UH1.D43(PCIE19_TXP/SATA6_TXP)
PCIE_PTX_DRX_P20: CN181.1 UH1.B44(PCIE20_TXP/SATA7_TXP)
PCIE_PTX_DRX_P21: CN201.1 UH1.F46(PCIE21_TXP)
PCIE_PTX_DRX_P22: CN199.1 UH1.H48(PCIE22_TXP)
PCIE_PTX_DRX_P23: CN197.1 UH1.G48(PCIE23_TXP)
PCIE_PTX_DRX_P24: CN195.1 UH1.G45(PCIE24_TXP)
PCIE_PTX_TRX_N1: CT3.2 UH1.A17(PCIE1_TXN/USB31_7_TXN)
PCIE_PTX_TRX_N2: CT5.2 UH1.B18(PCIE2_TXN/USB31_8_TXN)
PCIE_PTX_TRX_N3: CT124.2 UH1.B19(PCIE3_TXN/USB31_9_TXN)
PCIE_PTX_TRX_N4: CT126.2 UH1.D20(PCIE4_TXN/USB31_10_TXN)
PCIE_PTX_TRX_P1: CT2.2 UH1.B17(PCIE1_TXP/USB31_7_TXP)
PCIE_PTX_TRX_P2: CT4.2 UH1.C18(PCIE2_TXP/USB31_8_TXP)
PCIE_PTX_TRX_P3: CT123.2 UH1.C19(PCIE3_TXP/USB31_9_TXP)
PCIE_PTX_TRX_P4: CT125.2 UH1.C20(PCIE4_TXP/USB31_10_TXP)
PCIE_WAKE#: JDGFF1.E2 JNGFF1.47 JNGFF2.46 JNGFF3.54(PEWAKE#) JNGFF4.54(PEWAKE#) JNGFF5.54(PEWAKE#) RE274.1 RE275.1 RT448.1
PCIE_WAKE#_AR: RT441.2 RT613.1 RT622.2 UT1.Y2(PEWAKE#)
PCIE_WAKE#_AR_R: RT440.2 RT441.1 UT32.4(COM)
PCIE_WAKE#_R: RE35.1 RE275.2 UE1.N13(GPIO025/TIN0/NEM_INT/UART_CLK)
PCIECOMP: RH192.1 UH1.A13(PCIE_RCOMPP)
PCIECOMP#: RH192.2 UH1.B12(PCIE_RCOMPN)
PD#: CA31.2 DA8.2 RA18.2 RA48.2 RA50.2 UA1.2(PDB)
PECI_EC_R: RE60.1 UE1.K13(GPIO042/PECI_DAT/SB-TSI_DAT)
PEG_COMP: RC2.2 UC1.G2(PEG_RCOMP)
PEG_CRX_C_GTX_N0: CV428.1 JDGFF2.C8
PEG_CRX_C_GTX_N1: CV430.1 JDGFF2.B9
PEG_CRX_C_GTX_N2: CV432.1 JDGFF2.C5
PEG_CRX_C_GTX_N3: CV434.1 JDGFF2.B6
PEG_CRX_C_GTX_N4: CV436.1 JDGFF2.B3
PEG_CRX_C_GTX_N5: CV438.1 JDGFF2.A8
PEG_CRX_C_GTX_N6: CV440.1 JDGFF2.A5
PEG_CRX_C_GTX_N7: CV442.1 JDGFF2.A2
PEG_CRX_C_GTX_N8: CV444.1 JDGFF3.H8
PEG_CRX_C_GTX_N9: CV446.1 JDGFF3.H5
PEG_CRX_C_GTX_N10: CV448.1 JDGFF3.H2
PEG_CRX_C_GTX_N11: CV450.1 JDGFF3.G6
PEG_CRX_C_GTX_N12: CV452.1 JDGFF3.G3
PEG_CRX_C_GTX_N13: CV454.1 JDGFF3.G9
PEG_CRX_C_GTX_N14: CV456.1 JDGFF3.F5
PEG_CRX_C_GTX_N15: CV458.1 JDGFF3.F8
PEG_CRX_C_GTX_P0: CV427.1 JDGFF2.C7
PEG_CRX_C_GTX_P1: CV429.1 JDGFF2.B8
PEG_CRX_C_GTX_P2: CV431.1 JDGFF2.C4
PEG_CRX_C_GTX_P3: CV433.1 JDGFF2.B5
PEG_CRX_C_GTX_P4: CV435.1 JDGFF2.B2
PEG_CRX_C_GTX_P5: CV437.1 JDGFF2.A7
PEG_CRX_C_GTX_P6: CV439.1 JDGFF2.A4
PEG_CRX_C_GTX_P7: CV441.1 JDGFF2.A1
PEG_CRX_C_GTX_P8: CV443.1 JDGFF3.H7
PEG_CRX_C_GTX_P9: CV445.1 JDGFF3.H4
PEG_CRX_C_GTX_P10: CV447.1 JDGFF3.H1
PEG_CRX_C_GTX_P11: CV449.1 JDGFF3.G5
PEG_CRX_C_GTX_P12: CV451.1 JDGFF3.G2
PEG_CRX_C_GTX_P13: CV453.1 JDGFF3.G8
PEG_CRX_C_GTX_P14: CV455.1 JDGFF3.F4
PEG_CRX_C_GTX_P15: CV457.1 JDGFF3.F7
PEG_CRX_GTX_N0: CV428.2 UC1.E10(PEG_RXN_15)
PEG_CRX_GTX_N1: CV430.2 UC1.E11(PEG_RXN_14)
PEG_CRX_GTX_N2: CV432.2 UC1.E12(PEG_RXN_13)
PEG_CRX_GTX_N3: CV434.2 UC1.E13(PEG_RXN_12)
PEG_CRX_GTX_N4: CV436.2 UC1.E14(PEG_RXN_11)
PEG_CRX_GTX_N5: CV438.2 UC1.E15(PEG_RXN_10)
PEG_CRX_GTX_N6: CV440.2 UC1.E16(PEG_RXN_9)
PEG_CRX_GTX_N7: CV442.2 UC1.E17(PEG_RXN_8)
PEG_CRX_GTX_N8: CV444.2 UC1.F18(PEG_RXN_7)
PEG_CRX_GTX_N9: CV446.2 UC1.D19(PEG_RXN_6)
PEG_CRX_GTX_N10: CV448.2 UC1.F20(PEG_RXN_5)
PEG_CRX_GTX_N11: CV450.2 UC1.D21(PEG_RXN_4)
PEG_CRX_GTX_N12: CV452.2 UC1.F22(PEG_RXN_3)
PEG_CRX_GTX_N13: CV454.2 UC1.D23(PEG_RXN_2)
PEG_CRX_GTX_N14: CV456.2 UC1.F24(PEG_RXN_1)
PEG_CRX_GTX_N15: CV458.2 UC1.D25(PEG_RXN_0)
PEG_CRX_GTX_P0: CV427.2 UC1.F10(PEG_RXP_15)
PEG_CRX_GTX_P1: CV429.2 UC1.D11(PEG_RXP_14)
PEG_CRX_GTX_P2: CV431.2 UC1.F12(PEG_RXP_13)
PEG_CRX_GTX_P3: CV433.2 UC1.D13(PEG_RXP_12)
PEG_CRX_GTX_P4: CV435.2 UC1.F14(PEG_RXP_11)
PEG_CRX_GTX_P5: CV437.2 UC1.D15(PEG_RXP_10)
PEG_CRX_GTX_P6: CV439.2 UC1.F16(PEG_RXP_9)
PEG_CRX_GTX_P7: CV441.2 UC1.D17(PEG_RXP_8)
PEG_CRX_GTX_P8: CV443.2 UC1.E18(PEG_RXP_7)
PEG_CRX_GTX_P9: CV445.2 UC1.E19(PEG_RXP_6)
PEG_CRX_GTX_P10: CV447.2 UC1.E20(PEG_RXP_5)
PEG_CRX_GTX_P11: CV449.2 UC1.E21(PEG_RXP_4)
PEG_CRX_GTX_P12: CV451.2 UC1.E22(PEG_RXP_3)
PEG_CRX_GTX_P13: CV453.2 UC1.E23(PEG_RXP_2)
PEG_CRX_GTX_P14: CV455.2 UC1.E24(PEG_RXP_1)
PEG_CRX_GTX_P15: CV457.2 UC1.E25(PEG_RXP_0)
PEG_CTX_C_GRX_N0: CC65.2 JDGFF2.H8
PEG_CTX_C_GRX_N1: CC63.2 JDGFF2.H5
PEG_CTX_C_GRX_N2: CC61.2 JDGFF2.G6
PEG_CTX_C_GRX_N3: CC59.2 JDGFF2.H2
PEG_CTX_C_GRX_N4: CC57.2 JDGFF2.G9
PEG_CTX_C_GRX_N5: CC55.2 JDGFF2.G3
PEG_CTX_C_GRX_N6: CC53.2 JDGFF2.F5
PEG_CTX_C_GRX_N7: CC51.2 JDGFF2.F8
PEG_CTX_C_GRX_N8: CC49.2 JDGFF3.C8
PEG_CTX_C_GRX_N9: CC47.2 JDGFF3.C5
PEG_CTX_C_GRX_N10: CC45.2 JDGFF3.B3
PEG_CTX_C_GRX_N11: CC43.2 JDGFF3.B6
PEG_CTX_C_GRX_N12: CC41.2 JDGFF3.B9
PEG_CTX_C_GRX_N13: CC39.2 JDGFF3.A2
PEG_CTX_C_GRX_N14: CC37.2 JDGFF3.A8
PEG_CTX_C_GRX_N15: CC35.2 JDGFF3.A5
PEG_CTX_C_GRX_P0: CC64.2 JDGFF2.H7
PEG_CTX_C_GRX_P1: CC62.2 JDGFF2.H4
PEG_CTX_C_GRX_P2: CC60.2 JDGFF2.G5
PEG_CTX_C_GRX_P3: CC58.2 JDGFF2.H1
PEG_CTX_C_GRX_P4: CC56.2 JDGFF2.G8
PEG_CTX_C_GRX_P5: CC54.2 JDGFF2.G2
PEG_CTX_C_GRX_P6: CC52.2 JDGFF2.F4
PEG_CTX_C_GRX_P7: CC50.2 JDGFF2.F7
PEG_CTX_C_GRX_P8: CC48.2 JDGFF3.C7
PEG_CTX_C_GRX_P9: CC46.2 JDGFF3.C4
PEG_CTX_C_GRX_P10: CC44.2 JDGFF3.B2
PEG_CTX_C_GRX_P11: CC42.2 JDGFF3.B5
PEG_CTX_C_GRX_P12: CC40.2 JDGFF3.B8
PEG_CTX_C_GRX_P13: CC38.2 JDGFF3.A1
PEG_CTX_C_GRX_P14: CC36.2 JDGFF3.A7
PEG_CTX_C_GRX_P15: CC34.2 JDGFF3.A4
PEG_CTX_GRX_N0: CC65.1 UC1.B10(PEG_TXN_15)
PEG_CTX_GRX_N1: CC63.1 UC1.B11(PEG_TXN_14)
PEG_CTX_GRX_N2: CC61.1 UC1.B12(PEG_TXN_13)
PEG_CTX_GRX_N3: CC59.1 UC1.B13(PEG_TXN_12)
PEG_CTX_GRX_N4: CC57.1 UC1.B14(PEG_TXN_11)
PEG_CTX_GRX_N5: CC55.1 UC1.B15(PEG_TXN_10)
PEG_CTX_GRX_N6: CC53.1 UC1.B16(PEG_TXN_9)
PEG_CTX_GRX_N7: CC51.1 UC1.B17(PEG_TXN_8)
PEG_CTX_GRX_N8: CC49.1 UC1.C18(PEG_TXN_7)
PEG_CTX_GRX_N9: CC47.1 UC1.A19(PEG_TXN_6)
PEG_CTX_GRX_N10: CC45.1 UC1.C20(PEG_TXN_5)
PEG_CTX_GRX_N11: CC43.1 UC1.A21(PEG_TXN_4)
PEG_CTX_GRX_N12: CC41.1 UC1.C22(PEG_TXN_3)
PEG_CTX_GRX_N13: CC39.1 UC1.A23(PEG_TXN_2)
PEG_CTX_GRX_N14: CC37.1 UC1.C24(PEG_TXN_1)
PEG_CTX_GRX_N15: CC35.1 UC1.A25(PEG_TXN_0)
PEG_CTX_GRX_P0: CC64.1 UC1.C10(PEG_TXP_15)
PEG_CTX_GRX_P1: CC62.1 UC1.A11(PEG_TXP_14)
PEG_CTX_GRX_P2: CC60.1 UC1.C12(PEG_TXP_13)
PEG_CTX_GRX_P3: CC58.1 UC1.A13(PEG_TXP_12)
PEG_CTX_GRX_P4: CC56.1 UC1.C14(PEG_TXP_11)
PEG_CTX_GRX_P5: CC54.1 UC1.A15(PEG_TXP_10)
PEG_CTX_GRX_P6: CC52.1 UC1.C16(PEG_TXP_9)
PEG_CTX_GRX_P7: CC50.1 UC1.A17(PEG_TXP_8)
PEG_CTX_GRX_P8: CC48.1 UC1.B18(PEG_TXP_7)
PEG_CTX_GRX_P9: CC46.1 UC1.B19(PEG_TXP_6)
PEG_CTX_GRX_P10: CC44.1 UC1.B20(PEG_TXP_5)
PEG_CTX_GRX_P11: CC42.1 UC1.B21(PEG_TXP_4)
PEG_CTX_GRX_P12: CC40.1 UC1.B22(PEG_TXP_3)
PEG_CTX_GRX_P13: CC38.1 UC1.B23(PEG_TXP_2)
PEG_CTX_GRX_P14: CC36.1 UC1.B24(PEG_TXP_1)
PEG_CTX_GRX_P15: CC34.1 UC1.B25(PEG_TXP_0)
PG_1.0V: PR800.1 PR812.2 PU800.1(PGOOD)
PG_1.8V: PR900.2 PR906.2 PU900.2(PG)
PG_2.5V: PR400.2 PU400.2(PG)
PG_IO: PR300.2 PU300.13(PG)
PGOOD_3V: PR102.1 PR107.2 PU100.9(PG)
PGOOD_3VR: PR508.1 PR515.2 PU501.9(PG)
PGOOD_5V: PR103.1 PR110.2 PU101.9(PG)
PGOOD_5VR: PR500.2 PR509.1 PU500.9(PG)
PLTRST_CPU#: UC1.BP35(RESET#) UH1.AG5(PLTRST_CPU#)
PLTRST_GPU#: RH625.1 UV63.2(IN2)
PLTRST_LAN#: RH624.1 UL1.36(PE_RST_N)
PLTRST_MMI#: RH626.2 UR1.1(PERST#)
PLTRST_TPM#: RH622.2 RH623.1 UZ12.17(LRESET#/SPI_RST#/SRESET#)
PM_LANPHY_ENABLE: RL7.1 UH1.BF41(GPD11/LANPHYPC)
PME#: T178.1 UH1.BE36(GPP_A11/PME#/SD_VDD2_PWR_EN#)
POA_WAKE#_R: JUSH1.23 RZ364.2
POWER_SW#_MB: CE10.1 CZ541.1 JAPS1.11 JPB1.1 PWRSW1.1 RE33.2 SW3.2 SW3.4
POWER_SW_IN#: CE12.1 QZ22.3(EMITTER) RE31.2 RE33.1 UE1.D5(GPIO163/VCI_IN0#)
PRIM_PWRGD: PR812.1 PR906.1 UE1.L7(GPIO227/SHD_IO2)
PROCHOT#: CC324.1 JIO1.28 PR718.1 PR1103.2 PR1110.2 RC83.2 RC84.1 RE288.2 UV69.2(A)
PROCHOT#_R: PR718.2 PU700.10(PROCHOT#)
PROCHOT#_R1: RE288.1 UE1.H13(GPIO160/PWM11/PROCHOT#)
PS_ID: JIO1.13 UE1.J8(GPIO056/PWM3/SHD_CLK)
PSID_DISABLE#: JIO1.10 UE1.D7(GPIO004/SMB00_CLK/SPI0_MOSI)
PTP_DISABLE#: RE748.1 RZ1484.2 UE1.N12(GPIO026/TIN1)
PWM1_1PH/ICCMAX1: PR1120.1 PU1100.44(PWM_1PH/ICCMAX_1PH) PU1800.1(PWM)
PWM1_2PH/ICCMAX2: PR1152.1 PU1100.23(PWM1_2PH/ICCMAX_2PH) PU1700.1(PWM)
PWM1_4PH/ICCMAX4: PR1155.1 PU1100.18(PWM1_4PH/ICCMAX_4PH) PU1200.1(PWM)
PWM2_2PH/ROSC1: PR1171.1 PU1100.22(PWM2_2PH/ROSC_1PH)
PWM2_4PH/ADDR: PR1156.1 PU1100.19(PWM2_4PH/ADDR) PU1201.1(PWM)
PWM3_4PH/VBOOT: PR1157.1 PU1100.20(PWM3_4PH/VBOOT) PU1202.1(PWM)
PWM4_4PH/ROSCM: PR1158.1 PU1100.21(PWM4_4PH/ROSC_MPH) PU1203.1(PWM)
PWM_FAN1: JFAN1.2 RZ505.2 UE1.L10(GPIO053/PWM0/GPWM0)
PWM_FAN2: JFAN2.2 RZ504.2 UE1.L11(GPIO054/PWM1/GPWM1)
REFCLK_CNV: RH110.2 RZ371.2 UH1.R6(CLKIN_XTAL)
REG_OUT: LR1.1 UR1.37(REG_OUT_1) UR1.38(REG_OUT_2)
REM_DIODE1_N: CE24.1 CE35.2 CE339.1 QE3.3(EMITTER) QE26.1(COLLECTOR) QE26.2(BASE) UE1.A8(DN1_DP1A)
REM_DIODE1_P: CE24.2 CE35.1 CE339.2 QE3.1(COLLECTOR) QE3.2(BASE) QE26.3(EMITTER) UE1.A7(DP1_DN1A)
REM_DIODE2_N: CE26.1 CE46.2 QE7.1(COLLECTOR) QE7.2(BASE) UE1.A10(DN2_DP2A)
REM_DIODE2_P: CE26.2 CE46.1 QE7.3(EMITTER) UE1.A9(DP2_DN2A)
REM_DIODE3_N: CE270.1 CE272.2 QE104.3(EMITTER) UE1.B9(DN3_DP3A)
REM_DIODE3_P: CE270.2 CE272.1 QE104.1(COLLECTOR) QE104.2(BASE) UE1.B8(DP3_DN3A)
REM_DIODE4_N: CE27.1 CE39.2 QE6.3(EMITTER) UE1.A11(DN4_DP4A)
REM_DIODE4_P: CE27.2 CE39.1 QE6.1(COLLECTOR) QE6.2(BASE) UE1.B10(DP4_DN4A)
RES_BIAS: RL13.1 UL1.12(RBIAS)
RESET_IN#: RE362.1 UE1.C1(GPIO024/GPTP-IN2)
RF_+1VSP: PR804.1 PU800.5(TST)
RING2: CA4.2 LA10.1 RA5.2 UA1.30(MIC2-L/RING2)
RING2_R: CA13.1 DA3.2 JHP1.3 LA10.2
RJ45_MDIN0: JLOM1.2(PR1-) TL1.23(TX1-)
RJ45_MDIN1: JLOM1.6(PR2-) TL1.19(TX2-)
RJ45_MDIN2: JLOM1.5(PR3-) TL1.17(TX3-)
RJ45_MDIN3: JLOM1.8(PR4-) TL1.13(TX4-)
RJ45_MDIP0: JLOM1.1(PR1+) TL1.24(TX1+)
RJ45_MDIP1: JLOM1.3(PR2+) TL1.20(TX2+)
RJ45_MDIP2: JLOM1.4(PR3+) TL1.18(TX3+)
RJ45_MDIP3: JLOM1.7(PR4+) TL1.14(TX4+)
RREF: RR205.1 UR1.44(RREF)
RTC_DET#: PQ26.1(D) RH734.2 UH1.BF18(GPP_D3/SPI1_MOSI/SBK3_BK3)
RTCRST_ON: QE12.2(G) RE93.1 UE1.F11(GPIO122/BCM0_DAT/PVT_IO1)
RTCRST_ON_POWER: RE747.2 UE1.B13(GPIO127/A20M/UART0_CTS#)
RTCRST_ON_R: CE65.1 DE2.2 QE17.2(G) RE543.1
RTCRST_ON_R1: CE64.1 DE2.1 QE15.2(G) RE541.2 RE543.2 RE747.1
RTD3_CIO_PWR_EN: RH730.2 RT392.2 UH1.AE43(GPP_H16/SML4CLK)
RTD3_CIO_PWR_EN_R: RT372.1 RT392.1 RT614.1 RT643.1 UT1.T5(RTD3_PWR_EN)
RTD3_SELECT: RT447.2 UE12.21(GPE5) UT32.6(IN)
RTD3_USB_PWR_EN: RT26.1 RT591.1 UT1.V5(USB_FORCE_PWR)
RUN_ON: PR304.1 QE2.2(G) RE280.2 RE292.1 RZ510.1 RZ549.1 UE5.4(OUT) UR4.4(ON) UZ35.2(IN2) UZ43.3(ON) UZ45.3(ON) UZ60.2(IN2)
RUN_ON#: QE2.5(G) QE2.6(D) QZ21.2(G) RE68.1
RUN_ON_EC: RE292.2 RE738.2 UE1.E8(GPIO045) UE5.2(IN2)
RUN_ON_R: RZ510.2 UZ40.3(ON1) UZ40.5(ON2)
RUNPWROK: QE2.3(D) RE67.1 UE1.G3(GPIO057/VCC_PWRGD)
S3_1.2V: PR210.2 PU200.7(S3)
S5_1.2V: PC213.1 PR208.2 PU200.8(S5)
SA_SW: PC1809.1 PL1800.1 PU1800.11(SW1) PU1800.12(SW2)
SATAGP0: RH344.2 UH1.AH41(GPP_E0/SATAXPCIE0/SATAGP0)
SATAGP5: RH325.2 UH1.AM43(GPP_F2/SATAXPCIE5/SATAGP5)
SATAGP6: RH326.2 UH1.AM47(GPP_F3/SATAXPCIE6/SATAGP6)
SATALED#: RH380.2 RN216.2 RN217.2 RN218.2 UH1.AK48(GPP_E8/SATA_LED#)
SBIOS_TX: RE306.1 UH1.BB24(GPP_C9/UART0A_TXD)
SCK: UR1.17(SCK) UR3.6(CLK)
SCS: RR236.1 RR239.2 UR1.34(SCS) UR3.1(CS#)
SD_1_CD#: JSD1.17(CARD DETECT) UR1.47(SD_CD#)
SD_1_CLK: CR200.1 JSD1.5(CLK) RR213.2
SD_1_CLK_R: RR213.1 UR1.23(SD_CLK)
SD_1_CMD: JSD1.2(CMD) RR230.2
SD_1_CMD_R: RR230.1 UR1.25(SD_CMD)
SD_1_D0: JSD1.7(DAT0/RCLK+) RR234.1
SD_1_D0_R: RR234.2 UR1.22(SD_D0/RCLK_P)
SD_1_D1: JSD1.8(DAT1/RCLK-) RR233.1
SD_1_D1_R: RR233.2 UR1.21(SD_D1/RCLK_N)
SD_1_D2: JSD1.9(DAT2) RR228.2
SD_1_D2_R: RR228.1 UR1.27(SD_D2)
SD_1_D3: JSD1.1(CD/DAT3) RR229.2
SD_1_D3_R: RR229.1 UR1.26(SD_D3)
SD_1_N0: JSD1.12(D0-) UR1.32(LN0_N)
SD_1_N1: JSD1.15(D1-) UR1.29(LN1_N)
SD_1_P0: JSD1.11(D0+) UR1.33(LN0_P)
SD_1_P1: JSD1.16(D1+) UR1.28(LN1_P)
SD_RCOMP_1P8: RH611.2 UH1.BE5(SD_1P8_RCOMP)
SD_RCOMP_3P3: RH610.2 UH1.BE4(SD_3P3_RCOMP)
SDVDD1: CR224.2 CR225.2 JSD1.4(VDD/VDD1) UR1.19(SDVDD1)
SDVDD2: CR227.2 CR228.2 JSD1.14(VDD2) UR1.20(SDVDD2)
SDWP: QR1.1(D) UR1.43(SD_WP)
SDWP_Q: JSD1.18(WRITE PROTEC) QR1.3(S)
SIM_DET: JNGFF2.58 RZ522.2
SIM_DET_R: JSIM1.2(NC1) RZ522.1
SIO_EXT_SCI#: RC561.1 RH339.2 UH1.AU26(GPP_B20/GSPI1_CLK)
SIO_EXT_SMI#: RH310.2 UH1.AL47(GPP_E3/CPU_GP0)
SIO_EXT_WAKE#: RE703.1 RH309.2 UH1.AU24(GPP_C12/UART1_RXD/ISH_UART1_RXD)
SIO_PWRBTN#: CC269.1 JXDP1.41 RC241.2 UE1.K11(GPIO113/PS2_DAT1A) UH1.BE46(GPD3/PWRBTN#)
SIO_RCIN#: T317.1 UH1.BE39(GPP_A0/RCIN#/ESPI_ALERT1#)
SIO_SLP_A#: CH343.1 JAPS1.6 RE746.2 RH638.1 UH1.BE40(GPD6/SLP_A#)
SIO_SLP_LAN#: CH346.1 R128.1 RE743.2 RH204.1 RH631.1 UH1.BF40(SLP_LAN#) UZ7.3(ON)
SIO_SLP_S0#: JAPS1.15 RH446.1 RZ112.1 RZ362.2 RZ363.1 UH1.BC28(GPP_B12/SLP_S0#)
SIO_SLP_S3#: CH341.1 JAPS1.2 QE11.2(G) RE280.1 RH634.1 RT593.1 UE3.2(IN2) UE5.1(IN1) UH1.BF42(GPD4/SLP_S3#) UT1.U1(SLP_S3#)
SIO_SLP_S4#: CH342.1 JAPS1.5 PR208.1 PR401.2 RH635.1 UH1.BE42(GPD5/SLP_S4#) UZ21.4(ON) UZ34.2(IN2)
SIO_SLP_S5#: CH347.1 JAPS1.4 RH632.1 UH1.BC42(GPD10/SLP_S5#)
SIO_SLP_SUS#: CH345.1 RE349.1 RH441.1 RH639.1 UH1.BD39(SLP_SUS#)
SIO_SLP_SUS#_R: RE349.2 RE561.1 UE1.N4(GPIO230)
SIO_SLP_WLAN#: CH344.1 QZ15.1(D) RE569.1 RH629.1 UH1.BD42(GPD9/SLP_WLAN#)
SIO_SLP_WLAN#_Q: DZ9.3 QZ15.3(S) RZ71.1 RZ1385.2
SKL_CNL#: RC171.2 UC1.BN1(PROC_SELECT#)
SLEEVE: CA1.2 LA11.1 RA6.2 UA1.31(MIC2-R/SLEEVE)
SLEEVE_R: CA12.1 DA3.3 JHP1.4 LA11.2
SLOT3_DEVSLP: JNGFF3.38(DEVSLP) RN37.1 UH1.AH35(GPP_E5/SATA_DEVSLP1)
SLOT3_SSD_PWR_EN: RZ539.1 UE1.G5(GPIO213/ADC11) UZ9.3(ON1)
SLOT4_DEVSLP: JNGFF4.38(DEVSLP) RN202.1 UH1.AR47(GPP_F6/SATA_DEVSLP4)
SLOT4_SSD_PWR_EN: RZ537.1 UE1.K3(GPIO207/ADC07) UZ58.3(ON)
SLOT5_SSD_PWR_EN: RZ538.1 UE12.22(GPE6) UZ9.5(ON2)
SLP_WLAN#_GATE: QZ15.2(G) RE552.2 RE570.1 RZ375.2
SLP_WLAN#_GATE_R: RE569.2 RE570.2 UE1.D9(GPIO133/PWM9)
SMART_SPK_DET0#: JSPK1.5 RA224.2 UH1.AV13(GPP_G7/SD_WP)
SML0_SMBCLK: CC318.1 RH67.2 RT641.1 UH1.BF25(GPP_C3/SML0CLK) UL1.28(SMB_CLK)
SML0_SMBDATA: RH77.2 RT642.1 UH1.BE24(GPP_C4/SML0DATA) UL1.31(SMB_DATA)
SML1_SMBCLK: CC319.1 RH80.2 UE1.D8(GPIO010/SMB03_CLK/PS2_DAT0B) UH1.BF27(GPP_C6/SML1CLK)
SML1_SMBDATA: RH81.2 UE1.E11(GPIO007/SMB03_DATA/PS2_CLK0B) UH1.BE27(GPP_C7/SML1DATA)
SNUB_1.2V: PC210.1 PR202.2
SNUB_1V: PC808.1 PR805.2
SNUB_3V: PC109.1 PR100.2
SNUB_5V: PC126.1 PR112.2
SNUB_5VR: PC512.1 PR502.2
SNUB_CHG: PC717.1 PR722.2
SNUB_IO: PC301.1 PR301.2
SPKR: RA12.2 RH86.2 UH1.AW29(GPP_B14/SPKR)
SPKR_R: CA27.1 CA228.1 RA12.1 RA225.1
SRN_1: PR728.2 PU700.19(SRN)
SRP_1: PR727.2 PU700.20(SRP)
SRTCRST#: CH41.2 RH201.2 UH1.BD46(SRTCRST#)
SSD_SCP#: RN219.2 RN220.2 RN221.2 UE1.L6(GPIO224/GPTP-IN4/SHD_IO1)
SUNB_3VR: PC527.1 PR511.2
SUSACK#: RE745.1 RH443.2
SUSACK#_R: RH327.1 RH443.1 UH1.BE35(GPP_A15/SUSACK#)
SUSCLK: JNGFF2.60 RH83.1 RN99.2 RN205.2 RN207.2 RZ56.2 UH1.BE45(GPD8/SUSCLK)
SUSCLK_R3: JNGFF3.60(SUSCLK(32KHZ)) RN99.1
SUSCLK_R4: JNGFF4.68(SUSCLK(32KHZ)) RN205.1
SUSCLK_R5: JNGFF5.60(SUSCLK(32KHZ)) RN207.1
SW1_2PH: PL1700.2 PR1145.2 PR1160.2
SW1_4PH: PL1202.2 PR1143.1 PR1154.1
SW1_CET: CV818.2 UV64.47(CEXT)
SW1_EDP_AUXN: CV2.1 RV840.2 UV64.31(OUT_AUXN_SDA)
SW1_EDP_AUXN_C: CV2.2 JEDP1.29
SW1_EDP_AUXP: CV1.1 RV842.2 UV64.32(OUT_AUXP_SCL)
SW1_EDP_AUXP_C: CV1.2 JEDP1.28
SW1_EDP_HPD: JEDP1.25 RV7.2 UV64.44(OUT_HPD)
SW1_EDP_N0: CV847.1 UV64.45(OUT_D0N)
SW1_EDP_N0_C: CV847.2 JEDP1.38
SW1_EDP_N1: CV845.1 UV64.42(OUT_D1N)
SW1_EDP_N1_C: CV845.2 JEDP1.36
SW1_EDP_N2: CV5.1 UV64.39(OUT2_D2N)
SW1_EDP_N2_C: CV5.2 JEDP1.34
SW1_EDP_N3: CV3.1 UV64.36(OUT_D3N)
SW1_EDP_N3_C: CV3.2 JEDP1.32
SW1_EDP_P0: CV848.1 UV64.46(OUT_D0P)
SW1_EDP_P0_C: CV848.2 JEDP1.39
SW1_EDP_P1: CV846.1 UV64.43(OUT_D1P)
SW1_EDP_P1_C: CV846.2 JEDP1.37
SW1_EDP_P2: CV6.1 UV64.40(OUT2_D2P)
SW1_EDP_P2_C: CV6.2 JEDP1.35
SW1_EDP_P3: CV4.1 UV64.37(OUT_D3P)
SW1_EDP_P3_C: CV4.2 JEDP1.33
SW1_REXT: RV835.2 UV64.34(REXT)
SW2_4PH: PL1203.2 PR1146.1 PR1161.1
SW2_DP2_1_AUXN: RV809.1 UV8.27(OUT1_AUXN_SDA)
SW2_DP2_1_AUXN_C: RV809.2 UV67.59(IN2_AUXN)
SW2_DP2_1_AUXP: RV808.1 UV8.26(OUT1_AUXP_SCL)
SW2_DP2_1_AUXP_C: RV808.2 UV67.60(IN2_AUXP)
SW2_DP2_1_HPD: RV903.1 UV8.48(OUT1_HPD) UV67.19(IN2_HPD)
SW2_DP2_1_N0: CV892.2 UV8.49(OUT1_D0N)
SW2_DP2_1_N0_C: CV892.1 UV67.15(IN2_D0N)
SW2_DP2_1_N1: CV894.2 UV8.46(OUT1_D1N)
SW2_DP2_1_N1_C: CV894.1 UV67.18(IN2_D1N)
SW2_DP2_1_N2: CV896.2 UV8.44(OUT1_D2N)
SW2_DP2_1_N2_C: CV896.1 UV67.21(IN2_D2N)
SW2_DP2_1_N3: CV898.2 UV8.41(OUT1_D3N)
SW2_DP2_1_N3_C: CV898.1 UV67.23(IN2_D3N)
SW2_DP2_1_P0: CV891.2 UV8.50(OUT1_D0P)
SW2_DP2_1_P0_C: CV891.1 UV67.14(IN2_D0P)
SW2_DP2_1_P1: CV893.2 UV8.47(OUT1_D1P)
SW2_DP2_1_P1_C: CV893.1 UV67.17(IN2_D1P)
SW2_DP2_1_P2: CV895.2 UV8.45(OUT1_D2P)
SW2_DP2_1_P2_C: CV895.1 UV67.20(IN2_D2P)
SW2_DP2_1_P3: CV897.2 UV8.42(OUT1_D3P)
SW2_DP2_1_P3_C: CV897.1 UV67.22(IN2_D3P)
SW2_DP2_2_AUXN: JDGFF4.F5 UV8.29(OUT2_AUXN_SDA)
SW2_DP2_2_AUXP: JDGFF4.F4 UV8.28(OUT2_AUXP_SCL)
SW2_DP2_2_HPD: JDGFF4.C2 UV8.38(OUT2_HPD)
SW2_DP2_2_N0: JDGFF4.B9 UV8.39(OUT2_D0N)
SW2_DP2_2_N1: JDGFF4.C5 UV8.36(OUT2_D1N)
SW2_DP2_2_N2: JDGFF4.C8 UV8.34(OUT2_D2N)
SW2_DP2_2_N3: JDGFF4.F8 UV8.31(OUT2_D3N)
SW2_DP2_2_P0: JDGFF4.B8 UV8.40(OUT2_D0P)
SW2_DP2_2_P1: JDGFF4.C4 UV8.37(OUT2_D1P)
SW2_DP2_2_P2: JDGFF4.C7 UV8.35(OUT2_D2P)
SW2_DP2_2_P3: JDGFF4.F7 UV8.32(OUT2_D3P)
SW3_4PH: PL1204.2 PR1148.1 PR1163.1
SW3_DP1_AUXN: CT19.2 RV855.1 UV66.57(OUT_AUXN_SDA)
SW3_DP1_AUXN_C: CT19.1 UT1.N2(DPSNK1_AUX_N)
SW3_DP1_AUXP: CT18.2 RV890.1 UV66.58(OUT_AUXP_SCL)
SW3_DP1_AUXP_C: CT18.1 UT1.N1(DPSNK1_AUX_P)
SW3_DP1_HPD: UT1.AA2(DPSNK1_HPD) UV66.49(OUT_HPD)
SW3_DP1_N0: CT11.2 UV66.53(OUT_D0N)
SW3_DP1_N0_C: CT11.1 UT1.AB7(DPSNK1_ML0_N)
SW3_DP1_N1: CT13.2 UV66.50(OUT_D1N)
SW3_DP1_N1_C: CT13.1 UT1.AC9(DPSNK1_ML1_N)
SW3_DP1_N2: CT15.2 UV66.47(OUT_D2N)
SW3_DP1_N2_C: CT15.1 UT1.AB11(DPSNK1_ML2_N)
SW3_DP1_N3: CT17.2 UV66.44(OUT_D3N)
SW3_DP1_N3_C: CT17.1 UT1.AC13(DPSNK1_ML3_N)
SW3_DP1_P0: CT10.2 UV66.54(OUT_D0P)
SW3_DP1_P0_C: CT10.1 UT1.AC7(DPSNK1_ML0_P)
SW3_DP1_P1: CT12.2 UV66.51(OUT_D1P)
SW3_DP1_P1_C: CT12.1 UT1.AB9(DPSNK1_ML1_P)
SW3_DP1_P2: CT14.2 UV66.48(OUT_D2P)
SW3_DP1_P2_C: CT14.1 UT1.AC11(DPSNK1_ML2_P)
SW3_DP1_P3: CT16.2 UV66.45(OUT_D3P)
SW3_DP1_P3_C: CT16.1 UT1.AB13(DPSNK1_ML3_P)
SW4_4PH: PL1205.2 PR1149.1 PR1164.1
SW4_DP2_AUXN: CT184.2 RV869.1 UV67.57(OUT_AUXN_SDA)
SW4_DP2_AUXN_C: CT184.1 UT1.P2(DPSNK2_AUX_N)
SW4_DP2_AUXP: CT178.2 RV889.1 UV67.58(OUT_AUXP_SCL)
SW4_DP2_AUXP_C: CT178.1 UT1.P1(DPSNK2_AUX_P)
SW4_DP2_HPD: UT1.Y4(DPSNK2_HPD) UV67.49(OUT_HPD)
SW4_DP2_N0: CT187.2 UV67.53(OUT_D0N)
SW4_DP2_N0_C: CT187.1 UT1.B5(DPSNK2_ML0_N)
SW4_DP2_N1: CT180.2 UV67.50(OUT_D1N)
SW4_DP2_N1_C: CT180.1 UT1.A3(DPSNK2_ML1_N)
SW4_DP2_N2: CT179.2 UV67.47(OUT_D2N)
SW4_DP2_N2_C: CT179.1 UT1.C1(DPSNK2_ML2_N)
SW4_DP2_N3: CT181.2 UV67.44(OUT_D3N)
SW4_DP2_N3_C: CT181.1 UT1.E1(DPSNK2_ML3_N)
SW4_DP2_P0: CT186.2 UV67.54(OUT_D0P)
SW4_DP2_P0_C: CT186.1 UT1.A5(DPSNK2_ML0_P)
SW4_DP2_P1: CT183.2 UV67.51(OUT_D1P)
SW4_DP2_P1_C: CT183.1 UT1.B3(DPSNK2_ML1_P)
SW4_DP2_P2: CT185.2 UV67.48(OUT_D2P)
SW4_DP2_P2_C: CT185.1 UT1.C2(DPSNK2_ML2_P)
SW4_DP2_P3: CT182.2 UV67.45(OUT_D3P)
SW4_DP2_P3_C: CT182.1 UT1.E2(DPSNK2_ML3_P)
SW_1PH: PL1800.2 PR1102.2
SW_TBT_A_USB20_N1: RT121.1 UT5.A2(D-_T_P1)
SW_TBT_A_USB20_N1_R: DT7.4 DT7.7 JUSBC1.B7(DN2) RT121.2
SW_TBT_A_USB20_N2: RT122.2 UT5.C1(D-_B_P1)
SW_TBT_A_USB20_N2_R: DT8.2 DT8.8 JUSBC1.A7(DN1) RT122.1
SW_TBT_A_USB20_P1: RT120.1 UT5.A1(D+_T_P1)
SW_TBT_A_USB20_P1_R: DT7.2 DT7.8 JUSBC1.B6(DP2) RT120.2
SW_TBT_A_USB20_P2: RT123.2 UT5.B1(D+_B_P1)
SW_TBT_A_USB20_P2_R: DT8.4 DT8.7 JUSBC1.A6(DP1) RT123.1
SW_TBT_B_USB20_N1: RT540.1 UT5.H1(D-_T_P2)
SW_TBT_B_USB20_N1_R: DT11.4 DT11.7 JUSBC1.1B7(DN2) RT540.2
SW_TBT_B_USB20_N2: RT539.2 UT5.L1(D-_B_P2)
SW_TBT_B_USB20_N2_R: DT12.2 DT12.8 JUSBC1.1A7(DN1) RT539.1
SW_TBT_B_USB20_P1: RT538.1 UT5.G1(D+_T_P2)
SW_TBT_B_USB20_P1_R: DT11.2 DT11.8 JUSBC1.1B6(DP2) RT538.2
SW_TBT_B_USB20_P2: RT541.2 UT5.K1(D+_B_P2)
SW_TBT_B_USB20_P2_R: DT12.4 DT12.7 JUSBC1.1A6(DP1) RT541.1
SYS_PWROK: RC129.1 RE56.1 RE548.1 RE548.2 RH199.1 UE1.G4(GPIO106/PWROK) UH1.AU3(SYS_PWROK)
SYS_PWROK_R: CC33.1 JXDP1.47 RC128.2 RC129.2 RC133.2
SYS_RESET#: CC302.1 JAPS1.13 RH66.1 UC3.4(OUT Y) UH1.AU2(SYS_RESET#)
SYSTEM_ID: CE47.1 RE300.2 UE1.J10(GPIO034/RC_ID1/SPI0_CLK)
TACH_FAN1: JFAN1.3 RZ508.2 UE1.E3(GPIO050/FAN_TACH0/GTACH0)
TACH_FAN2: JFAN2.3 RZ507.2 UE1.D1(GPIO051/FAN_TACH1/GTACH1)
TB_STAT#: PQ704.2(G2) PR725.1 PU700.16(TB_STAT#) UE12.5(GPA5)
TBT_A_SBU1: RT387.2 RT606.2 UT1.H4(ASBU1)
TBT_A_SBU2: RT388.2 RT607.2 UT1.J4(ASBU2)
TBT_A_TRX_C_DTX_N1: CT392.1 JUSBC1.A10(SSRXN2) RT631.1
TBT_A_TRX_C_DTX_N2: CT390.2 JUSBC1.B10(SSRXN1) RT488.1
TBT_A_TRX_C_DTX_P1: CT393.1 JUSBC1.A11(SSRXP2) RT504.1
TBT_A_TRX_C_DTX_P2: CT391.2 JUSBC1.B11(SSRXP1) RT489.1
TBT_A_TRX_DTX_N1: CT392.2 DT14.1 RT594.1
TBT_A_TRX_DTX_N1_R: RT594.2 UT1.A21(ASSRXN1)
TBT_A_TRX_DTX_N2: CT390.1 DT9.1 RT596.1
TBT_A_TRX_DTX_N2_R: RT596.2 UT1.B15(ASSRXN2)
TBT_A_TRX_DTX_P1: CT393.2 DT13.1 RT595.1
TBT_A_TRX_DTX_P1_R: RT595.2 UT1.B21(ASSRXP1)
TBT_A_TRX_DTX_P2: CT391.1 DT10.1 RT597.1
TBT_A_TRX_DTX_P2_R: RT597.2 UT1.A15(ASSRXP2)
TBT_A_TTX_C_DRX_N1: CT96.2 JUSBC1.B3(SSTXN2) RT490.1
TBT_A_TTX_C_DRX_N2: CT98.2 JUSBC1.A3(SSTXN1) RT219.1
TBT_A_TTX_C_DRX_P1: CT95.2 JUSBC1.B2(SSTXP2) RT491.1
TBT_A_TTX_C_DRX_P2: CT97.2 JUSBC1.A2(SSTXP1) RT632.1
TBT_A_TTX_DRX_N1: CT96.1 DT6.1 RT624.1
TBT_A_TTX_DRX_N1_R: RT624.2 UT1.B19(ASSTXN1)
TBT_A_TTX_DRX_N2: CT98.1 DT18.1 RT626.1
TBT_A_TTX_DRX_N2_R: RT626.2 UT1.B17(ASSTXN2)
TBT_A_TTX_DRX_P1: CT95.1 DT5.1 RT623.1
TBT_A_TTX_DRX_P1_R: RT623.2 UT1.A19(ASSTXP1)
TBT_A_TTX_DRX_P2: CT97.1 DT17.1 RT625.1
TBT_A_TTX_DRX_P2_R: RT625.2 UT1.A17(ASSTXP2)
TBT_A_USB20N: RT560.1 RT562.1 UT5.A7(D-_SYS_P1)
TBT_A_USB20P: RT559.1 RT561.1 UT5.A6(D+_SYS_P1)
TBT_B_SBU1: RT385.1 RT608.1 UT1.L4(BSBU1)
TBT_B_SBU2: RT386.1 RT609.1 UT1.L5(BSBU2)
TBT_B_TRX_C_DTX_N1: CT396.1 JUSBC1.1A10(SSRXN2) RT638.1
TBT_B_TRX_C_DTX_N2: CT395.2 JUSBC1.1B10(SSRXN1) RT635.1
TBT_B_TRX_C_DTX_P1: CT397.1 JUSBC1.1A11(SSRXP2) RT637.1
TBT_B_TRX_C_DTX_P2: CT394.2 JUSBC1.1B11(SSRXP1) RT636.1
TBT_B_TRX_DTX_N1: CT396.2 DT45.1 RT598.2
TBT_B_TRX_DTX_N1_R: RT598.1 UT1.B13(BSSRXN1)
TBT_B_TRX_DTX_N2: CT395.1 DT51.1 RT600.2
TBT_B_TRX_DTX_N2_R: RT600.1 UT1.A7(BSSRXN2)
TBT_B_TRX_DTX_P1: CT397.2 DT44.1 RT599.2
TBT_B_TRX_DTX_P1_R: RT599.1 UT1.A13(BSSRXP1)
TBT_B_TRX_DTX_P2: CT394.1 DT53.1 RT601.2
TBT_B_TRX_DTX_P2_R: RT601.1 UT1.B7(BSSRXP2)
TBT_B_TTX_C_DRX_N1: CT360.2 JUSBC1.1B3(SSTXN2) RT634.1
TBT_B_TTX_C_DRX_N2: CT365.2 JUSBC1.1A3(SSTXN1) RT639.1
TBT_B_TTX_C_DRX_P1: CT359.2 JUSBC1.1B2(SSTXP2) RT633.1
TBT_B_TTX_C_DRX_P2: CT366.2 JUSBC1.1A2(SSTXP1) RT640.1
TBT_B_TTX_DRX_N1: CT360.1 DT48.1 RT628.2
TBT_B_TTX_DRX_N1_R: RT628.1 UT1.B11(BSSTXN1)
TBT_B_TTX_DRX_N2: CT365.1 DT54.1 RT630.2
TBT_B_TTX_DRX_N2_R: RT630.1 UT1.B9(BSSTXN2)
TBT_B_TTX_DRX_P1: CT359.1 DT43.1 RT627.2
TBT_B_TTX_DRX_P1_R: RT627.1 UT1.A11(BSSTXP1)
TBT_B_TTX_DRX_P2: CT366.1 DT52.1 RT629.2
TBT_B_TTX_DRX_P2_R: RT629.1 UT1.A9(BSSTXP2)
TBT_B_USB20N: RT556.2 RT558.2 UT5.G11(D-_SYS_P2)
TBT_B_USB20P: RT555.2 RT557.2 UT5.F11(D+_SYS_P2)
TBT_CIO_PLUG_EVENT#: RT391.1 UH1.BF8(GPP_G2/SD_DATA1) UT1.AA1(CIO_PLUG_EVENT#)
TBT_FORCE_PWR: RT27.1 RT592.1 UH1.BE15(GPP_D4/ISH_I2C2_SDA/I2C3_SDA/SB) UT1.V4(FORCE_PWR)
TBT_I2C_SCL: RT514.1 UT1.V2(I2C_SCL) UT5.E2(I2C_SCL_SCB2_AR/GPIO_E2)
TBT_I2C_SDA: RT510.1 UT1.V1(I2C_SDA) UT5.D2(I2C_SDA_SCB2_AR/GPIO_D2)
TBT_ID: RH267.1 RH268.1 UH1.BF29(GPP_B16/GSPI0_CLK)
TBT_JTAG_TCK: RT6.1 UT1.W19(TCK)
TBT_JTAG_TDI: RT8.1 UT1.W20(TDI)
TBT_JTAG_TDO: RT5.1 UT1.Y19(TDO)
TBT_JTAG_TMS: RT7.1 UT1.Y20(TMS)
TBT_PCIE_RBIAS: RT34.1 UT1.N16(PCIE_RBIAS)
TBT_PERST#: RT501.2 RT612.2 RT621.2 UT1.T4(PERST#)
TBT_PERST#_R: RT501.1 RT611.2 UT34.4(OUT)
TBT_PWR_EN: T269.1 UH1.BF15(GPP_D20/DMIC_DATA0/SNDW4_DATA)
TBT_RBIAS: RT39.1 UT1.J6(RBIAS)
TBT_RESET_N_EC: RE506.2 RT11.1 RT37.1 UT1.E5(RESET#)
TBT_RESET_N_EC_R: RE95.2 RE506.1 UE1.L8(GPIO002/PWM5)
TBT_ROM_CLK: UT1.Y16(EE_CLK) UT2.6(CLK)
TBT_ROM_CS#: RT2.1 UT1.W18(EE_CS#) UT2.1(CS#)
TBT_ROM_DI: UT1.Y18(EE_DI) UT2.5(DI(IO0))
TBT_ROM_DO: RT3.1 UT1.W16(EE_DO) UT2.2(DO(IO1))
TBT_ROM_HOLD#: RT1.1 UT2.7(HOLD#(IO3))
TBT_ROM_WP#: RT4.1 UT1.W4(EE_WP#) UT2.3(WP#(IO2))
TBT_RSENSE: RT39.2 UT1.J5(RSENSE)
TBT_RTD3_WAKE#: RH732.2 RH735.2 RT456.1 RT622.1
TBT_RTD3_WAKE#_GPD7: RH602.1 RH735.1 UH1.BE41(GPD7)
TBT_RTD3_WAKE#_R: RH731.2 RH732.1 UH1.T47(GPP_K18/NMI#)
TBTA_CC1: CT352.1 DT7.1 DT7.9 JUSBC1.B5(CC2) UT5.K2(CC1_P1)
TBTA_CC2: CT354.1 DT8.5 DT8.6 JUSBC1.A5(CC1) UT5.H2(CC2_P1)
TBTA_DPSRC_AUX_N_C: RT388.1 RT516.1 UT5.C11(AUX_N_P1/GPIO_C11)
TBTA_DPSRC_AUX_P_C: RT387.1 RT523.1 UT5.B11(AUX_P_P1/GPIO_B11)
TBTA_HPD: RT23.1 RT529.2 RT619.1 UT5.K7(HPD_P1/GPIO_K7)
TBTA_HPD_R: RT619.2 RT641.2 UT1.T2(PA_HPD)
TBTA_I2C_INT#: RT16.1 RT511.1 UT1.M4(PA_I2C_INT) UT5.F2(I2C_INT_AR_P1/GPIO_F2)
TBTA_SBU1: DT7.5 DT7.6 JUSBC1.B8(SBU2) UT5.A3(SBU1_P1)
TBTA_SBU2: DT8.1 DT8.9 JUSBC1.A8(SBU1) UT5.A4(SBU2_P1)
TBTA_USB2_RBIAS: RT41.2 UT1.H19(PA_USB2_RBIAS)
TBTB_CC1: CT351.2 DT11.1 DT11.9 JUSBC1.1B5(CC2) UT5.K9(CC1_P2)
TBTB_CC2: CT353.2 DT12.5 DT12.6 JUSBC1.1A5(CC1) UT5.K10(CC2_P2)
TBTB_DPSRC_AUX_N_C: RT386.2 RT518.1 UT5.E11(AUX_N_P2/GPIO_E11)
TBTB_DPSRC_AUX_P_C: RT385.2 RT524.1 UT5.D11(AUX_P_P2/GPIO_D11)
TBTB_HPD: RT33.1 RT528.2 RT620.2 UT5.E10(HPD_P2/GPIO_E10)
TBTB_HPD_R: RT620.1 RT642.2 UT1.T1(PB_HPD)
TBTB_I2C_INT#: RT17.1 RT515.1 UT1.M5(PB_I2C_INT) UT5.G2(I2C_INT_AR_P2/GPIO_G2)
TBTB_SBU1: DT11.5 DT11.6 JUSBC1.1B8(SBU2) UT5.E1(SBU1_P2)
TBTB_SBU2: DT12.1 DT12.9 JUSBC1.1A8(SBU1) UT5.F1(SBU2_P2)
TBTB_USB2_RBIAS: RT42.2 UT1.F19(PB_USB2_RBIAS)
TDOCK_BATLOW#: RT20.1 UT1.U2(BATLOW#)
TEST_PWRGD: RT36.1 UT1.W5(TEST_PWR_GOOD)
THERMTRIP1#: QV40.1(D) RV817.2 UE1.B12(THERMTRIP1#)
THERMTRIP2#: CE36.1 QE4.1(COLLECTOR) RE69.2 UE1.H3(GPIO103/THERMTRIP2#)
TOUCH_SCREEN_DET#: JTS1.5 RV8.2 UH1.BC33(GPP_B4/CPU_GP3)
TOUCH_SCREEN_PD#: JTS1.4 RH348.2 UH1.AM45(GPP_E7/CPU_GP1)
TOUCHPAD_INTR#: JKBTP1.16 RE318.1 RH402.2 UH1.BF32(GPP_B3/CPU_GP2)
TP_LAN_JTAG_TCK: RL2.2 UL1.35(JTAG_TCK)
TP_LAN_JTAG_TDI: T73.1 UL1.32(JTAG_TDI)
TP_LAN_JTAG_TDO: T74.1 UL1.34(JTAG_TDO)
TP_LAN_JTAG_TMS: RL1.2 UL1.33(JTAG_TMS)
TP_SKL_E30: T281.1 UC1.E30(RSVD23)
TP_SKL_F30: T285.1 UC1.F30(RSVD24)
TPM_GPIO0: RZ112.2 UZ12.29(GPIO0/SDA)
TPM_GPIO4: T284.1 UZ12.13(CLKRUN#/GPIO4/SINT#)
TPM_LPM#: RZ363.2 UZ12.3(GPIO2/GPX)
TPM_PIRQ#: RC560.2 RC561.2 RZ69.2 UZ12.18(LAD2/SPI_IRQ#)
TPM_PIRQ#_R: RC560.1 UH1.BD29(GPP_B17/GSPI0_MISO)
TPM_TYPE: RH379.1 UH1.AW32(GPP_A22/ISH_GP4)
TRIP_+1VSP: PR801.2 PU800.2(TRIP)
TSENSE_2PH: PC1129.1 PR1166.1 PU1100.25(TTSENSE_2PH)
TSENSE_4PH: PC1127.1 PR1165.1 PU1100.14(TSENSE_4PH)
TYPEC_CON_SEL1: RH555.1 RH556.1 UH1.BA24(GPP_C10/UART0A_RTS#)
TYPEC_CON_SEL2: RH553.1 RH554.1 UH1.AP24(GPP_C11/UART0A_CTS#)
TYPEC_ID: CE62.1 RE343.2 UE1.F2(GPIO033/RC_ID0)
UART2_RXD: RH361.2 RH376.2 RT552.2 UH1.BD20(GPP_C20/UART2_RXD)
UART2_TXD: RH330.2 RH360.2 RT551.2 UH1.BE20(GPP_C21/UART2_TXD)
UART2RXD: JCCG1.9 RT552.1
UART2TXD: JCCG1.8 RT551.1
UG_1.2V: PQ200.4(G) PU200.17(UGATE)
UG_+1VSP: PQ800.4(G) PU800.9(DRVH)
UGATE_CHG: PQ702.4(G) PU700.26(HIDRV)
UIM_CLK: CZ38.1 JNGFF2.24 JSIM1.4(CLK)
UIM_DATA: CZ39.1 JNGFF2.26 JSIM1.3(I/O)
UIM_RESET: CZ40.1 JNGFF2.22 JSIM1.6(RST)
USB2_COMP: RH193.1 UH1.F4(USB2_COMP)
USB2_ID: RH365.1 UH1.G3(USB2_ID)
USB2_VBUSSENSE: RH364.1 UH1.F3(USB2_VBUSSENSE)
USB3_PRX_DTX_N1: DI1.1 DI1.9 JUSB1.5(SSRX-) UH1.D11(USB31_1_RXN)
USB3_PRX_DTX_N2: LI16.2 RI28.1 UH1.B9(USB31_2_RXN)
USB3_PRX_DTX_N3: DI6.1 DI6.9 JUSB2.5(SSRX-) UH1.B10(USB31_3_RXN)
USB3_PRX_DTX_P1: DI1.2 DI1.8 JUSB1.6(SSRX+) UH1.C11(USB31_1_RXP)
USB3_PRX_DTX_P2: LI16.3 RI27.1 UH1.C9(USB31_2_RXP)
USB3_PRX_DTX_P3: DI6.2 DI6.8 JUSB2.6(SSRX+) UH1.C10(USB31_3_RXP)
USB3_PRX_L_DTX_N2: JNGFF2.21 LI16.1 RI28.2
USB3_PRX_L_DTX_P2: JNGFF2.23 LI16.4 RI27.2
USB3_PTX_C_DRX_N1: CI16.1 DI1.4 DI1.7 JUSB1.8(SSTX-)
USB3_PTX_C_DRX_N2: CZ28.2 LI17.2 RI29.1
USB3_PTX_C_DRX_N3: CI65.1 DI6.4 DI6.7 JUSB2.8(SSTX-)
USB3_PTX_C_DRX_P1: CI13.1 DI1.5 DI1.6 JUSB1.9(SSTX+)
USB3_PTX_C_DRX_P2: CZ29.2 LI17.3 RI30.1
USB3_PTX_C_DRX_P3: CI63.1 DI6.5 DI6.6 JUSB2.9(SSTX+)
USB3_PTX_DRX_N1: CI16.2 UH1.F9(USB31_1_TXN)
USB3_PTX_DRX_N2: CZ28.1 UH1.C3(USB31_2_TXN)
USB3_PTX_DRX_N3: CI65.2 UH1.F11(USB31_3_TXN)
USB3_PTX_DRX_P1: CI13.2 UH1.F7(USB31_1_TXP)
USB3_PTX_DRX_P2: CZ29.1 UH1.D4(USB31_2_TXP)
USB3_PTX_DRX_P3: CI63.2 UH1.G12(USB31_3_TXP)
USB3_PTX_L_DRX_N2: JNGFF2.27 LI17.1 RI29.2
USB3_PTX_L_DRX_P2: JNGFF2.29 LI17.4 RI30.2
USB20_N1: UH1.J3(USB2N_1) UI1.2(DM_OUT)
USB20_N1_R: DI2.2 JUSB1.2(D-) LI3.4 RI60.2
USB20_N2: UH1.N13(USB2N_2) UI2.2(DM_OUT)
USB20_N2_R: DI3.2 JUSB2.2(D-) LI4.4 RI68.2
USB20_N4: RT560.2 UH1.M10(USB2N_4)
USB20_N5: RT556.1 UH1.M1(USB2N_5)
USB20_N6: T313.1 UH1.K7(USB2N_6)
USB20_N8: JNGFF2.9 UH1.G4(USB2N_8)
USB20_N9: LV3.4 UH1.M6(USB2N_9)
USB20_N9_R: DV30.2 JTS1.2 LV3.3
USB20_N10: JUSH1.19 UH1.H3(USB2N_10)
USB20_N11: LV2.1 UH1.R10(USB2N_11)
USB20_N11_R: DV41.2 JEDP1.15 LV2.2
USB20_N14: L1.1 RI49.1 UH1.E5(USB2N_14)
USB20_N14_R: JNGFF1.5 L1.2 RI49.2
USB20_NA: RT562.2 UT1.D20(PA_USB2_D_N)
USB20_NB: RT558.1 UT1.D19(PB_USB2_D_N)
USB20_P1: UH1.J2(USB2P_1) UI1.3(DP_OUT)
USB20_P1_R: DI2.3 JUSB1.3(D+) LI3.1 RI61.2
USB20_P2: UH1.N15(USB2P_2) UI2.3(DP_OUT)
USB20_P2_R: DI3.3 JUSB2.3(D+) LI4.1 RI70.2
USB20_P4: RT559.2 UH1.L9(USB2P_4)
USB20_P5: RT555.1 UH1.L2(USB2P_5)
USB20_P6: T314.1 UH1.K6(USB2P_6)
USB20_P8: JNGFF2.7 UH1.G5(USB2P_8)
USB20_P9: LV3.1 UH1.N8(USB2P_9)
USB20_P9_R: DV30.3 JTS1.3 LV3.2
USB20_P10: JUSH1.18 UH1.H2(USB2P_10)
USB20_P11: LV2.4 UH1.P9(USB2P_11)
USB20_P11_R: DV41.3 JEDP1.16 LV2.3
USB20_P14: L1.4 RI50.1 UH1.F6(USB2P_14)
USB20_P14_R: JNGFF1.3 L1.3 RI50.2
USB20_PA: RT561.2 UT1.E20(PA_USB2_D_P)
USB20_PB: RT557.1 UT1.E19(PB_USB2_D_P)
USB_ILIM1: RT587.1 RT588.1 UT9.11(ILIM)
USB_ILIM2: RT585.1 RT586.1 UT11.11(ILIM)
USB_OC0#: RH713.1 RH720.1 UH1.AH36(GPP_E9/USB2_OC0#)
USB_OC1#: RH710.1 RH719.1 UH1.AL40(GPP_E10/USB2_OC1#) UI1.13(FAULT#)
USB_OC2#: RH711.1 RH721.1 UH1.AJ44(GPP_E11/USB2_OC2#) UI2.13(FAULT#)
USB_OC3#: RH712.1 RH718.1 UH1.AL41(GPP_E12/USB2_OC3#)
USB_OC4#: CT383.2 RH714.1 UH1.AV47(GPP_F15/USB2_OC4#) UT9.8(FAULTB)
USB_OC5#: CT384.2 RH715.1 UH1.AR35(GPP_F16/USB2_OC5#) UT11.8(FAULTB)
USB_OC6#: RH716.1 UH1.AR37(GPP_F17/USB2_OC6#)
USB_OC7#: RH717.1 UH1.AV43(GPP_F18/USB2_OC7#)
USB_POWERSHARE_EN#: RE701.1 UE1.J3(GPIO206/ADC06) UI1.6(CTL1) UI2.6(CTL1)
USB_POWERSHARE_VBUS_EN: QT5.2(G) RE700.1 RE702.1 UE1.J2(GPIO205/ADC05) UI1.5(EN) UI2.5(EN)
USB_POWERSHARE_VBUS_EN#: QT5.1(D) RT564.2 RT610.2 UT10.1(B) UT12.1(B)
USH_DET#: JUSH1.1 RE526.2 UE1.C13(GPIO125/GPTP-OUT5/PVT_CLK)
USH_EXPANDER_SMBCLK: CZ62.1 JUSH1.16 RZ8.2 UE1.B3(GPIO006/SMB01_CLK/GPTP-OUT7) UE12.12(SCL)
USH_EXPANDER_SMBDAT: CZ63.1 JUSH1.15 RZ9.2 UE1.E5(GPIO005/SMB01_DATA/GPTP-OUT4) UE12.13(SDA)
USH_PWR_STATE#: JUSH1.5 RZ10.2 UE1.H2(GPIO204/ADC04)
USH_RST#_R: CZ61.1 JUSH1.6 RZ114.2
VCI_IN1#: RE507.1 UE1.B5(GPIO162/VCI_IN1#)
VCI_IN2#: RE508.1 UE1.D4(GPIO161/VCI_IN2#)
VCI_IN3#: RE750.1 UE1.E4(GPIO000/VCI_IN3#)
VCT_LAN_R1: RL3.1 RL50.2 UL1.6(SVR_EN_N)
VGA_IDENTIFY: JDGFF2.F1 JDGFF4.F1 RE84.1 UE1.L9(GPIO017/GPTP-IN5)
VID0_VCCIO_VR: PR313.2 PR314.1 PU300.4(C0)
VID1_VCCIO_VR: PR311.1 PR312.2 PU300.3(C1)
VOUT_IO: PR303.2 PR306.1 PU300.12(VOUT)
VR_SVID_ALERT#: PR1115.2 PR1199.2 RC152.2 RC153.1
VR_SVID_CLK: CC325.1 PR1104.2 PR1117.2 UC1.BH32(VIDSCK)
VR_SVID_DATA: PR1105.1 PR1113.2 RC157.2 UC1.BH29(VIDSOUT)
VRALERT#: RH203.1 UH1.BE32(GPP_B2/VRALERT#)
VSET_5105: CE38.1 RE77.1 UE1.C9(VSET)
VSN_1PH: PC1140.2 PR1107.2 PU1100.51(VSN_1PH)
VSN_2PH: PC1112.1 PR1127.1 PU1100.37(VSN_2PH)
VSN_4PH: PC1110.2 PR1123.2 PU1100.2(VSN_4PH)
VSP_1PH: PC1105.2 PR1109.2 PU1100.52(VSP_1PH)
VSP_2PH: PC1111.1 PR1126.1 PU1100.38(VSP_2PH)
VSP_4PH: PC1109.2 PR1121.2 PU1100.1(VSP_4PH)
WIGIG_32KHZ: JNGFF1.42 RZ56.1
WLAN_COEX1: JNGFF1.40 RZ130.2
WLAN_COEX2: JNGFF1.38 RZ129.2
WLAN_COEX3: JNGFF1.36 RZ128.2
WLAN_PWR_EN: DZ9.1 R127.1 RZ70.2 RZ71.2 UZ44.3(ON1)
WLAN_WIGIG60GHZ_DIS#: DZ1.1 RE8.1 UE1.L13(GPIO112/PS2_CLK1A)
WLAN_WIGIG60GHZ_DIS#_R: DZ1.2 JNGFF1.48
WRST#: CE343.1 RE564.2 UE12.19(WRST#)
WWAN_COEX1: JNGFF2.56 RZ130.1 RZ373.1
WWAN_COEX2: JNGFF2.54 RZ129.1 RZ372.1
WWAN_COEX3: JNGFF2.52 RZ128.1 RZ374.1
WWAN_FULL_PWR_EN: CZ198.1 JNGFF2.6 RZ43.1 UH1.BF19(GPP_D0/SPI1_CS#/SBK0_BK0)
WWAN_RADIO_DIS#: DZ5.1 RE10.1 UE1.F12(GPIO123/BCM0_CLK/PVT_IO2)
WWAN_RADIO_DIS#_R: DZ5.2 JNGFF2.8
WWAN_WAKE#: JNGFF2.15 RE38.1 UE1.M13(GPIO110/PS2_CLK2)
XCLK_RBIAS: RH171.2 RH435.2 UH1.T3(XCLK_BIASREF)
XDP_DBRESET#: CC32.1 JXDP1.48 RC137.1 RH66.2 UC3.1(IN B)
XDP_OBS0: RC239.1 UC1.BR27(BPM#_0)
XDP_OBS0_R: JXDP1.21 RC239.2
XDP_OBS1: RC240.1 UC1.BT27(BPM#_1)
XDP_OBS1_R: JXDP1.23 RC240.2
XDP_PRSNT_PIN1: JXDP1.1 RC121.1 RC122.1
XTAL24_IN_R: CH13.1 RH153.1 RH436.2 YH2.3(CRYSTAL3)
XTAL24_IN_R1: RH436.1 UH1.U10(XTAL_IN)
XTAL24_OUT: CH14.1 RH152.2 RH153.2 YH2.1(CRYSTAL1)
XTAL24_OUT_R1: RH152.1 UH1.U9(XTAL_OUT)
XTAL_25_IN: RT394.1 UT1.D22(XTAL_25_IN)
XTAL_25_OUT: RT40.1 UT1.D23(XTAL_25_OUT)
XTAL_25_OUT_R: CT20.1 RT40.2 YT1.3(OUT)
XTALI: CL14.1 UL1.10(XTAL_IN) Y1.1(IN)
XTALO: RL34.2 UL1.9(XTAL_OUT)
XTALO_R: CL13.1 RL34.1 Y1.3(OUT)
Z2805: RL18.1 TL1.22(TXCT1)
Z2806: RL17.1 TL1.16(TXCT3)
Z2807: RL16.1 TL1.21(TXCT2)
Z2808: RL15.1 TL1.15(TXCT4)
Z4012: PD8.2 PQ26.2(G) PR61.2 PR64.1
Z4304: PBATT1.4 PR65.1
Z4305: PBATT1.5 PR66.1
Z4306: PBATT1.6 PR67.1
N17828613: PC11.2 PQ17.4(G) PQ19.1(D) PR28.2 PR33.1
N17829900: PQ19.2(G) PR25.2 PR31.1
N17880182: PC12.2 PQ18.4(G) PQ20.1(D) PR29.2 PR34.1
N17880186: PQ20.2(G) PR26.2 PR32.1
N17880313: PQ5.3(D2) PR32.2
N17883210: PQ6.3(D2) PR34.2
N17883346: PQ5.5(G2) PQ5.6(D1) PR71.2
N17883375: PQ6.5(G2) PR38.1
N20816750: PR1701.1 PU1700.5(BOOT)
N20816752: PC1706.2 PU1700.7(PHASE)
N20816771: PC1706.1 PR1701.2
N20816775: PC1707.2 PR1700.2 PU1700.3(VCC)
N20816793: PL1700.3 PR1703.1
N20816800: PC1709.2 PR1702.1
N20816821: PC1806.2 PU1800.7(PHASE)
N20816822: PR1800.1 PU1800.5(BOOT)
N20816832: PC1807.2 PR1801.2 PU1800.3(VCC)
N20816859: PC1806.1 PR1800.2
N20816888: PC1809.2 PR1802.1
N20820556: PL1202.3 PR1203.1
N20820665: PL1203.3 PR1207.1
N23832668: PC19.2 PQ23.4(G) PQ25.1(D) PR47.2 PR52.1
N23832751: PQ25.2(G) PR44.2 PR50.1
N23832775: PQ8.3(D2) PR50.2
N23832788: PC18.2 PQ22.4(G) PQ24.1(D) PR46.2 PR51.1
N23832850: PQ24.2(G) PR43.2 PR48.1
N23833318: PQ9.3(D2) PR52.2
N23833326: PQ9.5(G2) PR53.1
N23900457: PR707.2 PU700.3(CMSRC)
N24451540: PC13.1 PQ6.2(G1) PR35.2 PR42.2
N24455122: PQ4.3(D2) PR35.1 PR39.2
N24455126: PQ4.4(S2) PR36.2 PR40.1
N24455128: PQ4.5(G2) PR41.2
N24468445: PC20.1 PQ9.2(G1) PR55.2 PR58.2
N24468529: PQ7.3(D2) PR55.1 PR57.2
N24468533: PQ7.4(S2) PR54.2 PR59.1
N24468535: PQ7.5(G2) PR60.2
N24695047: PQ8.5(G2) PQ8.6(D1) PR72.2
N24831965: PR207.2 PU200.9(TON)
N25195948: PC505.1 PU500.16(NC1) PU500.17(VCC)
N25195958: PC513.1 PU500.15(LDO)
N25196046: PC514.2 PR506.1
N25196480: PC501.1 PR501.2
N26820574: PD700.1(3) PD701.1(3) PR705.1
N26820774: PC709.1 PR706.1 PR709.1 PU700.6(ACDET)
N26821236: PR712.2 PR713.2 PR716.1 PU700.5(ACOK)
N26821586: PC711.2 PR717.2 PU700.7(IADP)
N26821595: PC712.2 PR719.2 PU700.8(IDCHG)
N26822390: PR708.1 PU700.25(BTST)
N26822393: PC708.2 PR708.2
N26949736: PR710.2 PU700.11(SDA)
N26949739: PR711.2 PU700.12(SCL)
N27028301: RZ120.2 UZ26.4(ON) UZ34.4(OUT)
N27121902: RV832.1 UV64.48(CA_DET)
N27182711: PC1119.1 PR1137.2
N28152235: PC1111.2 PC1112.2 PR1127.2 PR1128.1
N28152401: PC1128.2 PR1150.2 PU1100.15(VRMP)
N28152437: PC1118.2 PR1132.2 PU1100.3(IMON_4PH)
N28152465: PC1120.1 PR1135.1 PU1100.36(IMON_2PH)
N28152580: PC1103.2 PC1140.1 PR1106.2 PR1107.1
N28152729: PC1103.1 PC1105.1 PR1108.2 PR1109.1
N28152784: PC1130.1 PR1151.2 PU1100.16(VCC)
N28152844: PH1104.1 PR1166.2 PR1168.1
N28152958: PH1102.2 PR1141.2 PR1144.1
N28153073: PH1100.2 PR1101.1
N28153459: PH1103.1 PR1165.2 PR1167.1
N28153589: PR1198.1 PU1100.43(EN)
N28153954: PC1115.1 PR1133.2
N28154016: PC1109.1 PC1110.1 PR1122.2 PR1123.1
N28154283: PH1101.2 PR1140.2 PR1142.1
N28180064: PC1107.1 PR1118.2
N28185893: PC1116.1 PR1134.2
N28185971: PC1114.1 PR1130.2
N31547518: QV43.1(D) RV900.2 UV64.54(SW)
N42077965: PC1214.2 PU1200.7(PHASE)
N42077969: PR1201.1 PU1200.5(BOOT)
N42077993: PC1213.2 PR1200.2 PU1200.3(VCC)
N42078041: PC1224.2 PU1201.7(PHASE)
N42078055: PR1204.1 PU1201.5(BOOT)
N42078421: PC1214.1 PR1201.2
N42078543: PC1216.2 PR1202.1
N42078657: PC1224.1 PR1204.2
N42078671: PC1223.2 PR1205.2 PU1201.3(VCC)
N42078715: PC1226.2 PR1206.1
N43928883: PQ704.6(D2) PR721.2
N50626069: PQ2102.6(D1) PR2134.2
N50626073: PQ2101.2(G) PR2100.2 PR2134.1
N50626131: PC2100.2 PQ2100.4(G) PQ2101.1(D) PR2101.2 PR2108.1
N50626325: PQ2106.6(D1) PR2142.2
N50626329: PQ2105.2(G) PR2104.2 PR2142.1
N50626379: PC2102.2 PQ2104.4(G) PQ2105.1(D) PR2105.2 PR2109.1
N50692210: PR714.2 PU700.9(PMON)
N50714647: PQ2102.2(G1) PR2150.2
N50715082: PQ2106.2(G1) PR2106.2
N51087553: PC533.1 PU501.16(NC2) PU501.17(LDO)
N51087711: PC526.2 PR513.1
N51088117: PC531.1 PR514.2
N51093717: PC119.1 PU101.16(NC1) PU101.17(VCC)
N51093758: PC128.2 PR114.1
N51093811: PC115.1 PR111.2
N51093813: PC113.1 PR104.1 PR105.1 PU100.16(NC2) PU100.17(LDO)
N51093882: PC112.2 PR106.1
N51093922: PC110.1 PR101.2
N51431640: PQ700.4(G) PQ705.1(D) PR731.2 PR732.1
N52218840: PR1170.2 PU1100.27(CSP2_2PH)
N54556584: PD12.2 PR33.2
N54556800: PD12.1(3) PQ6.6(D1)
N54556836: PD13.2 PR51.2
N61680769: PD13.1(3) PQ9.6(D1)
N61687377: PC405.1 PR403.2
N61688443: PR807.2 PR809.2 PR810.1
N61688512: PC804.2 PR802.2
N61690744: PC903.1 PR903.2
N61692023: PC1243.2 PU1203.7(PHASE)
N61692025: PR1211.1 PU1203.5(BOOT)
N61692045: PC1244.2 PR1212.2 PU1203.3(VCC)
N61692067: PL1205.3 PR1215.1
N61692081: PC1243.1 PR1211.2
N61692131: PC1246.2 PR1213.1
N61692583: PL1204.3 PR1214.1
N61692600: PR1209.1 PU1202.5(BOOT)
N61692604: PC1233.2 PU1202.7(PHASE)
N61692626: PC1233.1 PR1209.2
N61692634: PC1234.2 PR1208.2 PU1202.3(VCC)
N61692676: PC1236.2 PR1210.1
N61733264: PD14.1(3) PQ4.2(G1)
N61733291: PD15.1(3) PQ7.2(G1)
N61859075: PR724.2 PU700.15(BATPRES#)
N63173356: JDIMM2.165(C1, CS3_N,NC) T49.1
N63173755: JDIMM2.162(C0/CS2_N/NC) T48.1
N63181367: JDIMM3.162(C0/CS2_N/NC) T50.1
N63181369: JDIMM3.165(C1, CS3_N,NC) T51.1
N63187763: JDIMM4.162(C0/CS2_N/NC) T52.1
N63187777: JDIMM4.165(C1, CS3_N,NC) T53.1
N63205753: RR237.1 UR3.3(WP#)
N63206214: CR256.2 RR227.1 UR4.6(VOUT)
N63206790: RR238.1 UR3.7(HOLD#)
N63261697: QE12.1(D) RE94.1
N63261780: RE703.2 UE1.M12(GPIO120)
N63261829: CE57.1 RE350.2
N63264088: RE57.1 RE58.1 UE1.B1(SYSPWR_PRES)
N63264181: RE318.2 UE1.G2(GPIO203/ADC03)
N63264846: QE17.1(D) RE546.2
N63282244: RA213.1 RA214.1 UA1.33(5VSTB/AUX_MODE)
N63282319: CA25.2 UA1.32(MIC2-CAP)
N63282335: CA29.1 CA232.1 UA1.24(CBN)
N63282517: CA35.2 UA1.38(VREF)
N63282540: CA51.2 RA44.2 UA1.39(LDO1-CAP)
N63282645: DA2.2 JHP1.5 RA219.2
N63282767: CA52.2 UA1.21(LDO2-CAP)
N63282827: CA29.2 CA232.2 UA1.23(CBP)
N63282834: CA53.2 UA1.19(LDO3-CAP)
N63282842: CA33.1 RA17.2
N63302772: CZ130.1 UZ23.6(CT)
N63303945: JNGFF3.10(DAS/DSS#) RN217.1
N63303993: JNGFF4.10(DAS/DSS#) RN218.1
N63304099: UZ23.3(ON) UZ60.4(O)
N63307260: JNGFF5.10(DAS/DSS#) RN216.1
N63354804: CT21.1 RT394.2 YT1.1(IN)
N63359901: CT375.1 QT2.2(G) RT545.1 RT546.1
N63359905: QT4.6(D) RT546.2
N63359909: CT375.2 QT2.3(S) QT3.3(S) RT545.2 RT547.1 RT548.2
N63359919: CT376.1 QT4.5(G) RT550.2
N63359925: QT3.2(G) QT4.2(G) RT548.1 RT549.1
N63359927: QT4.3(D) RT549.2
N63361205: CT372.1 RT542.1 UT7.5(VOUT)
N63361207: CT373.1 QT1.1(D) RT543.2 RT544.1 UT7.4(EN)
N63361304: DT64.2 QT10.1(D)
N63894512: CA49.2 CA233.2 UA1.25(CPVEE)
N64344369: RC114.1 UC1.BT25(CFG_RCOMP)
N64351847: T199.1 UC1.BP13(DDR0_VREF_DQ)
N64354433: T194.1 UC1.A33(EDP_DISP_UTIL)
N64403776: RH6.2 UH1.AU47(GPP_F13/SATA_SDATAOUT0)
N64404191: T34.1 UH1.Y35(RSVD2)
N64404193: T33.1 UH1.Y36(RSVD3)
N64404195: T36.1 UH1.BC1(RSVD1)
N64404197: T35.1 UH1.AL35(TP)
N64407208: T78.1 UH1.B25(RSVD2)
N64407218: T79.1 UH1.P24(RSVD3)
N64407220: T80.1 UH1.R24(RSVD4)
N64407222: T81.1 UH1.C26(RSVD5)
N64407224: T82.1 UH1.B26(RSVD6)
N64407234: T83.1 UH1.F26(RSVD7)
N64407236: T84.1 UH1.G26(RSVD8)
N64407238: T85.1 UH1.B27(RSVD9)
N64407240: T86.1 UH1.C27(RSVD10)
N64407242: T87.1 UH1.L26(RSVD11)
N64407244: T88.1 UH1.M26(RSVD12)
N64407246: T89.1 UH1.D29(RSVD13)
N64407248: T90.1 UH1.E28(RSVD14)
N64407250: T91.1 UH1.K29(RSVD15)
N64407252: T92.1 UH1.M29(RSVD16)
N64407590: T40.1 UH1.U13(RSVD_1)
N64412898: T60.1 UH1.R15(RSVD2)
N64412900: T61.1 UH1.R13(RSVD1)
N64412902: T62.1 UH1.AN35(TP)
N64412904: T63.1 UH1.AL37(VSS)
N64413001: CH321.1 RH28.2
N64413003: CH322.1 RH29.2
N64416436: RH101.2 SW1.2(B)
N64422426: T307.1 UH1.BC22(GPP_C17/I2C0_SCL)
N64422428: T306.1 UH1.BF23(GPP_C16/I2C0_SDA)
N64429445: CZ521.2 UZ42.6(CT)
N64429590: RZ509.2 UZ42.3(ON)
N64429642: CZ523.2 UZ40.12(CT1)
N64429659: CZ522.2 UZ40.10(CT2)
N64429688: QZ20.1(D) RZ514.2
N64429766: CZ515.2 UZ43.6(CT)
N64429852: RZ548.2 RZ549.2 UZ41.3(ON1)
N64429908: CZ517.2 UZ41.12(CT1)
N64429910: CZ516.2 UZ41.10(CT2)
N64430360: CZ121.1 UZ45.6(CT)
N64433226: DV3.1 DV42.1 RV3.1 UV24.4(EN)
N64433264: RV843.2 UV24.3(/OC)
N64434267: DV39.2 UV65.4(OUT Y)
N64440122: QV2.1(D) RV5.2
N64440771: CV953.1 QV8.2(G) RZ546.1
N64440773: QV7.1(D) RV6.1 RZ546.2
N64476900: RI14.2 UI1.16(ILIM_HI)
N64477358: RI71.2 UI2.16(ILIM_HI)
N64495443: QE11.3(S) RE70.1 RE90.1
N64495463: QE4.2(BASE) RE70.2
N64496280: CE342.1 UE12.4(VCORE)
N64542251: DV44.2 JDGFF2.E2
N64542506: RV821.2 UV60.1(B) UV68.4(OUT Y)
N64542541: RV820.2 UV68.2(IN A) UV69.4(Y)
N64855800: T288.1 UH1.Y14(RSVD7)
N64855802: T289.1 UH1.Y15(RSVD8)
N64855804: T290.1 UH1.U37(RSVD6)
N64855809: T291.1 UH1.U35(RSVD5)
N64855811: T294.1 UH1.AH15(RSVD2)
N64855813: T295.1 UH1.AH14(RSVD1)
N64856540: CH340.1 QH7.2(G) RH432.2 RH433.1
N64856544: QH6.1(D) RH433.2
N64880560: T292.1 UH1.N32(RSVD3)
N64880580: T293.1 UH1.R32(RSVD4)
N64881659: RE743.1 UE1.H9(GPIO030/TIN3)
N64883172: RE745.2 UE1.K12(GPIO111/PS2_DAT2)
N64883286: RE746.1 UE1.M11(GPIO027/TIN2)
N64968632: RT445.2 RT456.2 UT32.1(NO)
N64968636: RT448.2 UT32.3(NC)
N65166298: JDIMM1.162(C0/CS2_N/NC) T46.1
N65166304: JDIMM1.165(C1, CS3_N,NC) T47.1
N65178354: RV50.1 UV8.20(REXT)
N65178456: CV75.1 UV8.17(CEXT)
N65183116: T315.1 UV66.37(RSV0)
N65183120: T316.1 UV67.37(RSV0)
N65189266: JEDP1.18 LV1.1
N65240098: RZ62.1 UZ12.27(SERIRQ)
N65240286: CZ56.1 RZ63.1
N65288200: JNGFF3.8(NC2) RN219.1
N65288306: JNGFF4.8(NC2) RN220.1
N65288375: JNGFF5.8(NC2) RN221.1
N65845957: RL10.2 UL1.2(LANWAKE_N)
N65846745: JLOM1.B1(GREEN_LED-) RL19.2
N65846769: JLOM1.B3(ORANGE_LED-) RL20.2
N65846785: JLOM1.A2(YELLOW_LED-) RL14.2
N65849361: RT608.2 UT5.K11(LSTX_P2/GPIO_K11)
N65849379: RT609.2 UT5.L11(LSRX_P2/GPIO_L11)
N65849441: RT606.1 UT5.A10(LSTX_P1/GPIO_A10)
