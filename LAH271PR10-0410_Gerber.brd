# Allegro board LAH271PR10-0410_Gerber.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3.3V_WWAN on TOP (solid shape): 310.85,10.63 310.85,9.86 310.68,9.69 310.22,9.69 310.08,9.54 310.08,8.81 309.7,8.42 309.61,8.39 309.51,8.43 307.7,7.67 309.56,7.02 309.65,7.07 309.75,7.03 309.75,6.56 308.97,5.79 304.69,5.79 304,6.47 304,7.68 303.84,7.85 303.84,10.44 304.13,10.73 306.75,10.73 306.83,10.81 310.66,10.81
+3.3V_WWAN on BOTTOM (solid shape): 284.54,10.5 284.54,9.82 284.24,9.52 282.86,9.52 282.55,9.21 282.55,7.39 282.5,7.34 281.85,7.34 281.8,7.39 281.8,10.71 281.89,10.79 284.25,10.79
+3.3V_WWAN on BOTTOM (solid shape): 290.43,10.66 290.43,9.31 290.26,9.14 288.1,9.14 287.88,8.92 286.26,8.92 286.21,8.97 286.21,9.63 286.31,9.73 288.19,9.73 288.28,9.82 288.31,9.82 288.53,10.04 288.73,10.04 289.42,10.73 290.36,10.73
+3.3V_WWAN on BOTTOM (solid shape): 309.61,11.01 309.86,11.01 310,10.87 310.21,10.87 310.21,10.78 310.33,10.78 310.38,10.73 310.59,10.73 310.9,10.42 310.9,9.7 310.72,9.52 308.18,9.52 307.2,8.54 306.85,8.54 306.58,8.8 306.58,10.73 307.28,11.43 309.19,11.43
+3.3V_WWAN on IN3 (solid shape): outline of 385 points within 282.32,9.52 294.98,15.75
+3.3V_WWAN on IN2: 293.65,14.6 293.32,14.92 293.32,16.64 296.46,19.77 296.54,19.8 296.62,19.75 296.99,19.56 297.29,19.85 297.29,19.91 314.04,19.91 315.31,18.64 315.31,17.38 315.31,17.38 315.31,16.59 314.16,15.45 312.84,15.45 312.61,15.53 312.38,15.45 312.24,15.45 312.02,15.52 311.8,15.45 307.19,15.45 306.44,16.2 302.59,16.2 300.99,14.6
+3.3V_WWAN on IN3: 315.25,15.52 315.25,11.34 313.61,9.7 311.77,9.7 311.7,9.73 311.67,9.8 311.66,9.91 311.62,10.01 311.16,10.24 310.96,9.76 310.92,9.72 310.86,9.7 309.88,9.7 308.87,10.71 308.87,11.36 309.68,12.17 310.59,12.17 311.12,12.7 311.12,15.57 312.18,16.63 314.15,16.63
+3.3V_WWAN on IN4: outline of 156 points within 310.74,14.93 333.52,24.91
+3.3V_WWAN_PWR on TOP (solid shape): outline of 100 points within 326.69,20.16 329.61,24.97
+3.3VB_1.8V on TOP (solid shape): 127.8,5.47 127.8,5.34 127.72,5.26 126.96,5.26 126.75,5.05 126.75,4.56 127.04,4.27 127.04,3.4 126.94,3.29 125.02,3.29 124.42,2.7 124.08,2.7 123.9,2.87 123.9,4 125.09,5.19 125.13,5.19 125.24,5.14 125.25,5.02 125.7,4.57 125.81,5.19 125.81,5.33 126.44,5.33 126.68,5.57 127.7,5.57
+3.3VB_2.5V on TOP (solid shape): 285,45.43 285,44.72 285.2,44.53 285.2,44.54 285.26,44.54 285.74,44.54 286.15,45.09 286.24,45.18 287.94,45.18 287.94,45.18 288.33,45.18 288.62,44.89 288.62,42.51 288.46,42.35 287.42,42.35 287.39,42.38 287.39,42.89 287.39,42.89 287.39,42.92 286.85,42.92 286.85,42.92 286.85,42.37 286.84,42.36 286.61,42.36 286.6,42.37 286.6,42.91 286.6,42.92 286.06,42.92 286.05,42.91 286.05,42.36 286.04,42.36 285.31,42.36 284.7,42.96 284.7,45.43 284.79,45.52 284.92,45.52
+5V_ALW on TOP (solid shape): 180.47,4.7 180.47,4.44 180.75,4.16 180.75,2.47 180.75,2.47 180.75,1.68 180.67,1.59 180.03,1.59 179.93,1.69 179.93,2.54 179.91,2.56 179.91,4.72 180.01,4.82 180.35,4.82
+5V_ALW on TOP (solid shape): 151.06,14.6 151.06,13.55 151.41,13.2 152.12,13.2 152.19,13.12 152.19,12.97 152.12,12.89 151.27,12.89 151.23,12.94 151.17,12.98 151.06,13.09 150.57,13.09 150.33,12.86 149.09,12.86 148.89,13.06 148.89,13.62 148.88,13.62 148.88,14.11 149,14.11 149.23,14.34 149.53,14.34 150.11,14.93 150.73,14.93
+5V_ALW on TOP (solid shape): 60.73,18.35 60.73,17.46 60.72,17.44 60.2,17.44 60.17,17.41 60.17,16.72 60.19,16.69 60.7,16.69 60.71,16.68 60.71,16.24 60.7,16.23 60.19,16.23 60.17,16.21 60.17,15.52 60.19,15.5 60.58,15.5 60.58,15.5 60.7,15.5 60.71,15.49 60.71,14.95 60.49,14.73 60.48,14.73 60.41,14.66 58.16,14.66 57.81,15 57.81,16.14 57.92,16.25 57.92,16.71 58.17,16.96 58.17,18.58 58.3,18.71 60.38,18.71
+5V_ALW on TOP (solid shape): 313.27,12.5 313.27,11.29 313.17,11.19 313.11,11.15 313.07,11.09 312.98,11 312.98,9.55 313.24,9.28 313.24,6.56 313.19,6.5 313.16,6.5 312.81,6.15 313.16,5.79 313.24,5.75 313.28,5.66 313.28,5.61 311.91,4.24 310.54,4.24 310.3,4 309.08,4 308.93,4.16 308.93,4.6 309.02,4.69 309.85,4.69 310.35,5.2 310.74,5.2 311.24,5.7 311.93,5.7 312.02,5.79 312.02,5.84 312.02,6.49 312.56,7.03 312.56,8.1 312.26,8.4 312.26,10.05 312.1,10.21 312.1,11.13 312.21,11.24 312.21,12.42 312.37,12.59 313.18,12.59
+5V_ALW on BOTTOM (solid shape): 48.25,34.24 48.27,34.25 48.39,34.13 48.39,34.11 48.53,33.87 48.81,33.8 48.84,33.81 48.88,33.77 49.05,33.77 49.05,33.63 49.22,33.63 49.24,33.62 49.24,32.49 49.17,32.43 49.04,32.43 48.88,32.47 48.73,32.43 48.35,32.43 48.15,32.63 47.55,32.63 47.41,32.49 47.41,32.42 47.39,32.4 47.39,31.96 47.21,31.79 46.86,31.79 46.65,31.99 46.65,34.03 47.02,34.4 48.09,34.4
+5V_ALW on BOTTOM (solid shape): 60.56,28.15 61.15,27.2 61.17,27.11 61.12,27.03 60.97,26.57 61.41,26.39 61.51,26.38 61.55,26.29 61.55,25.24 61.27,24.96 60.21,24.96 60.06,25.11 60.06,26.42 60.01,26.42 59.95,26.48 59.17,26.48 59.07,26.58 59.07,26.85 59.2,26.98 59.2,27.74 59.74,28.28 60.43,28.28
+5V_ALW on BOTTOM: 102.22,26.36 103.27,26.36 104.55,25.07 104.55,24.84 104.53,24.79 104.48,24.77 104.18,24.23 104.8,24.25 104.82,24.28 105.18,24.28 105.26,24.2 105.26,23.4 105.18,23.33 103.82,23.33 102.48,24.68 101.4,24.68 100.51,25.56 100.51,25.58 100.31,25.84 99.98,25.82 99.97,25.81 99.56,25.81 99.29,26.07 99.29,27.41 98.09,28.62 98.09,30.03 96.54,31.57 96.54,33.69 95.95,34.28 95.95,34.88 96.28,35.21 97.87,35.21 98.23,34.85 98.23,33.88 98.47,33.64 99.51,33.64 99.65,33.51 99.65,32.03 100.32,31.36 100.32,30.9 101.87,29.35 101.87,26.63 102.14,26.37 102.21,26.37
+5V_ALW on VCC: 46.75,34.31 47.33,34.89 51.96,34.89 53.37,33.48 57.71,33.48 60.74,30.45 61.82,30.45 62.03,30.25 62.03,29.14 63.19,27.97 66.95,27.97 67.85,27.07 67.85,26.49 66.36,25 66.36,20.01 67.29,19.08 67.29,15.33 66.42,14.46 54.4,14.46 53.81,15.05 53.81,22.88 46.75,29.93
+5V_ALW on IN3: outline of 618 points within 59.11,4.3 204.55,41.99
+5V_ALW_R on TOP (solid shape): 352.63,41.25 352.63,39.86 352.75,39.73 352.75,39.43 352.63,39.31 352.38,39.31 352.22,39.46 351.29,39.46 351.2,39.55 351.2,41.25 351.44,41.49 352.39,41.49
+5V_ALW_R on TOP (solid shape): 339.26,42.75 339.26,42.06 339.3,42.01 339.3,40.97 339.17,40.84 339.14,40.82 339.11,40.79 337.17,40.79 336.87,41.09 336.87,42.46 337.2,42.79 339.22,42.79
+5V_ALW_R on TOP (solid shape): 353.18,51.85 353.18,50.45 353.14,50.42 353.14,49.33 353.05,49.23 352.8,49.23 352.67,49.36 352.67,49.68 352.47,49.88 351.48,49.88 351.44,49.92 351.44,51.53 351.92,52.01 353.02,52.01
+5V_ALW_R on TOP (solid shape): 237.86,141.3 237.86,139.73 237.67,139.54 237.18,139.54 237.08,139.64 237.08,139.99 236.82,140.25 236.39,140.25 236.21,140.07 236.21,139.73 236.11,139.63 236.11,138.91 236.03,138.83 235.81,138.83 235.73,138.9 235.73,139.58 235.77,139.63 235.77,140.34 235.73,140.38 235.73,140.4 235.65,140.48 235.65,141.37 235.68,141.39 237.77,141.39
+5V_ALW_R on TOP (solid shape): 295.59,40.05 295.59,39.53 295.58,39.51 295.04,39.51 295.04,39.51 295.04,38.76 295.04,38.76 295.58,38.76 295.59,38.75 295.59,38.32 295.58,38.31 295.04,38.31 295.04,38.31 295.04,37.56 295.05,37.56 295.59,37.56 295.59,37.55 295.59,36.63 295.42,36.46 291.79,36.46 291.64,36.61 291.64,39.89 291.84,40.09 295.55,40.09
+5V_ALW_R on TOP (solid shape): 328.02,29.19 328.02,28.42 328.12,28.33 328.12,27.75 328.01,27.65 327.74,27.65 327.53,27.57 327.42,27.37 327.42,27.35 327.36,27.3 327.12,27.3 327.12,27.33 327.04,27.33 326.92,27.44 326.92,27.9 326.92,27.91 326.92,29.03 327.15,29.26 327.95,29.26
+5V_ALW_R on TOP (solid shape): 229.83,138.76 229.83,138.08 230.11,137.8 230.11,137.46 229.97,137.31 229.57,137.31 229.33,137.56 229.33,137.57 229.07,137.82 228.64,137.82 228.28,137.47 228.28,137.24 228.16,137.11 228.16,136.5 228.07,136.4 228.05,136.4 227.94,136.4 227.85,136.5 227.85,137.12 227.98,137.25 227.98,137.98 227.9,138.05 227.9,138.82 227.95,138.87 229.73,138.87
+5V_ALW_R on TOP (solid shape): 253.88,141.22 253.88,140.53 253.7,140.35 251.83,140.35 251.61,140.14 251.61,139.85 251.5,139.73 251.5,139 251.43,138.93 251.24,138.93 251.17,139.01 251.17,139.75 251.21,139.79 251.21,139.93 251.21,139.94 251.22,140.03 251.21,140.13 251.21,140.14 251.21,140.44 251.17,140.48 251.17,140.51 251.09,140.58 251.09,141.47 251.12,141.5 253.59,141.5
+5V_ALW_R on TOP (solid shape): 245.61,141.25 245.61,139.76 245.43,139.58 245,139.58 244.82,139.76 244.82,139.99 244.57,140.25 244.14,140.25 243.99,140.1 243.99,140.03 243.99,140.02 243.96,139.89 244,139.72 243.84,139.56 243.84,138.9 243.76,138.83 243.55,138.83 243.48,138.9 243.48,139.68 243.52,139.73 243.52,139.85 243.54,139.95 243.52,140.04 243.52,140.32 243.44,140.41 243.43,140.41 243.4,140.44 243.4,141.37 243.42,141.39 245.47,141.39
+5V_ALW_R on BOTTOM (solid shape): 269.14,131.82 269.14,131.44 269.2,131.39 269.49,131.39 269.77,131.67 269.84,131.67 269.85,131.67 270.11,131.67 270.3,131.49 271.06,131.49 271.18,131.36 271.18,130.25 271.2,130.23 271.2,129.32 271.14,129.26 268.93,129.26 268.84,129.35 268.84,129.46 268.94,129.56 269.89,129.56 270.26,129.93 270.26,130.35 270.01,130.61 269.17,130.61 269.17,130.61 268.99,130.61 268.79,130.81 268.79,130.87 268.77,130.92 268.77,131.01 268.52,131.26 268.52,131.53 268.32,131.73 267.78,131.73 267.67,131.62 267.67,130.35 267.57,130.25 267.44,130.25 267.34,130.35 267.34,131.8 267.72,132.18 268.79,132.18
+5V_ALW_R on BOTTOM (solid shape): outline of 95 points within 217.53,129.18 220.04,134.47
+5V_ALW_R on BOTTOM (solid shape): outline of 115 points within 178.64,85.46 182.21,88.89
+5V_ALW_R on IN2 (solid shape): outline of 1665 points within 263.66,54.67 293.82,143.07
+5V_ALW_R on IN3 (solid shape): outline of 418 points within 178.37,85.41 181.7,96.51
+5V_ALW_R on IN3 (solid shape): outline of 982 points within 288.43,35.4 296.95,57.68
+5V_ALW_R on IN4 (solid shape): outline of 402 points within 178.42,85.44 181.57,96.52
+5V_ALW_R on IN2: outline of 378 points within 292.06,21.37 354.33,52.32
+5V_ALW_R on VCC: 178.12,84.94 176.24,86.83 176.24,94.74 186.38,104.88 192.86,104.88 197.19,109.22 197.19,112.61 195.67,114.13 195.67,119.76 197.96,122.05 197.96,131.7 201.18,134.92 201.18,135.32 201.21,135.36 214.95,135.36 223.29,143.7 224.66,143.89 225.72,144.76 272.71,144.76 273.33,144.19 274.15,143.98 280.22,143.98 280.75,139.23 273.5,139.23 272.76,138.49 272.76,130.41 267.4,130.41 260.17,137.65 230.74,137.65 229.2,136.1 229.2,128.02 229.21,128.01 229.21,127.88 225.15,127.88 223.61,126.34 212.29,126.34 211.65,126.98 206.61,126.98 205.07,125.43 205.07,105.37 192.39,92.69 179.94,92.69 179.03,91.78 179.03,89.15 179.56,88.62 180.07,88.62 180.45,88.24 181.47,88.24 182.21,87.5 182.21,85.43 181.72,84.94
+5V_ALW_RP on TOP (solid shape): 300.94,41.64 300.94,35.22 300.48,34.76 297.66,34.76 297.62,34.8 297.62,35.71 297.3,36.04 295.98,36.04 295.74,36.28 295.74,37.7 295.73,37.71 295.68,37.71 295.2,37.71 295.19,37.72 295.19,38.14 295.2,38.15 295.74,38.15 295.75,38.16 295.75,38.9 295.74,38.91 295.2,38.91 295.19,38.92 295.19,39.34 295.21,39.36 295.74,39.36 295.75,39.37 295.75,40.21 295.64,40.32 291.73,40.32 291.45,40.61 291.45,42.06 291.6,42.21 300.37,42.21
+5V_ALWP on TOP (solid shape): 64.73,19.9 66.4,19.9 66.72,19.58 66.72,15.07 66.54,14.89 63.74,14.89 63.66,14.93 63.64,15.01 63.62,15.2 63.51,15.35 63.48,15.42 63.51,15.5 63.22,16.1 63.02,15.47 63.05,15.4 63.03,15.32 62.94,15.18 62.94,15.01 62.92,14.93 62.84,14.89 61,14.89 60.85,15.04 60.85,15.63 60.84,15.64 60.32,15.64 60.31,15.65 60.31,16.08 60.32,16.08 60.84,16.08 60.85,16.09 60.85,16.84 60.84,16.84 60.33,16.84 60.32,16.86 60.32,17.28 60.33,17.29 60.83,17.29 60.85,17.31 60.85,17.39 60.86,17.4 60.86,18.41 60.85,18.42 60.85,20.07 60.97,20.2 64.43,20.2
+5V_ALWP on BOTTOM (solid shape): 64.8,19.96 64.8,18.2 64.61,18.01 61,18.01 60.72,18.29 60.72,19.92 60.95,20.15 64.61,20.15
+5V_DGFF on TOP (solid shape): 171.27,86.58 171.27,86.47 171.27,86.47 171.27,86.14 171.58,85.83 172.5,85.83 172.61,85.71 172.61,85.04 172.49,84.92 171.14,84.92 170.8,85 170.46,84.92 170.36,84.92 170.11,85.17 170.11,86.43 170.49,86.8 171.05,86.8
+5V_DGFF on TOP (solid shape): 170.51,101.96 170.74,101.88 170.97,101.96 171.17,101.96 171.38,101.74 171.44,101.67 171.51,101.62 171.55,101.58 171.67,101.58 171.71,101.58 172.23,101.58 172.27,101.58 172.43,101.58 172.56,101.45 172.56,100.82 172.4,100.66 171.51,100.66 171.5,100.66 171.16,100.66 171.16,100.66 171.04,100.66 171.03,100.66 170.8,100.7 170.57,100.66 170.56,100.66 170.44,100.66 170.01,100.24 170.01,99.12 170.01,99.11 169.98,98.97 170.01,98.82 170.01,98.81 170.01,98.5 170.01,98.49 169.99,98.37 170.01,98.25 170.01,98.24 170.01,97.43 170.56,96.88 170.56,96.46 170.46,96.26 170.48,96.05 170.49,96.03 170.49,95.94 170.56,95.87 170.56,94.05 171.43,93.19 171.43,91.39 170.7,90.67 170,90.67 169.69,90.97 169.69,101.74 169.91,101.96
+5V_DGFF on BOTTOM (solid shape): outline of 1322 points within 169.64,80.87 186.5,92.84
+5V_DGFF on IN1 (solid shape): outline of 240 points within 169.72,90.61 172.15,102.16
+5V_DGFF on IN2 (solid shape): outline of 318 points within 169.68,84.99 172.35,102.17
+5V_DGFF_PWR on BOTTOM (solid shape): 184.14,86.83 184.24,86.79 184.27,86.68 184.54,86.28 184.96,86.53 186.13,86.53 186.26,86.4 186.26,84.8 186.45,84.61 186.45,83.22 186.2,82.97 185.69,82.97 185.69,82.99 185.68,82.99 185.68,83.5 185.17,83.5 185.17,82.99 185.15,82.99 185.15,82.97 184.9,82.97 184.9,82.99 184.88,82.99 184.88,83.5 184.37,83.5 184.37,82.97 183.98,82.97 183.96,82.99 183.48,83.47 183.48,86.77 183.54,86.83
+5V_HDD on TOP (solid shape): 325.25,31.88 325.25,31.01 325.26,31 325.8,31 325.81,30.99 325.81,30.82 325.8,30.81 325.26,30.81 325.26,30.81 325.26,30.35 325.21,30.31 323.91,30.31 323.76,30.46 323.76,31.84 323.9,31.98 325.15,31.98
+5V_HDD on IN1 (solid shape): outline of 1557 points within 323.38,15.5 346.14,33.73
+5V_HDD on IN3 (solid shape): outline of 1041 points within 342.38,6.24 353.55,17.59
+5V_HDD_UZ23 on TOP (solid shape): 327.49,32.39 327.49,31.82 327.64,31.67 327.85,31.67 328.02,31.51 328.02,30.7 327.91,30.59 327.23,30.59 327.03,30.39 325.42,30.39 325.4,30.41 325.4,30.65 325.42,30.66 325.95,30.66 325.97,30.68 325.97,31.15 325.96,31.15 325.41,31.15 325.4,31.17 325.4,32.34 325.56,32.5 327.38,32.5
+5V_RUN on TOP (solid shape): 81.6,56 81.6,53.95 80.48,52.84 79.2,52.84 78.83,53.2 78.83,53.8 79.83,54.8 79.83,55.8 80.3,56.27 81.33,56.27
+5V_RUN on TOP (solid shape): 304.73,47.53 304.73,47.04 304.3,46.61 302.21,46.61 301.99,46.82 301.99,47.44 302.2,47.65 303.44,47.65 303.78,48 304.26,48
+5V_RUN on TOP (solid shape): 193.1,5.16 193.98,5.16 194.03,5.21 194.48,5.21 194.54,5.15 194.54,4.58 194.2,4.25 192.8,4.25 192.34,4.71 192.34,5.32 192.49,5.48 192.78,5.48
+5V_RUN on TOP (solid shape): 302.1,54.21 302.1,52.94 301.79,52.63 295.75,52.63 295.37,53.01 295.37,53.41 295.52,53.57 296.07,53.57 296.07,53.57 296.25,53.57 296.43,53.75 296.43,54.25 296.47,54.3 297.33,54.3 297.58,54.06 299,54.06 299.4,54.46 301.84,54.46
+5V_RUN on TOP (solid shape): 172.56,131.22 172.56,129.87 172.48,129.8 170.3,129.8 170.22,129.87 170.22,130.41 170.48,130.67 170.52,130.65 171.11,130.67 171.51,131.1 171.51,131.12 171.69,131.3 172.48,131.3
+5V_RUN on TOP (solid shape): 334.24,47.46 334.24,46.76 334.28,46.72 334.78,46.72 334.8,46.7 334.8,46.28 334.79,46.27 334.33,46.27 334.32,46.27 334.26,46.27 334.24,46.25 334.24,45.56 334.28,45.52 334.77,45.52 334.79,45.5 334.79,45.07 334.78,45.06 334.37,45.06 334.37,45.07 334.29,45.07 334.27,45.05 334.27,45.04 334.25,45.03 334.25,43.65 333.89,43.29 331.62,43.29 331.25,43.65 331.25,45.16 331.96,45.86 331.96,46.87 332.6,47.51 334.19,47.51
+5V_RUN on TOP (solid shape): 343.98,39.32 343.98,36.12 343.92,36.07 343.43,36.07 343.42,36.05 343.42,35.52 343.17,35.52 343.15,35.54 343.15,36.04 343.12,36.07 342.64,36.07 342.62,36.04 342.62,35.97 342.62,35.54 342.6,35.52 342.37,35.52 342.35,35.54 342.35,35.98 342.34,35.99 342.34,36.06 342.32,36.08 341.04,36.08 340.75,36.37 340.75,39.1 341.25,39.61 343.69,39.61
+5V_RUN on TOP (solid shape): 82.87,27.43 82.87,25.78 82.69,25.6 82.04,25.6 82,25.62 81.08,25.47 80.93,24.55 80.96,24.5 80.99,24.45 80.99,22.86 80.69,22.56 80.04,22.56 79.95,22.65 79.95,23.45 79.49,23.91 79.49,26.59 79.6,26.74 79.66,26.93 80.22,27.48 81.1,27.48 81.24,27.63 82.68,27.63
+5V_RUN on BOTTOM (solid shape): 82.92,55.94 83.43,55.94 83.58,55.8 83.58,55.19 83.5,55.12 81.78,55.12 80.21,53.55 78.64,53.55 78.52,53.67 78.52,54.25 80.3,56.03 82.83,56.03
+5V_RUN on BOTTOM (solid shape): outline of 440 points within 77.43,26.15 82.7,44.42
+5V_RUN on IN1 (solid shape): outline of 415 points within 78.01,43.09 81.43,54.7
+5V_RUN on IN1 (solid shape): outline of 1487 points within 290.76,34.49 343.5,57.85
+5V_RUN on IN3 (solid shape): 211.43,93.89 211.43,93.7 210.93,93.21 210.93,85.67 221.83,74.77 269.33,74.77 282.51,61.58 282.51,57.79 282.27,57.55 281.04,57.55 280.53,58.06 280.53,61.22 273.92,67.84 273.89,67.92 273.92,67.99 273.94,68.51 273.42,68.49 273.35,68.46 273.27,68.49 268.56,73.2 268.48,73.2 268.48,73.2 218.79,73.2 207.51,84.48 207.54,84.5 207.54,89.21 208.21,89.89 208.21,90.16 208.23,90.18 208.23,93.77 208.69,94.23 211.09,94.23
+5V_RUN on IN3 (solid shape): outline of 1691 points within 297.24,37.62 342.82,54.5
+5V_RUN on IN4 (solid shape): outline of 1429 points within 170.16,92.85 211.42,131.49
+5V_RUN on VCC: 131.03,13.17 130.75,13.44 97.73,13.44 87.45,23.73 81.86,23.73 80.99,24.6 80.99,25.48 80.35,26.13 82.14,27.92 93.57,27.92 100.31,21.18 106.97,21.18 108.99,19.16 118.17,19.16 119.47,17.86 123.44,17.86 125.11,19.53 131.71,19.53 134.38,16.86 139.85,16.86 141.41,18.42 144.09,18.42 146.45,20.78 157.32,20.78 157.74,21.2 164.66,21.2 165.38,20.47 173.32,20.47 175.47,22.62 201.39,22.62 204.63,19.39 242.27,19.39 250.93,28.05 252.72,26.27 272.61,26.27 280.51,34.16 280.51,60.45 283.87,63.82 295.93,51.76 287.52,43.35 287.52,26.78 281.04,20.31 251.7,20.31 246.66,15.27 212.38,15.27 212.07,14.96 211.46,14.96 211.12,15.3 200.44,15.3 198.2,17.54 170.02,17.54 169.38,18.19 164.48,18.19 164.07,17.77 163.49,18.34 145.45,18.34 143.67,16.56 141.76,16.56 138.73,13.52 131.39,13.52
+5V_RUN_AUDIO on TOP (solid shape): outline of 258 points within 341.28,30.59 347.23,35.94
+5V_RUN_CHG on TOP (solid shape): 297.94,57.47 297.94,56.4 297.4,55.85 297.4,54.94 297.35,54.89 295.75,54.89 295.36,55.28 295.36,56.24 296.84,57.72 297.7,57.72
+5V_RUN_PVDD_L on TOP (solid shape): 343.78,30.31 343.78,30.05 343.58,29.85 343.56,29.85 343.26,29.55 343.26,28.77 343.25,28.73 343.22,28.68 343.15,28.68 342.6,28.43 343.09,28.06 343.2,28.05 343.26,27.94 343.26,27.51 344.08,26.7 344.08,25.89 344,25.82 343.9,25.82 343.85,25.87 343.85,26.65 343.77,26.73 343.61,26.85 343.43,26.81 343.36,26.79 343.3,26.81 343.13,26.85 342.98,26.76 342.34,26.76 342.13,26.54 340.35,26.54 340.01,26.88 340.01,28.83 339.87,28.97 339.87,29.7 340.18,30.01 341.05,30.01 341.55,30.5 343.59,30.5
+5V_RUN_PWR on TOP (solid shape): 338.19,46.79 338.8,46.79 338.95,46.64 338.95,46.15 338.92,46.14 338.71,45.71 339.11,45.46 339.14,45.46 339.26,45.34 339.26,44.13 339.19,44.07 334.71,44.07 334.38,44.39 334.38,44.91 334.4,44.93 334.92,44.93 334.94,44.95 334.94,45.65 334.93,45.67 334.39,45.67 334.38,45.68 334.38,46.11 334.39,46.12 334.92,46.12 334.94,46.15 334.94,46.86 334.93,46.87 334.4,46.87 334.39,46.89 334.39,47.44 334.48,47.52 337.45,47.52
+5V_USB_PWR1 on TOP (solid shape): 349.33,52.95 349.33,52.45 349.75,52.02 349.75,51.17 349.78,51.14 349.78,50.93 349.7,50.84 348.74,50.84 348.51,51.07 348.51,51.1 348.5,51.17 348.55,51.22 348.75,51.62 348.4,51.9 348.37,51.9 348.27,52 348.27,52.02 348.25,52.09 348.22,52.15 348.21,52.17 348.21,52.87 348.41,53.07 349.21,53.07
+5V_USB_PWR1 on TOP (solid shape): outline of 123 points within 353.29,48.39 361.63,51.62
+5V_USB_PWR1 on IN1 (solid shape): outline of 506 points within 348.06,49.13 361.62,58.38
+5V_USB_PWR2 on TOP (solid shape): 349.52,42.1 349.52,40.74 349.54,40.72 349.54,40.48 349.45,40.4 348.66,40.4 348.05,41.01 348.05,42.01 348.53,42.49 349.13,42.49
+5V_USB_PWR2 on TOP (solid shape): 352.91,34.39 352.91,32.73 352.3,32.12 352.3,31.89 351.94,31.53 351.09,31.53 350.74,31.89 350.74,34.78 350.91,34.96 352.33,34.96
+5V_USB_PWR2 on TOP (solid shape): outline of 104 points within 356.2,23.83 363.9,29.54
+5V_USB_PWR2 on IN1 (solid shape): outline of 1151 points within 347.84,26.74 361.57,42.59
+5V_VBUS1 on BOTTOM (solid shape): 39.2,15.07 39.2,13.39 39.55,13.05 39.55,11.99 39.01,11.46 36.77,11.46 36.24,11.99 36.24,12.01 36.11,12.13 36.11,14.2 35.75,14.56 35.75,15.28 35.95,15.48 38.79,15.48
+5V_VBUS1 on BOTTOM: 41.4,31.73 41.26,31.87 41.26,32.29 41.34,32.38 41.34,32.46 41.49,32.61 41.49,33.22 41.67,33.4 43.22,33.4 43.59,33.03 43.59,31.98 43.4,31.79 43.05,31.79 42.99,31.73
+5V_VBUS1 on VCC: 38.01,11.46 37.87,11.6 37.87,14 38.08,14.21 42.78,14.21 45.32,16.74 45.32,19.5 44.32,20.51 43.86,20.51 39.78,24.59 38.47,24.59 35.58,27.49 31.72,27.49 31.6,27.61 31.6,29.46 33.1,30.96 38.11,30.96 38.32,30.75 39.8,30.75 40.32,31.27 40.32,32.44 40.31,32.44 40.31,33.79 40.39,33.87 41.84,33.87 43.07,32.64 43.07,30.82 41.87,29.61 41.87,28.63 49.18,21.32 49.18,17.18 49.16,17.17 49.16,13.2 47.66,11.7 39.14,11.7 38.91,11.46 ; 1 cut-out
+5V_VBUS2 on BOTTOM: 53.46,25.74 53.46,26.02 53.69,26.25 54.61,26.25 54.63,26.25 54.77,26.21 54.92,26.25 54.93,26.25 55.24,26.25 55.25,26.25 55.51,26.25 55.68,26.44 55.69,26.46 56.01,26.46 56.18,26.41 56.34,26.46 56.75,26.46 57.08,26.13 57.08,25.11 56.94,24.97 56.2,24.97 55.69,25.48 53.71,25.48
+5V_VBUS2 on BOTTOM: 35.01,19.98 34.62,20.38 33.57,20.38 33.45,20.5 33.43,20.52 33.43,20.84 33.28,20.99 33.28,23.89 33.88,24.49 34.97,24.49 35.19,24.27 35.19,23.79 35.94,23.04 35.94,20.32 35.6,19.98
+5V_VBUS2 on IN2: outline of 89 points within 32.72,20.81 56.46,26.44
+13.5VB_BATT on TOP (solid shape): 274.67,12.69 274.67,11.46 272.85,9.64 272.85,6.47 272.4,6.02 270.36,6.02 270.16,6.22 270.16,10.85 270.61,11.31 270.62,11.4 270.62,12.38 270.71,12.47 270.82,12.8 270.62,13.08 270.62,13.37 270.84,13.6 273.76,13.6
+13.5VB_BATT on TOP (solid shape): 286.91,17.7 286.91,16.65 286.77,16.51 285.21,16.51 284.95,16.26 284.95,15.58 284.44,15.58 284.08,15.22 284.44,14.86 284.95,14.86 284.95,13.91 284.79,13.75 280.81,13.75 279.87,14.69 279.87,17.1 280.06,17.29 280.56,17.29 281.07,17.8 286.81,17.8
+13.5VB_BATT on BOTTOM: 271.51,11.97 270.93,12.54 270.93,12.89 270.62,13.2 270.62,14.99 270.93,15.29 270.93,15.66 270.99,15.72 271.01,15.73 271.5,16.24 271.01,16.76 270.99,16.76 270.93,16.83 270.93,19.33 274.63,23.03 281.85,23.03 282.44,22.44 282.44,20.11 282.4,20.01 282.3,19.99 281.97,19.87 281.9,19.53 282.04,19.28 282.32,19.22 282.41,19.2 282.44,19.12 282.44,18.63 282.93,18.15 283.86,18.15 284.12,17.89 284.12,14.29 283.98,14.16 276.69,14.16 274.5,11.97
+13.5VB_BATT_C on TOP (solid shape): 268.48,11.43 268.48,10.82 268.77,10.54 269.64,10.54 269.9,10.28 269.9,6.6 269.07,5.77 265.26,5.77 265.14,5.9 265.14,7.24 265.3,7.41 265.3,7.84 265.08,8.07 265.08,8.32 264.8,8.59 264.66,8.59 264.38,8.87 264.38,10.08 265.78,11.48 268.42,11.48
+13.5VB_BATT_C on BOTTOM (solid shape): 269.98,11.58 269.98,7.9 269.68,7.6 265.79,7.6 264.82,8.57 264.61,8.57 264.38,8.8 264.38,9.7 264.49,9.82 265.04,9.82 265.48,10.26 265.48,11.96 265.81,12.29 269.27,12.29
+13.5VB_CHG on TOP (solid shape): 306.64,15.8 306.64,13.26 306.87,13.03 309.76,13.03 309.96,12.84 309.96,11.18 309.84,11.07 306.69,11.07 305.88,11.88 304.99,11.88 304.71,12.16 304.71,15.7 304.91,15.9 304.96,15.95 306.49,15.95
+13.5VB_CHG on TOP (solid shape): 293.26,17.54 293.26,14.68 293.18,14.61 289.85,14.61 288.73,13.49 286.36,13.49 285.94,13.91 285.94,14.86 286.52,14.86 286.88,15.22 286.52,15.58 286,15.58 285.94,15.63 285.94,16.21 286.03,16.3 286.78,16.3 287.09,16.6 287.09,17.99 287.98,18.88 291.92,18.88
+13.5VB_CHG on BOTTOM (solid shape): 307.75,15.73 307.75,13.25 307.57,13.07 304.86,13.07 304.77,13.16 304.77,15.79 304.96,15.98 307.5,15.98
+13.5VB_CHG on IN1 (solid shape): outline of 308 points within 287.64,13 310.13,23.4
+13.5VB_CHG on IN4: 309.83,18.15 309.83,14.28 308.64,13.08 304.88,13.08 304.69,13.26 304.69,15.92 304.39,16.22 302.48,16.22 301.93,15.68 295.03,15.68 294.78,15.93 293.78,15.93 293.53,15.69 288.39,15.69 287.63,16.44 287.63,18.49 288.06,18.91 303.75,18.91 303.89,18.77 309.21,18.77
+19.5V_SDC_IN on TOP (solid shape): outline of 503 points within 38.8,4.33 57.22,13.34
+19.5V_SDC_IN on BOTTOM (solid shape): 50.83,13.24 50.83,12.92 50.64,12.73 50.64,7.45 50.48,7.29 44.29,7.29 44.01,7.57 44.01,8.05 43.64,8.42 41.76,8.42 41.54,8.64 41.54,10.84 44.09,10.84 44.09,10.82 44.1,10.76 44.12,10.71 44.14,10.66 44.17,10.62 44.2,10.58 44.25,10.55 44.29,10.52 44.34,10.5 44.39,10.49 44.45,10.49 44.5,10.49 44.55,10.5 44.6,10.52 44.65,10.55 44.69,10.58 44.73,10.62 44.76,10.66 44.78,10.71 44.8,10.76 44.8,10.82 44.8,10.87 44.8,10.92 44.78,10.97 44.76,11.02 44.73,11.06 44.69,11.1 44.65,11.14 44.6,11.16 44.55,11.18 44.5,11.19 44.45,11.2 44.39,11.19 44.34,11.18 44.29,11.16 44.25,11.14 44.2,11.1 44.17,11.06 44.14,11.02 44.12,10.97 44.1,10.92 44.09,10.87 44.09,10.84 41.54,10.84 41.54,12.52 42.34,13.31 50.75,13.31
+19.5V_SDC_IN_CR on TOP (solid shape): 58.7,13.47 58.84,13.44 58.98,13.47 59.93,13.47 60.02,13.38 60.02,12.82 59.48,12.82 59.12,12.46 59.48,12.1 60.02,12.1 60.02,11.43 59.96,11.37 59.68,11.37 59.61,11.3 59.61,10.53 59.39,10.32 59.39,8.85 59.29,8.74 59.06,8.74 58.71,8.86 58.44,8.6 58.29,8.45 56.6,8.45 56.43,8.62 56.43,11.5 56.65,11.72 57.56,11.72 57.88,12.05 57.88,13.22 58.13,13.47
+19.5VB on TOP (solid shape): 86.52,40.2 86.52,39.09 87.62,37.99 87.62,37.46 87.34,37.17 86.13,37.17 85.74,37.57 84.57,37.57 84.37,37.77 84.37,38.68 84.54,38.86 84.54,39.57 84.69,39.71 85.51,39.71 86.12,40.32 86.4,40.32
+19.5VB on TOP (solid shape): 315.13,33.56 315.13,33.08 315.15,33.05 315.69,33.05 315.69,33.56 315.71,33.58 315.89,33.58 315.91,33.56 315.91,33.08 315.94,33.05 318.47,33.05 318.71,32.81 318.71,31.49 318.51,31.29 315.55,31.29 315.19,31.65 314.39,31.65 314.1,31.94 314.1,32.84 314.31,33.05 314.85,33.05 314.87,33.08 314.87,33.56 314.9,33.58 315.1,33.58
+19.5VB on TOP (solid shape): 142.27,4.27 142.27,3.88 142.3,3.86 142.3,3.78 142.31,3.76 142.83,3.76 142.84,3.75 142.84,3.5 142.29,3.5 142.29,2.96 142.29,2.96 142.85,2.96 142.85,2.72 142.83,2.7 142.74,2.7 142.73,2.71 142.29,2.71 142.28,2.69 142.28,2.21 142.2,2.12 140.56,2.12 140.18,2.51 140.18,4.13 140.34,4.3 142.24,4.3
+19.5VB on TOP (solid shape): 213.56,6.27 213.56,5.73 213.57,5.72 214.1,5.72 214.11,5.73 214.11,6.27 214.11,6.27 214.36,6.27 214.37,6.27 214.37,5.75 214.4,5.73 214.84,5.73 214.87,5.69 214.87,4.49 214.64,4.25 213.07,4.25 212.78,4.54 212.78,5.7 212.8,5.72 213.2,5.72 213.2,5.73 213.28,5.73 213.3,5.75 213.3,6.27 213.31,6.28 213.56,6.28
+19.5VB on TOP (solid shape): 315.78,24.83 315.78,24.32 315.79,24.31 316.47,24.31 316.6,24.17 316.6,23.03 316.41,22.84 316.08,22.84 315.25,22.01 314.45,21.21 314.45,17.7 313.69,16.94 311.95,16.94 311.46,16.45 311.46,13.36 311.35,13.25 310.54,13.25 310.49,13.26 310.44,13.25 306.86,13.25 306.82,13.3 306.82,18.38 307.24,18.8 308.29,18.8 308.3,18.8 308.4,18.78 308.51,18.8 308.52,18.8 308.62,18.8 308.86,19.04 308.86,20.18 309.24,20.18 309.24,20.18 309.38,20.18 309.38,20.88 309.38,20.91 308.86,20.91 308.86,21.36 309.38,21.36 309.38,21.38 309.38,22.08 309.38,22.11 308.86,22.11 308.86,23.53 309.28,23.95 311.7,23.95 312.04,24.29 314.71,24.29 314.72,24.31 314.72,24.84 314.73,24.85 314.95,24.85 314.97,24.83 314.97,24.3 314.98,24.29 315.52,24.29 315.53,24.3 315.53,24.85 315.53,24.86 315.75,24.86
+19.5VB on TOP (solid shape): 96.46,25.07 103.24,25.07 104.23,24.08 104.37,23.94 104.37,19.89 103.55,19.07 102.05,19.07 101.62,18.64 101.62,16.26 101.21,15.85 99.38,15.85 99.05,15.51 99.05,11.23 98.18,10.36 98.18,9.03 98.03,8.89 96.36,8.89 96.36,8.89 96.2,8.73 95.85,8.73 95.77,8.81 95.77,9.6 96.26,10.08 96.26,15.5 99.18,18.42 99.24,18.42 99.29,18.43 99.35,18.44 99.4,18.47 99.44,18.49 99.49,18.53 99.52,18.57 99.55,18.61 99.58,18.66 99.59,18.71 99.6,18.77 99.61,18.82 99.6,18.88 99.59,18.93 99.57,18.98 99.54,19.03 99.51,19.07 99.49,19.09 99.49,19.67 101.06,21.23 101.06,21.25 101.07,21.27 101.07,22.16 101.07,22.24 101.07,22.69 101.5,22.69 101.5,21.24 101.99,20.75 102.85,20.75 103.25,21.15 103.25,22.72 102.87,23.1 101.91,23.1 101.5,22.69 101.07,22.69 101.07,23.14 101.06,23.15 101.06,23.23 100.6,23.69 95.71,23.69 94.81,24.59 93.22,24.59 92.8,25.02 92.8,25.71 93,25.91 95.62,25.91
+19.5VB on TOP (solid shape): 119.55,3.34 119.55,1.72 119.29,1.46 116.56,1.46 116.47,1.52 116.48,1.63 116.19,2.19 115.9,1.63 115.91,1.52 115.82,1.46 115.1,1.46 114.94,1.63 114.94,2.79 115.08,2.93 116.26,2.93 116.28,2.95 116.28,3.47 116.29,3.48 116.54,3.48 116.54,3.47 116.54,2.94 116.56,2.93 117.05,2.93 117.08,2.96 117.08,3.47 117.09,3.48 117.33,3.48 117.34,3.47 117.34,2.93 117.35,2.93 117.97,2.93 117.99,2.94 118.18,3.13 118.18,3.48 118.28,3.57 119.32,3.57
+19.5VB on TOP (solid shape): outline of 83 points within 61.03,8.95 64.73,13.46
+19.5VB on TOP (solid shape): outline of 371 points within 72.63,1.26 90.53,12.28
+19.5VB on BOTTOM (solid shape): 76.39,54.9 76.39,53.87 76.23,53.7 75.11,53.7 75.05,53.76 75.05,54.93 75.19,55.08 76.21,55.08
+19.5VB on BOTTOM (solid shape): 75.3,12.22 75.3,10.18 76.02,9.45 76.02,9.08 75.52,8.57 72.79,8.57 72.66,8.71 72.66,9.74 73.18,10.26 73.18,10.26 73.18,10.3 73.19,10.31 73.19,10.78 73.18,10.79 73.18,10.84 73.13,10.84 73.1,10.86 72.68,10.86 72.68,11.14 73.18,11.14 73.18,11.64 72.68,11.64 72.68,11.94 73.18,11.94 73.18,12.39 73.2,12.41 75.11,12.41
+19.5VB on BOTTOM (solid shape): 280.86,138.59 280.9,138.32 280.97,137.53 281.24,135.14 281.27,134.79 281.48,128.38 281.54,127.75 281.69,126.12 283.75,110.82 283.73,110.8 283.73,102.95 283.49,102.72 282.96,102.75 282.99,102.22 281.86,101.09 281.86,100.96 281.82,100.95 281.54,100.6 281.82,100.26 281.86,100.24 281.86,99.71 281.86,99.7 281.83,99.57 281.86,99.44 281.86,99.43 281.86,98.83 281.54,98.51 278.86,98.51 278.86,97.97 278.61,97.97 278.61,98.51 278.06,98.51 278.06,97.97 277.81,97.97 277.81,98.51 276.94,98.51 276.61,98.84 276.61,99.73 276.92,100.04 278.9,100.04 279.49,100.63 279.49,102.34 279.49,102.34 279.49,102.64 279.19,102.93 279.19,104.13 278.8,104.53 278.8,108.41 277.32,109.88 277.32,110.97 276.32,111.97 276.32,112.06 276.32,113.9 274.97,115.24 274.97,118.55 274.55,118.97 274.55,125.07 273.33,126.29 273.33,138.15 273.79,138.61 280.84,138.61
+19.5VB on BOTTOM (solid shape): outline of 331 points within 86.46,24.85 94.78,38.58
+19.5VB on BOTTOM (solid shape): outline of 1120 points within 140.22,1.32 204.79,9.75
+19.5VB on IN4 (solid shape): outline of 4045 points within 60.08,1.67 90.6,25.03
+19.5VB on IN1: 75.83,48.59 76.45,49.21 76.45,51.78 76.16,52.07 76.16,53.71 76.01,53.87 75.97,53.9 75.07,53.9 74.87,54.1 74.87,54.87 75.04,55.03 77.24,55.03 77.77,54.5 77.77,48.42 77.26,47.9 77.26,43.19 77.18,42.97 77.26,42.75 77.26,40 77.37,39.89 79.06,39.89 79.6,40.44 81.37,40.44 81.89,39.91 87.28,39.91 88.4,38.79 88.4,37.69 88.4,37.68 88.4,37.43 87.97,37 82.42,37 82.07,36.65 76.29,36.65 75.83,37.11
+19.5VB on VCC: outline of 92 points within 72.61,1.22 326.99,138.71 ; 5 cut-outs
+19.5VB on IN3: outline of 232 points within 83.04,1.67 175.04,9.51
+19.5VB on IN3: outline of 338 points within 197.6,1.29 331.17,37.53
+19.5VB_CHARGER on TOP (solid shape): 302.32,24.05 308.46,24.05 308.73,23.78 308.73,21.98 309.25,21.98 309.25,21.48 308.73,21.48 308.73,20.78 309.25,20.78 309.25,20.38 309.18,20.31 308.7,20.31 308.7,19.58 308.62,19.5 308.23,19.5 307.91,19.18 307.34,19.18 306.38,18.21 306.38,18 306.38,17.99 306.38,17.64 306.26,17.52 303.01,17.52 302.72,17.81 302.72,18.75 302.72,18.98 302.16,19.54 297.77,19.54 297.71,19.6 297.71,24.2 297.78,24.28 302.09,24.28
+19.5VB_CHARGER on BOTTOM (solid shape): 305.71,19.32 305.71,18.24 305.57,18.09 304.11,18.09 303.96,18.24 303.96,19.32 304.13,19.49 305.55,19.49
+19.5VB_CPU on TOP (solid shape): 270.84,123.07 270.84,120.58 270.35,120.09 268.37,120.09 268.03,120.44 268.03,123.21 268.16,123.35 270.56,123.35
+19.5VB_CPU on TOP (solid shape): 213.42,132.73 214.1,132.73 214.26,132.57 214.26,132.05 214.43,131.88 215.7,131.88 215.92,131.65 215.92,130.5 215.84,130.42 212.85,130.42 212.81,130.38 208.5,130.38 208.31,130.56 208.31,132.32 208.98,132.99 213.17,132.99
+19.5VB_CPU on TOP (solid shape): outline of 181 points within 219.45,134.87 252.72,145.27
+19.5VB_CPU on BOTTOM (solid shape): 272.77,136.44 272.77,132.99 272.56,132.78 268.38,132.78 268.14,133.03 268.14,136.28 268.39,136.53 272.68,136.53
+19.5VB_CPU on BOTTOM (solid shape): 268.57,128.1 268.57,126.75 268.72,126.6 269.38,126.6 269.56,126.42 269.56,125.79 270.14,125.2 271.29,125.2 271.62,124.87 271.62,120.38 271.33,120.09 268.41,120.09 268.04,120.46 268.04,123.26 268.6,123.82 268.6,124.9 268.29,125.21 267.5,125.21 267.32,125.39 267.32,128.1 267.43,128.2 268.47,128.2
+19.5VB_CPU on BOTTOM (solid shape): outline of 2040 points within 207.41,130.42 252.96,144.96
+19.5VB_CPU on IN3 (solid shape): outline of 1960 points within 246.5,120.23 271.9,145.16
+19.5VB_DGFF on TOP (solid shape): 96.05,16.55 96.05,12.44 95.74,12.12 94.08,12.12 93.94,12.27 93.05,12.27 92.87,12.08 92.87,10.75 92.71,10.6 92.27,10.6 92.2,10.66 92.2,10.91 92.08,11.04 90.63,11.04 90.32,10.73 90.32,8.18 90.28,8.02 90.32,7.87 90.32,7.39 90.13,7.21 87.04,7.21 86.87,7.37 86.87,9.3 87.17,9.6 87.17,12.39 87.52,12.75 87.61,12.79 87.7,12.76 88.22,12.83 88.09,13.34 88.09,15.29 89.49,16.69 94.86,16.69 95.02,16.85 95.76,16.85
+19VB_1.2V on TOP (solid shape): 220.67,11.16 220.67,9.44 221.09,9.03 221.09,4.67 221,4.59 216.31,4.59 215.03,5.87 214.51,5.87 214.51,6.42 213.96,6.42 213.96,5.87 213.71,5.87 213.71,6.43 213.16,6.43 213.16,5.87 212.58,5.87 212.28,6.17 212.28,8.78 212.32,8.82 215.5,8.82 216.24,9.56 219.78,9.56 220,9.78 220,11.14 220.08,11.21 220.61,11.21
+19VB_1V on TOP (solid shape): 144.56,5.88 147.06,5.88 147.24,5.69 147.24,2.65 147.06,2.47 146.24,2.47 145.85,2.85 144.62,2.85 143.95,2.19 142.46,2.19 142.41,2.23 142.41,2.54 142.43,2.57 142.51,2.57 142.52,2.56 142.96,2.56 142.98,2.58 142.98,3.07 142.95,3.1 142.42,3.1 142.41,3.12 142.41,3.33 142.45,3.36 142.74,3.36 142.74,3.36 142.95,3.36 142.98,3.39 142.98,3.9 142.97,3.91 142.43,3.91 142.41,3.92 142.41,4.36 142.4,4.36 142.4,4.39 142.24,4.55 141.1,4.55 140.98,4.67 140.98,6.1 141.08,6.2 144.24,6.2
+19VB_1V on BOTTOM (solid shape): 143.77,5.14 143.77,4.79 143.61,4.63 141.02,4.63 140.94,4.71 140.94,5.21 141,5.27 143.64,5.27
+19VB_3V on TOP (solid shape): 113.63,6.07 118.17,6.07 118.48,5.77 119.98,5.77 120.05,5.69 120.05,4.93 119.84,4.72 118.7,4.72 118.05,4.07 118.05,3.18 117.94,3.07 117.82,3.07 117.82,3.07 117.49,3.07 117.48,3.07 117.48,3.61 117.48,3.62 116.94,3.62 116.94,3.62 116.94,3.07 116.94,3.07 116.69,3.07 116.69,3.07 116.69,3.62 116.68,3.62 116.14,3.62 116.14,3.61 116.14,3.07 116.14,3.07 114.62,3.07 112.53,5.16 112.14,5.16 111.9,5.4 111.9,6.19 111.98,6.27 113.43,6.27
+19VB_3VR on TOP (solid shape): 312.59,27.24 313.37,27.24 313.87,27.73 318.5,27.73 318.69,27.55 318.69,26.46 318.57,26.34 317.27,26.34 316.78,25.84 316.78,24.62 316.6,24.44 315.95,24.44 315.93,24.46 315.93,25 315.92,25.01 315.39,25.01 315.38,25 315.38,24.46 315.37,24.45 315.15,24.45 315.14,24.46 315.14,24.98 315.12,25 314.58,25 314.58,24.99 314.58,24.46 314.56,24.44 312.4,24.44 311.93,24.91 311.93,26.39 311.36,26.96 310.47,26.96 310.36,27.06 310.36,27.82 310.45,27.91 311.92,27.91
+19VB_5V on TOP (solid shape): 71.67,10.82 71.67,9.12 71.14,8.59 70.4,8.59 70.3,8.69 70.3,9.35 70.07,9.58 70.07,10.95 70.17,11.05 71.44,11.05
+19VB_5V on BOTTOM (solid shape): 70.73,14.06 70.73,13.43 71.16,13 72.81,13 73.04,12.76 73.04,12.07 72.49,12.07 72.49,11.51 73.04,11.51 73.04,11.27 72.5,11.27 72.5,10.71 73.05,10.71 73.05,10.37 73.05,10.37 71.25,8.56 70.42,8.56 70.27,8.72 70.27,9.4 70.09,9.58 70.09,12.27 69.79,12.58 69.79,14.06 69.89,14.16 70.62,14.16
+19VB_5VR on TOP (solid shape): 317.35,37.74 317.35,33.38 317.15,33.18 316.09,33.18 316.07,33.2 316.07,33.71 316.04,33.74 315.56,33.74 315.53,33.71 315.53,33.2 315.3,33.2 315.28,33.23 315.28,33.74 315.25,33.76 314.72,33.76 314.72,33.2 314.16,33.2 313.93,33.43 313.93,34.27 313.66,34.55 310.53,34.55 309.93,35.15 309.93,35.18 310,35.29 310.13,35.28 310.56,35.43 310.29,35.79 310.27,35.79 310.06,36 309.93,36 309.93,36.58 309.67,36.83 309.18,36.83 309.06,36.95 309.06,37.72 309.13,37.79 310.62,37.79 311.09,37.32 311.09,37.32 311.28,37.13 311.93,37.13 312.69,37.89 317.2,37.89
+19VB_IO on BOTTOM (solid shape): 273.62,98.81 273.62,97.97 274.01,97.59 274.61,97.59 275.02,97.18 276.45,97.18 276.6,97.32 276.6,97.91 277.07,98.38 277.68,98.38 277.68,97.85 278.19,97.85 278.19,98.38 278.48,98.38 278.48,97.85 278.99,97.85 278.99,98.38 279.95,98.38 280.21,98.12 280.21,97.15 280.17,97.13 279.97,96.9 280.03,96.6 280.03,95.67 279.6,95.24 276.7,95.24 276.7,95.24 276.51,95.24 276.28,95.47 274.77,95.47 274.55,95.7 274.55,95.85 274.32,96.08 273.73,96.08 273.65,96.15 273.65,96.57 273.57,96.65 273.53,96.7 273.48,96.74 273.3,96.92 273.3,98.82 273.39,98.91 273.52,98.91
+20V_TBTA_VBUS on TOP (solid shape): 6.53,46.04 6.84,46.04 6.96,45.92 8.03,45.92 8.05,45.9 9.75,45.9 10.52,45.14 11.19,45.14 11.35,44.97 11.35,44.81 11.22,44.67 10.15,44.67 9.31,45.52 8.27,45.52 8.21,45.58 7.9,45.58 7.89,45.59 7.55,45.59 7.49,45.58 6.55,45.58 6.25,45.88 5.62,45.88 5.53,45.96 5.53,46.09 5.61,46.16 6.4,46.16
+20V_TBTA_VBUS on TOP (solid shape): 6.9,48.87 6.92,48.63 7.13,48.51 7.2,48.43 7.96,48.43 7.97,48.43 8.22,48.43 8.28,48.5 11.35,48.5 11.5,48.35 11.5,48.17 11.38,48.05 8.54,48.05 8.52,48.03 8.19,48.03 8.09,48.13 7.97,48.13 7.96,48.12 7.09,48.12 7,48.21 6.99,48.26 6.99,48.33 6.86,48.46 6.77,48.46 6.69,48.47 6.61,48.46 6.47,48.46 6.38,48.37 5.59,48.37 5.53,48.43 5.53,48.61 5.59,48.67 5.63,48.67 6.27,48.67 6.56,48.96 6.81,48.96
+20V_TBTA_VBUS on BOTTOM (solid shape): 6.56,48.99 6.63,48.97 6.7,48.96 6.77,48.97 6.84,48.99 8.16,48.99 8.66,48.49 11.42,48.49 11.49,48.42 11.49,48.17 11.38,48.06 8.17,48.06 7.75,48.48 6.18,48.48 6.14,48.52 4.98,48.52 4.93,48.57 4.93,48.98 4.94,48.99
+20V_TBTA_VBUS on BOTTOM (solid shape): 6.5,46.11 6.6,46.06 6.71,46.04 6.83,46.04 6.86,46.01 9.64,46.01 10.54,45.1 11.26,45.1 11.34,45.03 11.34,44.74 11.29,44.69 9.98,44.69 9.15,45.52 8.27,45.52 8.21,45.58 7.6,45.58 7.6,45.58 4.98,45.58 4.93,45.64 4.93,46.03 5.01,46.11
+20V_TBTA_VBUS on BOTTOM (solid shape): 9.94,42.07 10.15,41.96 10.21,41.89 10.21,41.51 10.79,40.93 11.67,40.93 11.75,40.85 11.75,39.84 11.36,39.45 11.25,39.45 11.07,39.28 10.84,39.04 10.84,38.56 11.26,38.14 12.59,38.14 13.03,37.7 13.03,36.2 13.14,36.08 14.53,36.08 14.68,35.93 14.68,34.16 14.62,34.11 13.99,34.11 13.92,34.17 13.92,34.4 13.5,34.82 12.4,34.82 11.79,35.44 9.22,35.44 8.67,35.99 8.67,36.96 8.32,37.31 8.32,41.55 8.07,41.8 8.07,42.04 8.46,42.43 8.46,42.45 8.71,42.71 8.99,42.71
+20V_TBTA_VBUS on VCC: 2.37,44.86 2.37,47.59 4.01,49.22 11.98,49.22 12.07,49.13 12.07,42.53 11.8,42.25 11.8,39.04 11.03,38.28 6.91,38.28 6.57,38.62 6.57,39.97 3.96,42.57 3.96,43.27
+20V_TBTA_VBUS on IN3: 6.93,38.28 6.58,38.62 6.58,39.97 3.97,42.58 3.97,43.3 2.38,44.88 2.38,47.58 4.03,49.22 12.01,49.22 12.16,49.07 12.16,39.31 11.13,38.28
+20V_TBTB_VBUS on TOP (solid shape): 6.53,62.24 6.92,62.24 7.04,62.12 7.83,62.12 7.85,62.1 8.3,62.1 8.35,62.14 9.4,62.14 11.05,60.5 11.05,60.29 10.92,60.16 10.69,60.16 9.18,61.67 8.41,61.67 8.29,61.78 7.83,61.78 7.78,61.83 7,61.83 6.94,61.78 6.55,61.78 6.25,62.08 5.6,62.08 5.54,62.14 5.54,62.3 5.61,62.36 6.4,62.36
+20V_TBTB_VBUS on TOP (solid shape): 17.35,63.08 17.35,63.08 17.38,63.05 17.38,62.07 17.53,61.91 17.53,61.74 17.38,61.59 17.38,61.35 18.48,60.25 19.21,60.25 21.67,57.79 21.67,57.61 22.22,57.06 22.43,57.06 22.86,57.49 23.1,57.49 23.76,56.82 23.76,56.44 21.6,54.28 21.3,54.28 20.51,55.07 20.03,55.07 19.31,55.8 19.31,56.14 19.55,56.38 19.55,57.17 18.62,58.1 18.42,58.1 15.76,60.76 15.67,60.88 15.31,61.56 15.31,61.61 15.31,63.06 15.54,63.29 17.14,63.29
+20V_TBTB_VBUS on TOP (solid shape): 6.9,65.08 6.92,64.83 7.13,64.71 7.2,64.63 7.96,64.63 8.1,64.49 10.69,64.49 10.9,64.46 11.09,64.35 11.42,64.03 11.42,63.78 11.3,63.66 10.92,63.66 10.55,64.04 8.25,64.04 7.96,64.32 7.06,64.32 7,64.38 7,64.41 7,64.52 6.82,64.7 6.44,64.7 6.31,64.57 5.65,64.57 5.55,64.67 5.55,64.81 5.62,64.87 5.63,64.87 6.27,64.87 6.56,65.16 6.81,65.16
+20V_TBTB_VBUS on BOTTOM (solid shape): 6.45,62.24 9.31,62.24 11.07,60.49 11.07,60.27 10.95,60.15 10.69,60.15 9.19,61.66 8.43,61.66 8.14,61.78 6.8,61.78 6.76,61.78 6.72,61.78 6.68,61.78 6.64,61.78 6.47,61.78 6.33,61.64 5.23,61.64 5.15,61.72 5.15,62.19 5.27,62.31 6.39,62.31
+20V_TBTB_VBUS on BOTTOM (solid shape): 7.67,64.49 10.75,64.49 10.94,64.46 11.11,64.36 11.87,63.6 11.87,63.46 11.64,63.23 11.46,63.23 10.61,64.09 7.44,64.09 6.86,64.66 6.67,64.67 6.52,64.66 6.32,64.46 6.32,64.46 6.16,64.3 6.16,63.65 6.08,63.57 5.55,63.57 5.48,63.64 5.48,64.67 5.96,65.15 7.01,65.15
+20V_TBTB_VBUS on IN2 (solid shape): outline of 290 points within 5.91,59.65 17.55,65.36
+20V_TBTB_VBUS on VCC: 43.72,40.93 43.26,41.4 40.93,41.4 40.6,41.06 31.96,49.7 35.05,52.79 37.77,52.15 40.53,51.72 40.53,45.2 41.41,43.06 43.55,42.18 46.92,42.18 46.92,41.27 46.58,40.93
+20V_TBTB_VBUS on VCC: 5.91,60.92 5.91,65.04 6.23,65.36 15.12,65.36 18.38,62.1 18.38,59.18 17.63,58.42 15.19,58.42 15.14,58.47 15.14,58.8 14.32,59.62 7.21,59.62
+20V_VBUS_1 on TOP (solid shape): 45.32,22.46 45.32,18.25 45.12,18.06 41.64,18.06 41.43,18.26 41.43,18.84 41.79,19.2 42.2,19.2 42.95,19.94 42.95,20.82 42.49,21.28 42.32,21.28 42.31,21.29 42.14,21.33 41.97,21.29 41.96,21.28 41.7,21.28 41.66,21.3 41.51,21.45 41.51,22.87 41.66,23.03 41.68,23.03 41.76,23.1 44.67,23.1
+20V_VBUS_1 on TOP (solid shape): 52.67,22.45 52.67,21.42 52.88,21.2 53.26,21.2 53.27,21.19 53.44,21.15 53.61,21.19 53.63,21.2 53.89,21.2 54.45,21.75 54.45,21.92 54.61,22.08 55.17,22.08 55.19,22.06 55.19,21.55 54.84,21.19 54.84,20.98 54.19,20.33 51.95,20.33 51.76,20.41 51.56,20.33 51.22,20.33 51.2,20.32 51.18,20.32 51.16,20.29 51.09,20.29 50.86,20.07 50.79,20.07 50.75,20.06 50.51,19.97 50.4,19.75 50.39,19.69 50.01,19.69 49.86,19.84 49.86,20.32 49.75,20.44 49.46,20.44 49.25,20.64 49.25,20.86 49.43,21.04 50.7,21.04 51.15,21.49 51.15,21.49 51.51,21.85 51.51,22.25 51.55,22.27 51.65,22.36 51.71,22.48 51.72,22.49 51.95,22.72 52.4,22.72
+20V_VBUS_1 on BOTTOM (solid shape): 12.21,34.6 13.33,34.6 13.69,34.25 13.74,34.2 13.76,34.13 13.76,33.14 13.85,33.04 16.7,33.04 16.71,33.03 16.71,32.99 16.73,32.97 16.73,32.13 15.91,31.32 14.99,31.32 14.62,30.95 14.62,30.63 13.82,29.84 11.28,29.84 11.16,29.95 11.16,30.46 11.16,30.46 11.21,31.1 11.16,31.74 11.16,31.74 11.16,31.87 11.13,31.9 11.12,31.92 10.77,32.88 10.16,33.71 10.16,34.89 10.45,35.18 11.63,35.18
+20V_VBUS_1 on BOTTOM (solid shape): 50.49,20.78 50.49,20.15 48.84,18.51 47.99,18.51 47.84,18.66 47.84,18.67 47.52,18.9 47.18,18.7 47.12,18.64 47.04,18.64 46.99,18.64 46.94,18.65 46.62,18.44 46.67,18.06 46.64,17.99 46.57,17.96 44.67,17.96 44.4,18.05 44.14,17.96 43.4,17.96 43.13,18.05 42.87,17.96 42.14,17.96 42,18.11 37.93,18.11 37.87,18.05 37.87,17.16 38.03,17 38.03,15.95 37.94,15.86 35.88,15.86 35.78,15.97 35.78,18.65 36.72,19.59 37.32,19.59 37.8,20.07 39.41,20.07 39.49,19.99 39.49,19.33 39.71,19.11 41.82,19.11 41.88,19.11 41.88,19.11 42.05,19.11 42.08,19.13 42.9,19.96 48.4,19.96 49.45,21 50.27,21
+20V_VBUS_1 on VCC: outline of 85 points within 3.62,6.49 44.82,36.75
+20V_VBUS_1 on IN3: 31.77,15.41 30.83,16.35 30.83,17.94 31.51,18.63 41.42,18.63 41.84,19.05 42.08,19.05 42.97,19.94 44.23,19.94 45.07,19.1 45.07,17.38 43.1,15.41 33.97,15.41 33.96,15.43 33.63,15.66 33.29,15.43 33.28,15.41 33.09,15.41 32.77,15.55 32.44,15.41
+20V_VBUS_2 on TOP (solid shape): 26.21,56.59 27.48,55.89 27.59,55.8 27.6,55.68 27.6,55.29 27.13,54.82 26.01,53.7 25.61,54.1 25.12,54.1 24.43,53.41 22.29,53.41 21.76,53.94 21.76,54.25 24.02,56.52 24.02,57.5 24.18,57.65 24.18,57.65 24.23,57.7 24.47,57.7
+20V_VBUS_2 on BOTTOM (solid shape): 48.91,23.97 48.98,23.92 49.29,23.62 49.29,22.16 49,21.86 49,20.81 48.39,20.2 42.96,20.2 42,19.24 41.82,19.23 39.77,19.23 39.61,19.39 39.61,20.86 39.61,20.86 39.41,21.06 37.98,21.06 37.87,21.17 36.45,21.17 36.31,21.31 36.31,22.87 36.75,23.3 38.54,23.3 38.83,23.19 39.1,23.35 43.4,23.35 43.65,23.09 43.65,21.57 44.06,21.16 44.19,21.16 44.2,21.16 44.4,21.11 44.61,21.16 44.62,21.16 47.41,21.16 47.74,21.49 47.74,21.51 47.76,21.52 48.25,21.71 48.01,22.18 48.01,23.75 48.3,24.03 48.84,24.03
+20V_VBUS_2 on IN2 (solid shape): outline of 230 points within 14.14,29.32 27.68,57.64
+20V_VBUS_2 on VCC: 20.63,19.1 12.86,26.87 12.86,28.71 13.36,29.2 13.36,30.84 12.86,31.34 12.86,34.84 10.59,37.11 12.31,38.83 12.31,42.04 12.58,42.32 12.58,55.55 13.88,56.85 14.51,56.88 14.54,57.5 14.92,57.89 17.84,57.89 19.64,59.69 21.78,59.69 24.16,57.87 29.13,55 34.49,52.95 28.75,47.21 28.63,47.09 28.63,47.09 26.77,45.23 26.77,45.23 24.17,42.63 24.17,32.27 29.48,26.96 30.25,26.96 30.26,26.96 35.39,26.96 38.25,24.09 39.53,24.09 43.1,20.52 42.91,20.34 42.9,20.34 42.75,20.19 42.75,20.17 42.67,20.09 42.53,20.09 42.25,19.81 42.25,19.64 42.06,19.44 41.76,19.44 41.76,19.45 41.55,19.45 41.2,19.1 ; 6 cut-outs
+20V_VBUS_DC_SS1 on TOP (solid shape): 42.03,17.92 42.22,17.87 42.4,17.92 42.41,17.93 42.61,17.93 42.62,17.92 42.8,17.87 42.98,17.92 42.99,17.93 43.2,17.93 43.22,17.92 43.4,17.87 43.59,17.92 43.6,17.93 43.85,17.93 43.86,17.92 44.04,17.88 44.21,17.92 44.22,17.93 45.01,17.93 45.4,17.53 45.4,15.96 45.98,15.39 49.67,15.39 49.75,15.31 49.75,13.95 49.49,13.69 40.38,13.69 40.24,13.84 40.24,17.77 40.4,17.93 42.02,17.93
+20V_VBUS_DC_SS2 on BOTTOM (solid shape): 42.09,17.84 42.91,17.84 42.94,17.86 43,17.89 43.05,17.91 43.21,17.91 43.27,17.89 43.32,17.86 43.36,17.84 44.18,17.84 44.21,17.86 44.27,17.89 44.32,17.91 44.48,17.91 44.54,17.89 44.59,17.86 44.63,17.84 46.16,17.84 46.48,17.52 46.48,15.83 46.92,15.38 49.67,15.38 49.75,15.31 49.75,13.95 49.49,13.69 40.4,13.69 40.24,13.86 40.24,17.57 40.24,17.58 40.24,17.72 40.44,17.91 42.01,17.91
+VCC_CORE on TOP (solid shape): outline of 142 points within 223.5,95.12 232.01,97.1
+VCC_CORE on TOP (solid shape): outline of 415 points within 232.31,95.12 243.46,97.04
+VCC_CORE on TOP (solid shape): outline of 2693 points within 224.19,107.32 251.02,126.99
+VCC_CORE on IN2 (solid shape): outline of 4036 points within 224.1,95.84 249.26,126.44
+VCC_CORE on IN3 (solid shape): outline of 2770 points within 223.91,107.17 249.25,127.11
+VCC_CORE on IN4 (solid shape): outline of 4056 points within 224.14,95.91 249.2,126.6
+VCC_CORE on BOTTOM: outline of 146 points within 223.76,95.81 249.17,126.47
+VCC_CORE on VCC: 226.53,109.07 226.53,118.64 223.87,121.3 223.87,125.86 225.36,127.35 229.85,127.35 230.1,127.11 246.95,127.11 247.45,126.61 249.27,126.61 249.26,122.1 243.42,116.26 243.42,109.07
+VCC_GT on TOP (solid shape): outline of 2419 points within 243.85,96.98 259.97,126.54
+VCC_GT on BOTTOM (solid shape): outline of 1482 points within 244.1,95.46 259.32,130.84
+VCC_GT on IN2 (solid shape): outline of 3053 points within 244.02,96.22 259.51,126.49
+VCC_GT on IN3 (solid shape): outline of 1626 points within 243.94,109.01 259.82,126.6
+VCC_GT on IN4 (solid shape): outline of 3196 points within 243.8,96.22 259.58,126.9
+VCC_GT on VCC: 243.93,109.07 243.93,116.04 249.77,121.89 249.77,126.6 258.56,126.6 259.81,125.35 259.81,110.96 257.92,109.07
+VCC_SA on TOP (solid shape): 212.89,125.46 215.68,125.46 215.83,125.32 215.83,124.32 215.81,124.3 214.92,124.3 214.92,123.54 215.8,123.54 215.84,123.49 215.84,123.36 215.85,123.36 215.85,122.55 216.14,122.26 216.14,121.57 216.14,121.56 216.12,121.46 216.14,121.37 216.14,121.36 216.14,121.18 215.98,121.02 215.87,121.02 215.87,120.92 215.85,120.89 215.85,120.88 215.71,120.74 215.71,119.13 215.2,118.62 211.59,118.62 211.5,118.71 211.5,125.83 211.63,125.96 212.38,125.96
+VCC_SA on TOP (solid shape): outline of 288 points within 223.46,107.32 226.13,114.48
+VCC_SA on BOTTOM (solid shape): outline of 805 points within 211.67,107.55 226.76,125.96
+VCC_SA on IN3 (solid shape): outline of 1253 points within 211.91,109.55 226.32,125.91
+VCC_SA on VCC: 219.67,107.4 218,109.07 214.19,109.07 211.29,111.97 211.29,124.84 212.29,125.84 223.36,125.84 223.36,121.09 226.02,118.43 226.02,109.07 221.35,109.07
+VCC_SFR_OC on TOP (solid shape): outline of 97 points within 273.57,82.61 276.74,86.8
+VCC_SFR_OC on IN4 (solid shape): 224.99,95.39 224.99,95.06 224.68,94.75 224.48,94.75 224.47,94.74 224.44,94.74 224.2,94.65 224.11,94.41 224.11,94.4 224.09,94.39 223.98,94.36 223.92,94.46 223.46,94.74 223.4,94.21 223.44,94.13 223.39,94.05 223.32,93.97 223.27,93.88 223.26,93.82 223.26,93.75 223.23,93.65 223.13,93.61 222.62,93.61 222.45,93.79 222.45,94.51 222.45,94.53 222.47,94.63 222.46,94.74 222.45,94.78 222.78,95.11 222.79,95.11 222.86,95.13 222.92,95.17 222.93,95.18 223.01,95.18 223.46,95.64 223.89,95.64 224.1,95.84 224.53,95.84
+VDD_SUPPLY on TOP (solid shape): 56.22,33.31 56.22,32.24 56.1,32.13 56.03,31.98 56.02,31.8 56.1,31.64 56.12,31.6 56.1,31.56 56.05,31.48 56.02,31.39 56.01,31.31 56.01,31.23 55.97,31.19 55.92,31.18 55.43,31.18 55.35,31.25 55.35,31.73 55.37,31.73 55.56,31.97 55.5,32.28 55.5,33.47 55.56,33.53 55.99,33.53
+VDDA_AVDD1 on TOP (solid shape): 347.06,30.27 347.18,30.27 347.22,30.23 347.22,29.66 347.46,29.42 347.46,28.5 347.46,27.68 347.18,27.4 346.89,27.4 346.87,27.41 346.64,27.35 346.52,27.15 346.51,27.08 346.47,27.04 346.31,27.04 346.26,27.1 346.26,27.57 346.45,27.77 346.45,27.89 346.6,28.04 346.6,28.92 346.27,29.25 346.27,29.68 346.13,29.82 346.13,30.13 346.28,30.28 347.05,30.28
GND on TOP (solid shape): 87.74,16.6 87.74,13.45 87.64,13.34 84.05,13.34 83.75,13.64 83.75,16.55 84.07,16.87 87.48,16.87
GND on TOP (solid shape): 150.66,44.52 150.66,41.02 150.54,40.9 142.04,40.9 141.91,41.03 141.91,44.52 142.02,44.62 150.56,44.62
GND on TOP (solid shape): 175.87,144.29 175.87,142.62 175.69,142.44 172.99,142.44 172.8,142.63 172.8,144.02 173.26,144.48 175.67,144.48
GND on TOP (solid shape): 191.45,129.71 191.45,126.14 191.35,126.04 187.57,126.04 187.45,126.16 187.45,129.72 187.51,129.79 191.37,129.79
GND on TOP (solid shape): 230.01,140.59 230.01,139.18 229.91,139.07 227.95,139.07 227.86,139.17 227.86,140.49 228.1,140.73 229.87,140.73
GND on TOP (solid shape): 237.91,143.09 237.91,141.68 237.81,141.57 235.85,141.57 235.76,141.67 235.76,142.81 236.1,143.15 237.86,143.15
