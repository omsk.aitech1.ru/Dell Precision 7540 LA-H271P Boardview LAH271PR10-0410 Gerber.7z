# Allegro board LAH271PR10-0410_Gerber.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
RE532  4.7K_0402_5%  [R_0402]  138.41 16.98 180 bottom
RE536  0_0402_5%  [R_0402]  142.69 32.03 180 bottom
RE539  100_0402_5%  [R_0402]  145.6 17.96 270 top
RE541  100K_0402_5%  [R_0402]  149.49 26.92 180 top
RE543  1M_0402_5%  [R_0402]  149.49 27.83 180 top
RE546  10K_0402_5%  [R_0402]  154.5 28 180 top
RE547  100K_0402_5%  [R_0402]  135.48 34.83 0 bottom
RE548  0_0402_5%  [R0402_0OHM]  129.16 25.06 0 bottom
RE549  100K_0402_5%  [R_0402]  126.82 19.42 0 top
RE550  100K_0402_5%  [R_0402]  124.78 16.97 270 top
RE551  0_0402_5%  [R_0402]  154.5 28.91 180 top
RE552  0_0402_5%  [R0402_0OHM]  141.01 19.78 0 bottom
RE557  10K_0402_5%  [R_0402]  116.32 13.25 90 top
RE561  100K_0402_5%  [R_0402]  131.37 17.4 270 top
RE563  10K_0402_5%  [R_0402]  8.74 9 270 bottom
RE564  10K_0402_5%  [R_0402]  5.03 14.63 270 bottom
RE565  10K_0402_5%  [R_0402]  8.92 17.58 270 bottom
RE566  10K_0402_5%  [R_0402]  10.61 8.55 90 bottom
RE567  10K_0402_5%  [R_0402]  8.02 16.66 90 bottom
RE568  10K_0402_5%  [R_0402]  9.68 9.47 270 bottom
RE569  0_0402_5%  [R_0402]  144.9 32.69 180 top
RE570  0_0402_5%  [R_0402]  142.09 32.69 0 top
RE700  100K_0402_5%  [R_0402]  127.3 21.56 90 bottom
RE701  100K_0402_5%  [R_0402]  128.49 20.17 180 bottom
RE702  1M_0402_5%  [R_0402]  69.05 24.49 270 bottom
RE703  0_0402_5%  [R_0402]  143.13 23.51 180 bottom
RE730  2.2K_0402_5%  [R_0402]  138.08 36.61 90 bottom
RE731  2.2K_0402_5%  [R_0402]  136.87 36.61 90 bottom
RE732  100K_0402_5%  [R_0402]  140.01 15.34 0 top
RE733  100K_0402_5%  [R_0402]  140.01 14.45 0 top
RE734  100K_0402_5%  [R_0402]  140 13.26 0 top
RE735  100K_0402_5%  [R_0402]  143.44 13.07 180 top
RE736  100K_0402_5%  [R_0402]  146.78 17.71 270 top
RE737  100K_0402_5%  [R_0402]  147.66 17.71 270 top
RE738  100K_0402_5%  [R_0402]  148.55 17.71 270 top
RE739  10K_0402_5%  [R_0402]  51.13 2.65 0 bottom
RE740  10K_0402_5%  [R_0402]  51.13 1.76 0 bottom
RE741  10K_0402_5%  [R_0402]  63.1 2.01 180 bottom
RE742  10K_0402_5%  [R_0402]  63.1 2.9 180 bottom
RE743  0_0201_5%  [R_0201]  145.67 24.36 180 top
RE745  0_0402_5%  [R_0402]  142.8 22.55 180 top
RE746  0_0201_5%  [R_0201]  138.19 17.96 0 bottom
RE747  0_0402_5%  [R0402_0OHM]  147.71 27.83 270 top
RE748  100K_0402_5%  [R_0402]  139.92 17.17 270 top
RE749  0_0402_5%  [R0402_0OHM]  125.27 21.56 180 top
RE750  100K_0402_5%  [R_0402]  127.5 28.06 0 bottom
RH1  100K_0402_5%  [R_0402]  178.56 47.35 270 bottom
RH6  0_0402_5%  [R0402_0OHM]  178.38 15.65 90 top
RH28  33_0402_5%  [R_0402]  116.25 32.95 180 top
RH29  33_0402_5%  [R_0402]  137.44 42.9 90 bottom
RH30  20K_0402_5%  [R_0402]  176.23 15.53 90 top
RH37  0_0402_5%  [R0402_0OHM]  127.45 35.3 90 bottom
RH38  30_0402_5%  [R_0402]  176.93 51.67 270 top
RH39  30_0402_5%  [R_0402]  177.99 51.67 270 top
RH42  30_0402_5%  [R_0402]  179.33 50.75 90 top
RH43  0_0402_5%  [R0402_0OHM]  172.15 14.43 90 top
RH44  10M_0402_5%  [R_0402]  173.01 15.32 90 top
RH45  33_0402_5%  [R_0402]  167.69 40.16 0 top
RH46  33_0402_5%  [R_0402]  167.31 41.05 0 top
RH48  33_0402_5%  [R_0402]  167.69 38.38 0 top
RH50  33_0402_5%  [R_0402]  167.13 42.09 0 top
RH56  1K_0402_5%  [R_0402]  164.53 29.03 90 top
RH57  1K_0402_5%  [R_0402]  164.07 31.7 270 top
RH61  4.7K_0402_5%  [R_0402]  165.02 31.8 0 top
RH65  100K_0402_5%  [R_0402]  44.99 38.22 180 bottom
RH66  0_0402_5%  [R0402_0OHM]  172.58 48.19 180 top
RH67  499_0402_1%  [R_0402]  169.08 31.35 180 bottom
RH70  8.2K_0402_5%  [R_0402]  168.98 50.08 270 top
RH73  13_0402_5%  [R_0402]  182.8 52.92 90 top
RH74  10K_0402_5%  [R_0402]  182.28 51.6 0 top
RH75  620_0402_5%  [R_0402]  184.95 48.8 90 top
RH76  10K_0402_5%  [R_0402]  177.69 16.26 90 bottom
RH77  499_0402_1%  [R_0402]  168.05 33.75 180 bottom
RH78  4.7K_0402_5%  [R_0402]  168.05 32.9 180 bottom
RH80  1K_0402_5%  [R_0402]  164.99 29.75 180 bottom
RH81  1K_0402_5%  [R_0402]  164.23 31.7 0 bottom
RH83  1K_0402_5%  [R_0402]  174.25 22.78 180 bottom
RH86  4.7K_0402_5%  [R_0402]  167.87 27.36 180 bottom
RH90  10K_0402_5%  [R_0402]  164.43 44.99 0 top
RH92  1K_0201_5%  [R_0201]  169.31 17.17 180 top
RH93  10K_0201_5%  [R_0201]  171.43 22 90 bottom
RH94  8.2K_0402_5%  [R_0402]  169.02 20.53 180 bottom
RH95  10K_0402_5%  [R_0402]  161.13 22.01 90 bottom
RH97  33_0402_5%  [R_0402]  163.61 21.66 270 bottom
RH99  22_0402_5%  [R_0402]  175.4 26.7 180 bottom
RH100  0_0402_5%  [R0402_0OHM]  331.41 36.59 270 top
RH101  1K_0402_5%  [R_0402]  332.59 36.58 270 top
RH110  10K_0402_5%  [R_0402]  191.15 46.7 270 bottom
RH123  10K_0201_5%  [R_0201]  162.45 26.51 180 bottom
RH124  10K_0201_5%  [R_0201]  164.58 26.04 180 bottom
RH126  10K_0201_5%  [R_0201]  165.7 26.04 0 bottom
RH127  10K_0201_5%  [R_0201]  163.16 27.4 0 bottom
RH128  10K_0201_5%  [R_0201]  161.17 31.03 270 bottom
RH130  10K_0201_5%  [R_0201]  185.18 16.58 270 top
RH131  10K_0201_5%  [R_0201]  186.63 16.65 270 top
RH132  10K_0201_5%  [R_0201]  184.12 16.65 270 bottom
RH133  10K_0201_5%  [R_0201]  184.49 16.58 270 top
RH134  10K_0201_5%  [R_0201]  185.11 16.64 270 bottom
RH152  0_0201_5%  [R_0201]  189.33 48.8 0 top
RH153  1M_0402_1%  [R_0402]  191.98 49.06 180 top
RH154  0_0402_5%  [R0402_0OHM]  186.21 56.17 90 top
RH155  0_0402_5%  [R0402_0OHM]  185.32 56.17 90 top
RH156  30_0402_5%  [R_0402]  184.2 51.72 90 top
RH161  0_0402_5%  [R0402_0OHM]  202.03 44.7 180 top
RH166  0_0402_5%  [R0402_0OHM]  202.03 45.59 180 top
RH167  0_0402_5%  [R0402_0OHM]  200.71 48.39 0 top
RH168  0_0402_5%  [R0402_0OHM]  200.71 49.28 0 top
RH169  0_0402_5%  [R0402_0OHM]  202.03 47.37 180 top
RH170  0_0402_5%  [R0402_0OHM]  202.03 46.48 180 top
RH171  2.7K_0402_1%  [R_0402]  198.47 51.93 180 top
RH177  0_0201_5%  [R_0201]  171.82 65.09 225 bottom
RH178  4.99_0402_1%  [R_0402]  170.8 64.21 135 bottom
RH179  4.99_0402_1%  [R_0402]  170.02 63.44 225 bottom
RH180  1K_0402_5%  [R_0402]  177.12 15.69 90 top
RH181  4.99_0402_1%  [R_0402]  167.99 62.78 315 bottom
RH182  0_0201_5%  [R0201_0OHM]  167.42 62.13 315 bottom
RH183  4.99_0402_1%  [R_0402]  166.79 61.57 315 bottom
RH184  4.99_0402_1%  [R_0402]  166.12 60.92 315 bottom
RH185  0_0402_5%  [R_0402]  165.34 59.15 45 bottom
RH192  100_0402_1%  [R_0402]  200.41 39.37 90 top
RH193  113_0402_1%  [R_0402]  197.21 49.8 90 top
RH198  1M_0402_5%  [R_0402]  176.41 19.7 90 bottom
RH199  100K_0402_5%  [R_0402]  176.76 48.18 0 bottom
RH200  20K_0402_5%  [R_0402]  164.73 18.27 0 top
RH201  20K_0402_5%  [R_0402]  176.89 18.1 180 bottom
RH203  10K_0402_5%  [R_0402]  162.45 25.62 180 top
RH204  10K_0402_5%  [R_0402]  165.75 22.08 180 top
RH214  100K_0402_5%  [R_0402]  164.43 44.1 0 top
RH215  0_0402_5%  [R0402_0OHM]  170.08 19.41 270 bottom
RH221  2.2K_0402_5%  [R_0402]  176.78 46.88 0 bottom
RH222  2.2K_0402_5%  [R_0402]  181.84 42.29 90 bottom
RH223  2.2K_0402_5%  [R_0402]  180.82 42.29 90 bottom
RH224  2.2K_0402_5%  [R_0402]  179.53 45.23 0 bottom
RH225  2.2K_0402_5%  [R_0402]  175.45 50.64 180 top
RH237  0_0402_5%  [R0402_0OHM]  181.53 30.83 180 bottom
RH239  0_0603_5%  [R_0603]  175.04 35.58 180 bottom
RH240  0_0402_5%  [R0402_0OHM]  197.09 40.4 0 bottom
RH241  0_0603_5%  [R_0603]  198.44 47.08 180 bottom
RH242  0_0603_5%  [R0603_0OHM]  172.34 37.56 270 bottom
RH243  10K_0402_5%  [R_0402]  169.32 21.3 180 top
RH246  0_0402_5%  [R0402_0OHM]  180.41 19.92 90 bottom
RH247  0_0603_5%  [R0603_0OHM]  171.2 37.56 180 bottom
RH250  0_0402_5%  [R_0402]  175.73 31.34 0 bottom
RH254  0_1206_5%  [R1206_0OHM]  197.73 17.36 0 bottom
RH255  0_0402_5%  [R_0402]  170.84 20.38 180 bottom
RH256  0_0402_5%  [R0402_0OHM]  186.1 19.34 90 bottom
RH257  0_0402_5%  [R0402_0OHM]  184.12 45.92 270 bottom
RH258  0_0402_5%  [R0402_0OHM]  185.32 46.49 270 bottom
RH259  0_0402_5%  [R0402_0OHM]  198.51 50.67 0 top
RH260  0_0402_5%  [R0402_0OHM]  194.21 37.61 180 bottom
RH267  10K_0402_5%  [R_0402]  167.54 29.3 0 bottom
RH268  10K_0402_5%  [R_0402]  164.82 28.67 180 bottom
RH279  0_1206_5%  [R1206_0OHM]  171.12 26.14 90 bottom
RH286  0_0402_5%  [R0402_0OHM]  195.78 35.38 180 bottom
RH287  0_0402_5%  [R0402_0OHM]  184.98 19.06 90 bottom
RH288  0_0402_5%  [R0402_0OHM]  184.09 19.06 90 bottom
RH290  0_0402_5%  [R0402_0OHM]  193.84 17.47 180 bottom
RH291  0_0402_5%  [R_0402]  173.15 27.59 0 bottom
RH292  0_0402_5%  [R0402_0OHM]  172.61 33.49 180 bottom
RH293  0_0402_5%  [R0402_0OHM]  178.82 30.95 0 bottom
RH294  0_0402_5%  [R0402_0OHM]  172.96 25.25 90 bottom
RH295  0_0402_5%  [R_0402]  169.22 34.6 0 bottom
RH296  0_0402_5%  [R_0402]  178.82 31.83 0 bottom
RH297  0_0402_5%  [R0402_0OHM]  163.88 18.42 90 top
RH298  0_0603_5%  [R0603_0OHM]  167.27 41.8 90 bottom
RH299  0_0402_5%  [R0402_0OHM]  170.62 41.12 315 bottom
RH300  0_0402_5%  [R0402_0OHM]  178.99 19.5 90 bottom
RH302  0_0402_5%  [R0402_0OHM]  192.17 33.73 180 bottom
RH303  0_0402_5%  [R0402_0OHM]  182.81 20.03 90 bottom
RH304  0_0402_5%  [R0402_0OHM]  173.15 28.48 0 bottom
RH305  0_0402_5%  [R0402_0OHM]  173.47 33.49 0 bottom
RH306  0_0402_5%  [R0402_0OHM]  187.71 16.65 90 bottom
RH308  100K_0402_5%  [R_0402]  172.39 23.02 270 bottom
RH309  10K_0402_5%  [R_0402]  170.83 30.9 0 bottom
RH310  10K_0402_5%  [R_0402]  182.73 15.73 90 top
RH311  8.2K_0402_5%  [R_0402]  173 29.64 0 bottom
RH312  51_0402_5%  [R_0402]  180.72 48.53 90 bottom
RH313  51_0402_5%  [R_0402]  182.6 45.69 270 bottom
RH314  51_0402_5%  [R_0402]  182.76 52.66 90 bottom
RH315  51_0402_5%  [R_0402]  180.45 51.67 270 top
RH319  10K_0201_5%  [R_0201]  176.22 42.39 315 bottom
RH324  10K_0402_5%  [R_0402]  183.62 15.73 90 top
RH325  10K_0201_5%  [R_0201]  181.34 19.94 90 bottom
RH326  10K_0201_5%  [R_0201]  179.15 15.88 90 top
RH327  1K_0402_5%  [R_0402]  168.42 26.46 270 bottom
RH328  1K_0402_5%  [R_0402]  167.69 39.27 0 top
RH329  150K_0402_5%  [R_0402]  169.37 27.87 90 bottom
RH330  49.9K_0402_1%  [R_0402]  161.9 36.53 0 top
RH331  4.7K_0402_5%  [R_0402]  161.53 26.51 0 top
RH333  2.2K_0402_5%  [R_0402]  162.37 32.19 180 top
RH334  1K_0402_5%  [R_0402]  167.44 13.93 90 top
RH335  20K_0402_5%  [R_0402]  166.32 13.95 90 top
RH339  10K_0402_5%  [R_0402]  172.99 31.27 0 bottom
RH340  8.2K_0402_1%  [R_0402]  161.91 22.7 90 bottom
RH344  10K_0402_5%  [R_0402]  185.9 15.92 90 top
RH348  10K_0402_5%  [R_0402]  181.83 15.71 90 top
RH349  100K_0402_5%  [R_0402]  179.57 46.44 90 bottom
RH350  100K_0402_5%  [R_0402]  168.48 35.58 180 bottom
RH351  33_0402_5%  [R_0402]  126.56 35.22 90 bottom
RH352  0_0402_5%  [R_0402]  127.47 29.5 180 top
RH353  33_0402_5%  [R_0402]  128.28 31.47 180 top
RH355  10K_0402_1%  [R_0402]  172.99 30.46 0 bottom
RH360  49.9K_0402_1%  [R_0402]  161.91 37.42 0 top
RH361  49.9K_0402_1%  [R_0402]  161.91 34.7 0 top
RH364  1K_0402_5%  [R_0402]  197.02 47.14 90 top
RH365  0_0402_5%  [R0402_0OHM]  196 47.14 90 top
RH371  10K_0402_5%  [R_0402]  163.86 36.41 0 bottom
RH372  10K_0402_5%  [R_0402]  163.85 37.33 0 bottom
RH373  100K_0402_5%  [R_0402]  168.54 35.84 180 top
RH374  2.2K_0402_5%  [R_0402]  161.15 28.09 0 top
RH375  100K_0402_5%  [R_0402]  165.15 27.4 0 bottom
RH376  49.9K_0402_1%  [R_0402]  161.9 35.65 0 top
RH378  10K_0402_5%  [R_0402]  167.66 36.83 0 top
RH379  100_0402_1%  [R_0402]  181.69 27.02 90 bottom
RH380  10K_0402_5%  [R_0402]  183.87 13.53 0 bottom
RH400  10K_0402_5%  [R_0402]  164.9 37.96 180 top
RH401  10K_0402_5%  [R_0402]  166.72 36.71 180 top
RH402  10K_0402_5%  [R_0402]  161.53 24.73 0 top
RH424  10K_0402_5%  [R_0402]  177.41 19.44 90 bottom
RH431  100K_0402_5%  [R_0402]  120.67 8.59 0 top
RH432  499K_0402_1%  [R_0402]  122.43 8.6 0 top
RH433  49.9K_0402_1%  [R_0402]  123.14 11.02 90 top
RH435  60.4_0402_1%  [R_0402]  198.47 52.82 180 top
RH436  0_0201_5%  [R_0201]  191.3 48.32 0 top
RH439  0_0402_5%  [R_0402]  129.49 11.21 270 top
RH440  0_0402_5%  [R0402_0OHM]  130.4 11.2 270 top
RH441  0_0402_5%  [R_0402]  165.97 23.7 180 top
RH442  0_0402_5%  [R0402_0OHM]  152.91 21.82 180 bottom
RH443  0_0402_5%  [R_0402]  169.69 26.39 180 top
RH445  0_0402_5%  [R0402_0OHM]  152.06 25.25 180 bottom
RH446  0_0201_5%  [R_0201]  196.81 88.21 270 top
RH553  10K_0402_5%  [R_0402]  169.83 32.9 180 bottom
RH554  10K_0402_5%  [R_0402]  169.22 33.67 0 bottom
RH555  10K_0402_5%  [R_0402]  171.74 31.7 180 bottom
RH556  10K_0402_5%  [R_0402]  171.74 32.48 180 bottom
RH600  100K_0402_5%  [R_0402]  157.8 28.57 270 bottom
RH601  100K_0402_5%  [R_0402]  187.35 15.89 90 top
RH602  100K_0402_5%  [R_0402]  166.59 21.16 0 top
RH603  10K_0201_5%  [R_0201]  174.94 47.72 0 bottom
RH604  4.7K_0201_5%  [R_0201]  173.64 47.72 0 bottom
RH605  20K_0201_5%  [R_0201]  171.4 46.13 0 bottom
RH606  100K_0201_5%  [R_0201]  170.43 46.12 90 bottom
RH607  100K_0201_5%  [R_0201]  176.65 44.96 270 bottom
RH608  100K_0201_5%  [R_0201]  176.65 43.76 270 bottom
RH609  200_0402_1%  [R_0402]  169.53 45.24 0 top
RH610  200_0402_1%  [R_0402]  170.3 44.39 0 bottom
RH611  200_0402_1%  [R_0402]  170.3 45.26 0 bottom
RH612  150_0402_1%  [R_0402]  168.95 48.18 0 top
RH613  20K_0402_5%  [R_0402]  172.11 46.87 0 bottom
RH614  20K_0402_5%  [R_0402]  172.13 48.33 180 bottom
RH615  2.2K_0402_5%  [R_0402]  188.23 15.9 90 top
RH616  0_0402_5%  [R0402_0OHM]  172.56 47.09 315 top
RH617  75K_0402_5%  [R_0402]  170.36 35.98 180 top
RH619  0_0402_5%  [R0402_0OHM]  44.99 39.01 180 bottom
RH622  0_0402_5%  [R0402_0OHM]  45.75 38.17 90 bottom
RH623  0_0201_5%  [R_0201]  158.29 32.76 180 top
RH624  0_0201_5%  [R0201_0OHM]  158.24 34.61 180 top
RH625  0_0201_5%  [R0201_0OHM]  158.29 33.7 180 top
RH626  0_0201_5%  [R0201_0OHM]  157.69 30.88 0 top
RH628  2.2K_0402_5%  [R_0402]  177.55 44.29 90 bottom
RH629  100K_0201_5%  [R_0201]  151.83 36.07 90 top
RH630  100K_0402_5%  [R_0402]  178.24 38.61 0 bottom
RH631  100K_0201_5%  [R_0201]  208.04 124.72 0 top
RH632  100K_0201_5%  [R_0201]  135.08 17.01 180 bottom
RH633  75K_0201_5%  [R_0201]  160.44 22.53 90 bottom
RH634  100K_0201_5%  [R_0201]  154.66 33.51 0 top
RH635  100K_0201_5%  [R_0201]  279.43 85.12 0 top
RH636  100K_0201_5%  [R_0201]  168.76 42.51 270 top
RH637  100K_0201_5%  [R_0201]  170 39.18 0 top
RH638  100K_0201_5%  [R_0201]  139.94 18.57 270 bottom
RH639  100K_0201_5%  [R_0201]  134.2 12.88 180 bottom
RH640  100K_0201_5%  [R_0201]  158.28 20.27 0 bottom
RH641  100K_0201_5%  [R_0201]  155.89 33.21 270 bottom
RH710  10K_0402_5%  [R_0402]  191.8 16.82 270 bottom
RH711  10K_0402_5%  [R_0402]  189.13 16.82 270 bottom
RH712  10K_0402_5%  [R_0402]  190.02 16.82 270 bottom
RH713  10K_0402_5%  [R_0402]  190.91 16.82 270 bottom
RH714  10K_0402_5%  [R_0402]  155.22 20.55 180 top
RH715  10K_0402_5%  [R_0402]  155.22 21.44 180 top
RH716  10K_0402_5%  [R_0402]  155.22 22.33 180 top
RH717  10K_0402_5%  [R_0402]  155.22 23.22 180 top
RH718  15K_0402_5%  [R_0402]  190.02 16.82 270 top
RH719  15K_0402_5%  [R_0402]  191.8 16.82 270 top
RH720  15K_0402_5%  [R_0402]  190.91 16.82 270 top
RH721  15K_0402_5%  [R_0402]  189.13 16.82 270 top
RH722  33_0402_5%  [R_0402]  132.15 38.98 270 bottom
RH723  33_0402_5%  [R_0402]  133.02 38.99 270 bottom
RH724  33_0402_5%  [R_0402]  133.9 38.98 270 bottom
RH725  33_0402_5%  [R_0402]  134.77 38.99 270 bottom
RH726  33_0402_5%  [R_0402]  129.14 32.36 180 top
RH727  33_0402_5%  [R_0402]  129.15 35.01 180 top
RH728  33_0402_5%  [R_0402]  129.16 34.13 180 top
RH729  33_0402_5%  [R_0402]  129.15 33.24 180 top
RH730  10K_0402_5%  [R_0402]  182.15 16.1 90 bottom
RH731  10K_0402_5%  [R_0402]  192.75 15.65 90 bottom
RH732  0_0402_5%  [R0402_0OHM]  193.64 16.57 270 bottom
RH733  75K_0402_5%  [R_0402]  197.63 31.73 90 bottom
RH734  10K_0402_5%  [R_0402]  131.32 10.01 0 top
RH735  0_0402_5%  [R_0402]  167.49 22.09 180 top
RH736  100K_0402_5%  [R_0402]  164.63 34.64 0 top
RI13  10K_0402_5%  [R_0402]  351.07 44.37 180 top
RI14  22.1K_0402_1%  [R_0402]  347.83 46.3 0 top
RI27  0_0402_5%  [R_0402-NPM]  299.76 9.14 0 top
RI28  0_0402_5%  [R_0402-NPM]  299.76 10.16 0 top
RI29  0_0402_5%  [R_0402-NPM]  300.64 8.04 0 top
RI30  0_0402_5%  [R_0402-NPM]  300.64 7.03 0 top
RI49  0_0402_5%  [R_0402-NPM]  312.45 9.93 270 bottom
RI50  0_0402_5%  [R_0402-NPM]  313.32 9.93 270 bottom
RI60  0_0402_5%  [R_0402-NPM]  350.91 53.64 0 top
RI61  0_0402_5%  [R_0402-NPM]  350.91 52.72 0 top
RI67  10K_0402_5%  [R_0402]  351.3 36.35 0 top
RI68  0_0402_5%  [R_0402-NPM]  353.96 41.28 270 top
RI70  0_0402_5%  [R_0402-NPM]  353.07 41.28 270 top
RI71  22.1K_0402_1%  [R_0402]  348.66 36.41 180 top
RL1  10K_0402_5%  [R_0402]  195.83 126.87 180 bottom
RL2  10K_0402_5%  [R_0402]  195.82 125.87 180 bottom
RL3  0_0402_5%  [R0402_0OHM]  183.52 120.36 270 bottom
RL5  10K_0402_5%  [R_0402]  186.31 119.38 90 bottom
RL6  4.7K_0402_5%  [R_0402]  187.11 121.89 90 bottom
RL7  0_0402_5%  [R0402_0OHM]  184.53 119.38 90 bottom
RL8  0_0603_5%  [R0603_0OHM]  183.67 125.31 180 bottom
RL9  10K_0402_5%  [R_0402]  185.42 120.3 270 bottom
RL10  0_0402_5%  [R0402_0OHM]  186.29 121.89 90 bottom
RL12  1K_0402_1%  [R_0402]  194.91 127.86 0 bottom
RL13  3.01K_0402_1%  [R_0402]  185.38 131.6 90 bottom
RL14  150_0402_5%  [R_0402]  203.66 131.75 90 top
RL15  75_0402_1%  [R_0402]  173.63 151.04 270 top
RL16  75_0402_1%  [R_0402]  175.61 151.01 270 top
RL17  75_0402_1%  [R_0402]  174.67 151.04 270 top
RL18  75_0402_1%  [R_0402]  176.53 151.03 270 top
RL19  150_0402_5%  [R_0402]  221.67 140.72 180 top
RL20  150_0402_5%  [R_0402]  221.7 139.78 180 top
RL29  1M_0402_5%  [R_0402]  198.31 128.73 90 top
RL30  1M_0402_5%  [R_0402]  199.43 133.42 0 top
RL34  0_0402_5%  [R_0402]  184.88 130.36 270 bottom
RL50  4.7K_0402_5%  [R_0402]  182.63 119.44 90 bottom
RL71  0_0402_5%  [R0402_0OHM]  184.66 135.64 90 bottom
RL72  0_0402_5%  [R0402_0OHM]  185.87 135.64 90 bottom
RL73  0_0402_5%  [R0402_0OHM]  187.22 135.64 90 bottom
RL74  0_0402_5%  [R0402_0OHM]  188.44 135.64 90 bottom
RL75  0_0402_5%  [R0402_0OHM]  189.73 135.64 90 bottom
RL76  0_0402_5%  [R0402_0OHM]  190.96 135.63 90 bottom
RL77  0_0402_5%  [R0402_0OHM]  192.81 132.55 90 bottom
RL78  0_0402_5%  [R0402_0OHM]  194.11 132.55 90 bottom
RN1  100K_0402_5%  [R_0402]  345.38 30.05 270 bottom
RN2  100K_0402_5%  [R_0402]  341.15 25.98 0 bottom
RN37  10K_0402_5%  [R_0402]  86.59 39.78 0 bottom
RN99  0_0402_5%  [R0402_0OHM]  87.32 32.44 0 bottom
RN200  10K_0402_5%  [R_0402]  74.13 31.67 180 bottom
RN202  10K_0402_5%  [R_0402]  350.23 12.22 270 top
RN203  10K_0402_5%  [R_0402]  345.91 11.15 90 bottom
RN205  0_0402_5%  [R0402_0OHM]  346.8 11.15 90 bottom
RN207  0_0402_5%  [R0402_0OHM]  86.43 7.59 0 bottom
RN208  10K_0402_5%  [R_0402]  81.12 10.53 90 top
RN216  0_0402_5%  [R_0402]  86.5 21.91 0 bottom
RN217  0_0402_5%  [R_0402]  83.34 52.37 180 bottom
RN218  0_0402_5%  [R_0402]  358.41 11.87 180 top
RN219  0_0402_5%  [R0402_0OHM]  91.13 44.86 270 bottom
RN220  0_0402_5%  [R0402_0OHM]  358.41 12.74 180 top
RN221  0_0402_5%  [R0402_0OHM]  86.5 22.78 0 bottom
RR200  0_0603_5%  [R0603_0OHM]  30.38 9.66 90 bottom
RR201  10K_0402_5%  [R_0402]  30.37 11.96 90 bottom
RR205  6.2K_0402_1%  [R_0402]  27.93 14.15 0 bottom
RR211  10K_0402_5%  [R_0402]  27.35 8.99 90 bottom
RR213  10_0402_5%  [R_0402]  15.97 17.1 90 bottom
RR227  0_0603_1%  [R_0603]  7.37 23.78 90 bottom
RR228  0_0402_5%  [R0402_0OHM]  31.25 13.4 270 bottom
RR229  0_0402_5%  [R0402_0OHM]  20.04 20.48 90 bottom
RR230  0_0402_5%  [R0402_0OHM]  19.13 20.5 90 bottom
RR231  0_0402_5%  [R0402_0OHM]  30.47 15.4 180 bottom
RR232  0_0402_5%  [R_0402]  27.32 15.4 0 bottom
RR233  0_0402_5%  [R0402_0OHM]  12.69 15.07 0 bottom
RR234  0_0402_5%  [R0402_0OHM]  12.69 16.03 0 bottom
RR235  0_0402_5%  [R_0402]  13.76 17.17 180 bottom
RR236  10K_0402_5%  [R_0402]  11.03 23.19 270 bottom
RR237  10K_0402_5%  [R_0402]  13.76 18.06 180 bottom
RR238  10K_0402_5%  [R_0402]  10.3 26.23 270 bottom
RR239  10K_0402_5%  [R_0402]  18.22 20.51 90 bottom
RT1  3.3K_0402_5%  [R_0402]  40.45 43.03 180 top
RT2  2.2K_0402_5%  [R_0402]  37.66 36.44 270 top
RT3  2.2K_0402_5%  [R_0402]  37.77 33.78 90 top
RT4  3.3K_0402_5%  [R_0402]  44.64 33.87 90 top
RT5  10K_0402_5%  [R_0402]  38.99 35.45 180 bottom
RT6  10K_0402_5%  [R_0402]  38.99 34.53 180 bottom
RT7  10K_0402_5%  [R_0402]  38.99 33.66 180 bottom
RT8  10K_0402_5%  [R_0402]  34.61 34.46 0 top
RT9  0_0402_5%  [R_0402]  38.95 36.66 180 bottom
RT11  10K_0402_5%  [R_0402]  26.11 42.91 90 top
RT16  10K_0201_5%  [R_0201]  31.51 42.96 90 top
RT17  10K_0201_5%  [R_0201]  30.94 42.96 90 top
RT20  10K_0402_5%  [R_0402]  36.06 46.04 90 bottom
RT23  100K_0402_5%  [R_0402]  33.53 48.57 90 bottom
RT26  100K_0402_5%  [R_0402]  35.19 39.48 270 top
RT27  100K_0402_5%  [R_0402]  33.89 42.94 90 top
RT33  100K_0402_5%  [R_0402]  35.71 48.54 90 bottom
RT34  3.01K_0402_1%  [R_0402]  35.76 36.56 270 top
RT36  100_0402_5%  [R_0402]  36.17 38.76 90 top
RT37  0_0402_5%  [R_0402]  26.74 41.64 180 top
RT39  4.75K_0402_0.5%  [R_0402]  30.74 45.17 270 top
RT40  0_0402_5%  [R_0402]  21.3 30.13 0 bottom
RT41  200_0402_1%  [R_0402]  15.51 37.42 0 bottom
RT42  200_0402_1%  [R_0402]  15.53 38.36 0 bottom
RT120  0_0402_5%  [R0402_0OHM]  15.21 45.87 180 bottom
RT121  0_0402_5%  [R0402_0OHM]  15.21 46.9 180 bottom
RT122  0_0402_5%  [R0402_0OHM]  14.3 45.87 0 top
RT123  0_0402_5%  [R0402_0OHM]  14.3 46.9 0 top
RT184  100K_0402_5%  [R_0402]  32.22 43.83 0 top
RT219  221K_0201_1%  [R_0201]  13.21 49.22 270 top
RT372  10K_0402_5%  [R_0402]  37.94 40.26 90 top
RT385  0_0201_5%  [R0201_0OHM]  55.91 36.4 270 bottom
RT386  0_0201_5%  [R0201_0OHM]  54.08 35.93 270 bottom
RT387  0_0201_5%  [R0201_0OHM]  59.27 39.45 270 bottom
RT388  0_0201_5%  [R0201_0OHM]  58.26 39.45 270 bottom
RT391  10K_0402_5%  [R_0402]  37.73 48.57 0 bottom
RT392  0_0201_5%  [R0201_0OHM]  37.84 38.63 270 top
RT394  0_0402_5%  [R_0402]  24.04 30.17 180 bottom
RT440  1M_0201_5%  [R_0201]  40.49 50.65 270 top
RT441  0_0201_5%  [R0201_0OHM]  41.08 50.07 90 top
RT445  0_0201_5%  [R_0201]  39.42 44.87 90 top
RT447  10K_0201_5%  [R_0201]  39.2 50.65 270 top
RT448  0_0201_5%  [R0201_0OHM]  40.75 44.87 90 top
RT456  0_0201_5%  [R0201_0OHM]  38.84 44.86 90 top
RT488  221K_0201_1%  [R_0201]  13.21 49.22 270 bottom
RT489  221K_0201_1%  [R_0201]  13.21 49.81 90 bottom
RT490  221K_0201_1%  [R_0201]  11.15 43.13 90 bottom
RT491  221K_0201_1%  [R_0201]  11.15 42.55 270 bottom
RT499  0_0201_5%  [R0201_0OHM]  117.59 14.46 0 top
RT500  0_0201_5%  [R0201_0OHM]  117.59 13.78 0 top
RT501  0_0201_5%  [R0201_0OHM]  121.92 13.24 0 top
RT502  10K_0402_5%  [R_0402]  37.59 42.38 90 top
RT503  2.2K_0402_5%  [R_0402]  35.26 42.4 0 top
RT504  221K_0201_1%  [R_0201]  11.15 42.55 270 top
RT505  100K_0402_5%  [R_0402]  36.83 46.19 90 bottom
RT506  100K_0402_5%  [R_0402]  37.63 46.32 90 bottom
RT507  100K_0402_5%  [R_0402]  38.57 46.21 90 bottom
RT508  100K_0402_5%  [R_0402]  31.88 46.79 90 bottom
RT509  100K_0402_5%  [R_0402]  32.67 48.57 90 bottom
RT510  2.2K_0402_5%  [R_0402]  45.05 32.7 270 top
RT511  2.2K_0402_5%  [R_0402]  54.7 28.31 0 top
RT512  0_0603_5%  [R_0603]  58.88 31.1 0 bottom
RT514  2.2K_0402_5%  [R_0402]  46 32.7 270 top
RT515  2.2K_0402_5%  [R_0402]  57.84 25.82 180 top
RT516  100K_0201_5%  [R_0201]  57.69 39.45 270 bottom
RT517  10K_0201_5%  [R_0201]  50.01 28.66 0 top
RT518  100K_0201_5%  [R_0201]  54.69 35.35 90 bottom
RT519  10K_0201_5%  [R_0201]  49.65 32.61 0 bottom
RT521  10K_0201_5%  [R_0201]  49.54 29.24 0 top
RT522  10K_0201_5%  [R_0201]  49.64 33.2 0 bottom
RT523  100K_0201_5%  [R_0201]  59.84 39.45 270 bottom
RT524  100K_0201_5%  [R_0201]  56.53 36.03 90 bottom
RT525  4.7K_0402_5%  [R_0402]  55.65 31.41 270 top
RT526  1K_0402_5%  [R_0402]  50.01 38.61 0 top
RT527  1K_0402_5%  [R_0402]  48.45 38.98 180 top
RT528  10K_0201_5%  [R_0201]  57.23 37.02 270 bottom
RT529  10K_0402_5%  [R_0402]  47.47 30.42 0 top
RT534  1.3K_0402_1%  [R_0402]  49.43 34.04 0 bottom
RT535  13.3K_0402_1%  [R_0402]  50.9 37.79 180 top
RT536  9.1K_0402_1%  [R_0402]  49.44 34.82 90 bottom
RT537  13.3K_0402_1%  [R_0402]  53.19 34.92 90 bottom
RT538  0_0402_5%  [R0402_0OHM]  12.05 55.82 90 bottom
RT539  0_0402_5%  [R0402_0OHM]  12.05 56.73 270 top
RT540  0_0402_5%  [R0402_0OHM]  13.05 55.82 90 bottom
RT541  0_0402_5%  [R0402_0OHM]  13.05 56.73 270 top
RT542  0_0805_5%  [R0805_0OHM]  37.71 24.6 180 bottom
RT543  300K_0402_5%  [R_0402]  31.64 26.63 270 bottom
RT544  300K_0402_5%  [R_0402]  29.86 25.7 90 bottom
RT545  1M_0402_1%  [R_0402]  38.15 26.92 0 top
RT546  10K_0402_1%  [R_0402]  36.59 28.93 0 bottom
RT547  0_0805_5%  [R0805_0OHM]  40.48 26.34 0 top
RT548  100K_0402_1%  [R_0402]  39.05 25.89 90 bottom
RT549  0_0402_5%  [R0402_0OHM]  38.17 25.89 90 bottom
RT550  0_0402_5%  [R0402_0OHM]  39.06 27.69 180 bottom
RT551  0_0201_5%  [R0201_0OHM]  55.07 40.11 90 top
RT552  0_0201_5%  [R0201_0OHM]  55.95 40.11 90 top
RT553  10K_0402_5%  [R_0402]  35.26 41.46 0 top
RT554  10K_0402_5%  [R_0402]  26.8 38.04 180 top
RT555  0_0201_5%  [R0201_0OHM]  16.44 35.97 0 bottom
RT556  0_0201_5%  [R0201_0OHM]  16.44 35.34 0 bottom
RT557  0_0201_5%  [R_0201]  18.75 35.97 180 bottom
RT558  0_0201_5%  [R_0201]  18.75 35.34 180 bottom
RT559  0_0201_5%  [R0201_0OHM]  19.93 33.08 180 bottom
RT560  0_0201_5%  [R0201_0OHM]  19.93 33.71 180 bottom
RT561  0_0201_5%  [R_0201]  21.3 33.06 0 bottom
RT562  0_0201_5%  [R_0201]  21.3 33.7 0 bottom
RT564  100K_0402_5%  [R_0402]  65.77 20.99 0 bottom
RT565  100_0603_5%  [R_0603]  73.78 24.54 90 top
RT566  100_0603_5%  [R_0603]  46.49 40.68 180 top
RT567  100K_0201_5%  [R_0201]  70.03 24.17 90 top
RT568  100K_0201_5%  [R_0201]  48.01 38.18 180 top
RT569  0_0603_5%  [R_0603]  58.88 29.89 0 bottom
RT570  0_0402_5%  [R0402_0OHM]  49.51 30.47 180 bottom
RT571  51K_0201_1%  [R_0201]  43.01 27.85 90 bottom
RT573  100K_0201_5%  [R_0201]  44.53 27.83 90 bottom
RT574  0_0402_5%  [R0402_0OHM]  68.18 24.59 180 bottom
RT575  51K_0201_1%  [R_0201]  57.96 19.85 90 bottom
RT577  100K_0201_5%  [R_0201]  59.45 20.21 90 bottom
RT578  0_0402_5%  [R_0402]  45.49 34.39 0 top
RT579  0_0201_5%  [R0201_0OHM]  59.62 33.18 0 bottom
RT580  0_0201_5%  [R0201_0OHM]  58.97 31.97 0 bottom
RT581  0_0201_5%  [R0201_0OHM]  52.77 35.73 270 top
RT582  0_0201_5%  [R0201_0OHM]  53.36 35.73 270 top
RT583  100K_0201_5%  [R_0201]  70.01 23.93 90 bottom
RT584  100K_0201_5%  [R_0201]  64.23 22.28 0 top
RT585  56K_0402_1%  [R_0402]  71.16 21.4 0 bottom
RT586  64.9K_0402_1%  [R_0402]  69.84 21.33 90 bottom
RT587  56K_0402_1%  [R_0402]  73.73 21.6 0 top
RT588  64.9K_0402_1%  [R_0402]  71.31 23.13 180 top
RT589  0_0201_5%  [R0201_0OHM]  65.39 23.4 90 top
RT590  0_0201_5%  [R0201_0OHM]  59.62 33.79 0 bottom
RT591  10K_0201_5%  [R_0201]  36.9 38.69 90 top
RT592  10K_0201_5%  [R_0201]  34.58 43.2 0 top
RT593  10K_0402_5%  [R_0402]  36.93 48.55 180 top
RT594  2.2_0201_1%  [R_0201]  18.49 38.16 0 top
RT595  2.2_0201_1%  [R_0201]  18.49 37.55 0 top
RT596  2.2_0201_1%  [R_0201]  20.96 37.71 0 bottom
RT597  2.2_0201_1%  [R_0201]  20.96 38.32 0 bottom
RT598  2.2_0201_1%  [R_0201]  23.09 38.87 180 top
RT599  2.2_0201_1%  [R_0201]  23.09 38.26 180 top
RT600  2.2_0201_1%  [R_0201]  21.59 42.67 180 bottom
RT601  2.2_0201_1%  [R_0201]  21.59 43.28 180 bottom
RT606  0_0201_5%  [R0201_0OHM]  58.5 35.23 90 bottom
RT607  0_0201_5%  [R0201_0OHM]  57.88 35.23 90 bottom
RT608  0_0201_5%  [R0201_0OHM]  51.64 35.03 270 bottom
RT609  0_0201_5%  [R0201_0OHM]  51.07 35.03 270 bottom
RT610  10K_0201_5%  [R_0201]  65.05 22.65 90 bottom
RT611  100K_0201_5%  [R_0201]  122.51 13.82 180 top
RT612  0_0201_5%  [R_0201]  117.59 15.04 0 top
RT613  10K_0201_5%  [R_0201]  38.03 44.75 0 bottom
RT614  100K_0402_5%  [R_0402]  37.07 37.75 180 top
RT615  100K_0402_5%  [R_0402]  180.75 15.9 90 top
RT616  100K_0402_5%  [R_0402]  179.86 15.9 90 top
RT617  100K_0201_5%  [R_0201]  49.28 29.17 270 bottom
RT618  100K_0201_5%  [R_0201]  66.05 24.54 180 bottom
RT619  0_0201_5%  [R0201_0OHM]  33.85 47.86 0 bottom
RT620  0_0201_5%  [R0201_0OHM]  35.03 47.86 0 bottom
RT621  0_0201_5%  [R_0201]  123.73 13.24 180 top
RT622  0_0201_5%  [R_0201]  37.52 50.09 90 top
RT623  2.2_0201_1%  [R_0201]  23.14 34.57 0 bottom
RT624  2.2_0201_1%  [R_0201]  23.14 35.16 0 bottom
RT625  2.2_0201_1%  [R_0201]  23.38 36.79 0 bottom
RT626  2.2_0201_1%  [R_0201]  23.38 36.2 0 bottom
RT627  2.2_0201_1%  [R_0201]  22.94 39.09 180 bottom
RT628  2.2_0201_1%  [R_0201]  22.94 39.68 180 bottom
RT629  2.2_0201_1%  [R_0201]  22.94 41.43 180 bottom
RT630  2.2_0201_1%  [R_0201]  22.94 40.79 180 bottom
RT631  221K_0201_1%  [R_0201]  11.15 43.13 90 top
RT632  221K_0201_1%  [R_0201]  13.21 49.81 90 top
RT633  221K_0201_1%  [R_0201]  9.39 59.24 180 bottom
RT634  221K_0201_1%  [R_0201]  9.97 59.24 0 bottom
RT635  221K_0201_1%  [R_0201]  15.46 57.71 180 bottom
RT636  221K_0201_1%  [R_0201]  16.04 57.71 0 bottom
RT637  221K_0201_1%  [R_0201]  9.39 59.24 180 top
RT638  221K_0201_1%  [R_0201]  9.97 59.24 0 top
RT639  221K_0201_1%  [R_0201]  15.46 57.71 180 top
RT640  221K_0201_1%  [R_0201]  16.04 57.71 0 top
RT641  0_0201_5%  [R_0201]  34.41 49.04 270 bottom
RT642  0_0201_5%  [R_0201]  34.98 49.04 270 bottom
RT643  10K_0201_5%  [R_0201]  37.48 39.29 0 top
RT644  100K_0402_5%  [R_0402]  178.63 15.43 270 bottom
RV3  100K_0402_5%  [R_0402]  132.44 42.64 270 top
RV4  100K_0402_5%  [R_0402]  84.85 39.3 90 top
RV5  47K_0402_5%  [R_0402]  81.71 57.32 0 bottom
RV6  47K_0402_5%  [R_0402]  79.4 23 0 top
RV7  4.7K_0402_5%  [R_0402]  106.64 46.46 270 bottom
RV8  10K_0402_5%  [R_0402]  77.72 34.19 90 top
RV50  4.99K_0402_1%  [R_0402]  195.68 123.31 0 top
RV55  4.7K_0402_5%  [R_0402]  193.26 116.26 0 bottom
RV56  4.7K_0402_5%  [R_0402]  193.55 117.16 180 bottom
RV57  4.7K_0402_5%  [R_0402]  188.86 110.1 0 top
RV58  4.7K_0402_5%  [R_0402]  189.78 111 180 top
RV59  4.7K_0402_5%  [R_0402]  188.88 108.26 90 top
RV60  4.7K_0402_5%  [R_0402]  189.79 109.17 270 top
RV61  4.7K_0402_5%  [R_0402]  190.75 110.1 90 top
RV62  4.7K_0402_5%  [R_0402]  191.73 111.01 270 top
RV63  4.7K_0402_5%  [R_0402]  192.25 108.27 90 top
RV64  4.7K_0402_5%  [R_0402]  193.18 109.18 270 top
RV65  4.7K_0402_5%  [R_0402]  196.59 112.05 180 top
RV66  4.7K_0402_5%  [R_0402]  195.67 113.03 0 top
RV125  4.7K_0402_5%  [R_0402]  193.9 110.25 90 top
RV126  4.7K_0402_5%  [R_0402]  196.6 122.4 180 top
RV127  4.7K_0402_5%  [R_0402]  194.87 110.25 90 top
RV130  1M_0402_5%  [R_0402]  189.38 116.1 180 bottom
RV131  1M_0402_5%  [R_0402]  188.94 118.69 90 bottom
RV323  0_0402_5%  [R0402_0OHM]  79.43 30.54 180 top
RV324  0_0402_5%  [R_0402]  76.53 29.49 90 top
RV326  100K_0402_5%  [R_0402]  77.54 29.5 90 top
RV485  0_0402_5%  [R0402_0OHM]  184.33 99.32 0 top
RV737  0_0201_5%  [R_0201]  109.6 29.34 270 top
RV738  0_0201_5%  [R_0201]  109.6 28.06 270 top
RV739  10K_0402_5%  [R_0402]  108.9 29.29 270 top
RV740  10K_0402_5%  [R_0402]  108.05 29.29 270 top
RV741  1K_0402_5%  [R_0402]  108.03 27.27 0 top
RV742  0_0201_5%  [R_0201]  96.4 36.89 90 top
RV800  0_0402_5%  [R0402_0OHM]  186.79 88.31 90 top
RV803  10K_0402_5%  [R_0402]  181.56 80.8 270 top
RV804  4.7K_0402_5%  [R_0402]  188.58 105.06 270 top
RV805  4.7K_0402_5%  [R_0402]  184.51 104.83 90 top
RV806  10K_0402_5%  [R_0402]  187.78 89.23 270 top
RV807  10K_0402_5%  [R_0402]  187.78 90.12 90 top
RV808  0_0402_5%  [R0402_0OHM]  154.82 42.07 180 top
RV809  0_0402_5%  [R0402_0OHM]  154.82 41.18 180 top
RV812  100K_0402_5%  [R_0402]  181.87 82.69 90 top
RV813  100K_0402_5%  [R_0402]  186.16 82.62 90 top
RV815  10K_0402_5%  [R_0402]  185.83 88.31 90 top
RV816  10K_0402_5%  [R_0402]  189.74 84.21 270 top
RV817  10K_0402_5%  [R_0402]  186.27 86.33 270 top
RV818  100K_0402_5%  [R_0402]  186.79 90.13 90 top
RV819  4.7K_0402_5%  [R_0402]  181.15 93.13 90 top
RV820  10K_0402_5%  [R_0402]  184.61 95.46 0 top
RV821  10K_0402_5%  [R_0402]  182.83 95.46 0 top
RV822  4.7K_0402_5%  [R_0402]  115.85 43.61 90 bottom
RV823  4.7K_0402_5%  [R_0402]  117.16 45.94 180 bottom
RV824  4.7K_0402_5%  [R_0402]  117.55 35.7 0 bottom
RV825  4.7K_0402_5%  [R_0402]  116.98 29.47 270 bottom
RV826  4.7K_0402_5%  [R_0402]  117.72 43.53 90 bottom
RV827  4.7K_0402_5%  [R_0402]  116.8 43.6 90 bottom
RV828  4.7K_0402_5%  [R_0402]  117.9 29.49 270 bottom
RV829  4.7K_0402_5%  [R_0402]  117.55 36.98 0 bottom
RV830  4.7K_0402_5%  [R_0402]  107.54 43.49 90 bottom
RV831  4.7K_0402_5%  [R_0402]  117.55 37.93 0 bottom
RV832  1M_0402_5%  [R_0402]  98.82 36.43 180 bottom
RV833  4.7K_0402_5%  [R_0402]  117.5 40.37 270 bottom
RV834  4.7K_0402_5%  [R_0402]  117.16 41.6 90 bottom
RV835  4.99K_0402_1%  [R_0402]  99.91 36.47 90 bottom
RV836  4.7K_0402_5%  [R_0402]  110.3 47.58 90 bottom
RV839  4.7K_0402_5%  [R_0402]  133.42 49.26 90 top
RV840  100K_0402_5%  [R_0402]  102.83 48.37 270 bottom
RV842  100K_0402_5%  [R_0402]  105.63 48.37 270 bottom
RV843  100K_0402_5%  [R_0402]  94.26 19.75 270 top
RV848  4.7K_0402_5%  [R_0402]  57.1 35.89 180 top
RV849  4.7K_0402_5%  [R_0402]  70.5 37.65 90 bottom
RV850  4.7K_0402_5%  [R_0402]  63.42 26.04 270 top
RV851  4.7K_0402_5%  [R_0402]  61.61 26.04 270 top
RV852  4.7K_0402_5%  [R_0402]  62.55 26.03 270 top
RV853  4.7K_0402_5%  [R_0402]  62.52 24.23 0 top
RV855  100K_0402_5%  [R_0402]  74.15 29.58 0 top
RV856  4.7K_0402_5%  [R_0402]  59.7 33.22 180 top
RV857  4.7K_0402_5%  [R_0402]  60.38 34.32 180 top
RV858  4.7K_0402_5%  [R_0402]  58.61 35.58 90 top
RV861  4.99K_0402_1%  [R_0402]  60.89 29.67 0 top
RV862  4.7K_0402_5%  [R_0402]  155.31 45.05 90 bottom
RV863  4.7K_0402_5%  [R_0402]  142.19 37.85 270 top
RV864  4.7K_0402_5%  [R_0402]  143.97 35.57 270 top
RV865  4.7K_0402_5%  [R_0402]  144.85 35.57 270 top
RV866  4.7K_0402_5%  [R_0402]  142.19 35.57 270 top
RV867  4.7K_0402_5%  [R_0402]  143.08 35.57 270 top
RV868  4.7K_0402_5%  [R_0402]  144.83 37.88 270 top
RV869  100K_0402_5%  [R_0402]  154.15 39.25 0 top
RV870  4.99K_0402_1%  [R_0402]  131.45 41.76 90 top
RV871  4.7K_0402_5%  [R_0402]  139.73 40.92 180 top
RV872  4.7K_0402_5%  [R_0402]  139.58 42.18 180 top
RV873  4.7K_0402_5%  [R_0402]  139.83 43.13 180 top
RV874  4.7K_0402_5%  [R_0402]  139.83 44.14 180 top
RV875  4.7K_0402_5%  [R_0402]  143.97 37.85 270 top
RV876  4.7K_0402_5%  [R_0402]  60.05 29.67 180 top
RV877  4.7K_0402_5%  [R_0402]  57.95 34.05 180 top
RV878  4.7K_0402_5%  [R_0402]  57.95 33.18 180 top
RV879  4.7K_0402_5%  [R_0402]  60.19 31.51 180 top
RV880  4.7K_0402_5%  [R_0402]  61.97 28.34 270 top
RV881  4.7K_0402_5%  [R_0402]  63.14 28.37 270 top
RV882  4.7K_0402_5%  [R_0402]  64.1 28.38 270 top
RV883  4.7K_0402_5%  [R_0402]  61.09 28.34 270 top
RV884  4.7K_0402_5%  [R_0402]  143.08 37.85 270 top
RV885  4.7K_0402_5%  [R_0402]  137.4 44.08 180 top
RV886  4.7K_0402_5%  [R_0402]  137.44 43.09 180 top
RV887  4.7K_0402_5%  [R_0402]  137.69 41.35 180 top
RV888  4.7K_0402_5%  [R_0402]  137.69 42.22 180 top
RV889  100K_0402_5%  [R_0402]  154.15 40.14 0 top
RV890  100K_0402_5%  [R_0402]  74.15 30.47 0 top
RV891  4.7K_0402_5%  [R_0402]  66.85 28.57 270 bottom
RV892  4.7K_0402_5%  [R_0402]  67.77 28.57 270 bottom
RV893  4.7K_0402_5%  [R_0402]  148.16 35.57 270 top
RV894  4.7K_0402_5%  [R_0402]  148.16 37.29 270 top
RV895  1M_0402_5%  [R_0402]  71.7 29.53 270 top
RV896  1M_0402_5%  [R_0402]  149.17 36.38 90 top
RV897  100K_0402_5%  [R_0402]  145.51 46.08 270 bottom
RV898  100K_0402_5%  [R_0402]  65.27 36.24 0 bottom
RV900  10K_0402_5%  [R_0402]  81.74 63.07 180 bottom
RV901  8.2K_0402_5%  [R_0402]  80.85 62.07 270 bottom
RV902  100K_0402_5%  [R_0402]  59.98 36.06 90 top
RV903  100K_0402_5%  [R_0402]  181.01 113.24 180 bottom
RV904  100K_0402_5%  [R_0402]  185.79 80.62 270 top
RV905  100K_0402_5%  [R_0402]  194.16 100.8 0 top
RV907  4.3M_0402_1%  [R_0402]  87.15 35.13 270 top
RV908  3M_0402_1%  [R_0402]  88.79 30.99 270 top
RV909  100K_0402_5%  [R_0402]  86.86 28.41 180 top
RV910  100K_0402_5%  [R_0402]  85.08 30.48 90 top
RV911  1M_0402_1%  [R_0402]  85.08 32.3 0 top
RZ3  0_0201_5%  [R_0201]  338.33 5.06 180 top
RZ4  0_0201_5%  [R_0201]  337.75 5.06 0 bottom
RZ8  4.7K_0402_5%  [R_0402]  139.36 12.95 90 bottom
RZ9  4.7K_0402_5%  [R_0402]  135.58 12.94 90 bottom
RZ10  100K_0402_5%  [R_0402]  126.68 22.95 0 top
RZ18  4.7K_0402_5%  [R_0402]  274.73 8.46 0 top
RZ19  4.7K_0402_5%  [R_0402]  274.73 9.58 0 top
RZ20  2.2K_0402_5%  [R_0402]  273.9 5.34 0 top
RZ21  2.2K_0402_5%  [R_0402]  273.9 6.61 0 top
RZ22  0_0402_5%  [R_0402]  276.57 8.39 0 top
RZ23  0_0402_5%  [R_0402]  276.57 9.58 0 top
RZ25  150_0402_5%  [R_0402]  137.26 8.68 0 top
RZ26  0_0402_5%  [R0402_0OHM]  275.76 5.34 0 top
RZ28  200_0402_5%  [R_0402]  140.44 11.07 0 top
RZ29  0_0402_5%  [R0402_0OHM]  275.73 6.66 0 top
RZ32  470_0402_5%  [R_0402]  316.75 48.68 0 top
RZ43  10K_0402_5%  [R_0402]  286.54 8.26 90 bottom
RZ56  0_0402_5%  [R_0402]  328.97 20.25 90 bottom
RZ58  33_0402_5%  [R_0402]  124.89 27.57 270 top
RZ59  33_0402_5%  [R_0402]  125.33 25.8 180 top
RZ60  33_0402_5%  [R_0402]  125.33 23.94 180 top
RZ61  0_0402_5%  [R0402_0OHM]  125.32 24.88 180 top
RZ62  10K_0402_5%  [R_0402]  121.42 27.5 0 top
RZ63  33_0402_5%  [R_0402]  125.33 23.03 180 top
RZ69  10K_0402_5%  [R_0402]  125.57 20.67 180 top
RZ70  0_0402_5%  [R_0402]  135.23 39.67 0 top
RZ71  0_0402_5%  [R_0402]  136.11 37.53 90 top
RZ78  0_0402_5%  [R_0402]  166.61 34.63 0 top
RZ79  0_0402_5%  [R_0402]  168.36 34.63 0 top
RZ80  0_0402_5%  [R_0402]  170.24 37.24 0 top
RZ81  0_0402_5%  [R_0402]  158.38 31.98 0 top
RZ85  0_0402_5%  [R_0402]  194.99 3.68 270 top
RZ89  0_0402_5%  [R0402_0OHM]  116.56 22.06 90 bottom
RZ112  0_0402_5%  [R0402_0OHM]  119.61 27.52 0 top
RZ114  0_0402_5%  [R_0402]  183.22 14.57 90 bottom
RZ116  10K_0402_5%  [R_0402]  278.49 5.37 180 top
RZ117  10K_0402_5%  [R_0402]  278.49 6.56 180 top
RZ119  0_0402_5%  [R_0402]  273.96 81.99 90 top
RZ120  0_0402_5%  [R0402_0OHM]  276.31 79.18 0 top
RZ128  0_0402_5%  [R_0402]  319.1 3.34 270 top
RZ129  0_0402_5%  [R_0402]  320.6 4.7 270 top
RZ130  0_0402_5%  [R_0402]  320.6 2.89 270 top
RZ151  0_0402_5%  [R_0402]  267.73 110.41 0 top
RZ346  0_0402_5%  [R0402_0OHM]  277.42 10.51 180 top
RZ347  0_0402_5%  [R0402_0OHM]  277.48 7.47 180 top
RZ361  470_0402_5%  [R_0402]  140.17 10.1 0 top
RZ362  10K_0402_5%  [R_0402]  115.94 26.14 180 top
RZ363  0_0402_5%  [R_0402]  115.03 25.25 0 top
RZ364  100_0402_5%  [R_0402]  193.27 3.58 270 top
RZ365  0_0402_5%  [R0402_0OHM]  117.15 17.05 180 bottom
RZ366  0_0402_5%  [R_0402]  121.86 19.15 270 top
RZ367  0_0402_5%  [R_0402]  115.91 21.56 90 top
RZ368  0_0402_5%  [R0402_0OHM]  121.78 16.49 0 top
RZ369  0_0402_5%  [R_0402]  121.78 17.38 0 top
RZ371  0_0402_5%  [R_0402]  333.32 21.44 90 bottom
RZ372  0_0201_5%  [R_0201]  319.43 6.58 90 top
RZ373  0_0201_5%  [R_0201]  319.84 2.94 270 top
RZ374  0_0201_5%  [R_0201]  319.24 4.11 90 top
RZ375  10K_0402_5%  [R_0402]  135.23 36.57 0 top
RZ376  10K_0402_5%  [R_0402]  337.14 6.71 0 bottom
RZ377  100K_0402_5%  [R_0402]  340.68 3.57 270 top
RZ378  100K_0402_5%  [R_0402]  336.91 2.78 90 top
RZ379  20K_0402_5%  [R_0402]  134.32 38.4 0 top
RZ381  100K_0402_5%  [R_0402]  336.96 2 90 bottom
RZ504  10K_0402_5%  [R_0402]  77.07 54.75 0 bottom
RZ505  10K_0402_5%  [R_0402]  299.6 52.02 0 top
RZ507  10K_0402_5%  [R_0402]  82.63 56.52 180 bottom
RZ508  10K_0402_5%  [R_0402]  299.62 51.11 0 top
RZ509  0_0402_5%  [R0402_0OHM]  105.3 22.6 0 bottom
RZ510  0_0402_5%  [R0402_0OHM]  340.29 40.06 90 top
RZ512  100K_0402_5%  [R_0402]  92.51 10.9 0 top
RZ513  100K_0402_5%  [R_0402]  107.28 11.63 0 top
RZ514  20K_0402_5%  [R_0402]  94.07 9.91 180 top
RZ518  20_0603_5%  [R_0603]  296.89 53.83 90 top
RZ522  0_0402_5%  [R0402_0OHM]  351.14 49.11 0 bottom
RZ523  0_0201_5%  [R_0201]  312.36 11.83 270 bottom
RZ524  0_0201_5%  [R_0201]  311.7 11.83 270 bottom
RZ525  0_0201_5%  [R_0201]  323.33 7 90 bottom
RZ526  0_0201_5%  [R_0201]  322.74 7 90 bottom
RZ527  0_0201_5%  [R_0201]  310.32 9.12 0 bottom
RZ528  0_0201_5%  [R_0201]  310.32 8.56 0 bottom
RZ529  0_0201_5%  [R_0201]  310.53 11.81 0 bottom
RZ530  0_0201_5%  [R_0201]  310.53 11.09 0 bottom
RZ531  22_0402_5%  [R_0402]  336.89 5.45 270 top
RZ532  22_0402_5%  [R_0402]  337.14 5.82 0 bottom
RZ533  22_0402_5%  [R_0402]  321.14 20.18 90 bottom
RZ534  22_0402_5%  [R_0402]  322.05 20.18 90 bottom
RZ535  22_0402_5%  [R_0402]  322.94 20.17 90 bottom
RZ536  22_0402_5%  [R_0402]  325.32 20.35 90 bottom
RZ537  100K_0402_5%  [R_0402]  319.36 9.49 0 top
RZ538  100K_0402_5%  [R_0402]  86.85 26.47 180 top
RZ539  100K_0402_5%  [R_0402]  86.86 27.42 180 top
RZ541  1M_0201_5%  [R_0201]  331.71 27.02 90 top
RZ542  10K_0402_5%  [R_0402]  196.89 91.7 90 top
RZ543  10K_0402_5%  [R_0402]  195.7 87.8 270 top
RZ545  0_0201_5%  [R0201_0OHM]  165.57 33.91 180 top
RZ546  0_0201_5%  [R0201_0OHM]  75.76 25.44 180 top
RZ547  100K_0402_5%  [R_0402]  91.23 6.43 0 top
RZ548  0_0402_5%  [R_0402]  181.87 87.65 270 top
RZ549  0_0402_5%  [R0402_0OHM]  181.87 84.97 90 top
RZ550  0_0603_5%  [R_0603]  80.29 59.9 270 bottom
RZ551  0_0603_5%  [R_0603]  75.68 62.36 270 bottom
RZ1385  10K_0402_5%  [R_0402]  134.32 37.53 0 top
RZ1413  330K_0402_5%  [R_0402]  138.04 13.67 270 top
RZ1415  0_0402_5%  [R0402_0OHM]  137.15 12.74 90 top
RZ1482  1M_0402_5%  [R_0402]  136.17 13.8 270 top
RZ1483  0_0402_5%  [R_0402]  195 6.69 90 top
RZ1484  0_0402_5%  [R_0402]  280.97 4.2 180 top
SW1  SS3-CMFTQR9_3P  [SW_SS3-CMFTQR9_3P]  337.57 29.16 180 top
SW3  SKRBAAE010_4P  [SW_SKRBAAE010_4P]  328.67 35.43 180 top
T1  PAD~D  [TPC12]  213.05 85.66 0 top
T2  PAD~D  [TPC12]  219.51 83.53 180 bottom
T3  PAD~D  [TPC12]  217.4 83.64 180 bottom
T4  PAD~D  [TPC12]  218.49 84.32 180 bottom
T5  PAD~D  [TPC12]  261.22 83.05 180 bottom
T6  PAD~D  [TPC12]  260.62 84.24 180 bottom
T7  PAD~D  [TPC12]  259.46 117.56 180 bottom
T8  PAD~D  [TPC12]  258.41 118.66 180 bottom
T9  PAD~D  [TPC12]  224.78 104.79 180 bottom
T10  PAD~D  [TPC12]  223.28 104.77 180 bottom
T11  PAD~D  [TPC12]  264.7 118.88 180 bottom
T12  PAD~D  [TPC12]  214.79 87.27 180 bottom
T13  PAD~D  [TPC12]  213.22 87.27 180 bottom
T14  PAD~D  [TPC12]  226.72 118.84 180 bottom
T15  PAD~D  [TPC12]  239.74 117.2 0 top
T18  PAD~D  [TPC12]  215.64 110.47 0 top
T19  PAD~D  [TPC12]  209.64 110.98 180 bottom
T20  PAD~D  [TPC12]  220.52 84.32 180 bottom
T21  PAD~D  [TPC12]  216.33 84.35 180 bottom
T22  PAD~D  [TPC12]  258.43 120.02 180 bottom
T23  PAD~D  [TPC12]  265.9 112.59 0 top
T24  PAD~D  [TPC12]  273.12 110.27 180 bottom
T25  PAD~D  [TPC12]  264.5 87.19 180 bottom
T26  PAD~D  [TPC12]  263.3 85.89 180 bottom
T27  PAD~D  [TPC12]  244.57 98.73 180 bottom
T28  PAD~D  [TPC12]  247.23 118.92 180 bottom
T29  PAD~D  [TPC12]  254.58 108.26 180 bottom
T30  PAD~D  [TPC12]  254.6 106.73 180 bottom
T31  PAD~D  [TPC12]  263.23 87.35 180 bottom
T32  PAD~D  [TPC12]  265.79 87.11 180 bottom
T33  PAD~D  [TPC12]  188.41 23.61 180 bottom
T34  PAD~D  [TPC12]  188.11 25.54 270 bottom
T35  PAD~D  [TPC12]  180.58 25.59 180 bottom
T36  PAD~D  [TPC12]  167.84 47.35 0 top
T40  PAD~D  [TPC12]  188.2 45.56 180 bottom
T46  PAD~D  [TPC12]  235.5 28.67 270 bottom
T47  PAD~D  [TPC12]  231.86 35.46 270 bottom
T48  PAD~D  [TPC12]  234.15 34.87 90 top
T49  PAD~D  [TPC12]  233.89 28.71 270 bottom
T50  PAD~D  [TPC12]  233.71 63.05 90 top
T51  PAD~D  [TPC12]  238.1 28.78 270 bottom
T52  PAD~D  [TPC12]  236.8 28.7 270 bottom
T53  PAD~D  [TPC12]  232.42 62.49 90 top
T60  PAD~D  [TPC12]  191.01 37.72 270 bottom
T61  PAD~D  [TPC12]  193.72 39.32 180 bottom
T62  PAD~D  [TPC12]  179.4 26.34 270 bottom
T63  PAD~D  [TPC12]  181.8 23.91 270 bottom
T73  PAD~D  [TPC12]  196.8 127.83 180 bottom
T74  PAD~D  [TPC12]  196.83 125.92 180 bottom
T75  PAD~D  [TPC12]  170.42 44.2 0 top
T76  PAD~D  [TPC12]  191.51 14.55 270 top
T77  PAD~D  [TPC12]  191.57 13.25 0 top
T78  PAD~D  [TPC12]  198.17 31.58 0 top
T79  PAD~D  [TPC12]  190.93 31.3 180 bottom
T80  PAD~D  [TPC12]  191.35 32.53 180 bottom
T81  PAD~D  [TPC12]  200.83 31.32 0 top
T82  PAD~D  [TPC12]  202.22 30.67 0 top
T83  PAD~D  [TPC12]  194.72 31.02 180 bottom
T84  PAD~D  [TPC12]  193.41 30.87 180 bottom
T85  PAD~D  [TPC12]  198.06 30.1 0 top
T86  PAD~D  [TPC12]  200.66 30.04 0 top
T87  PAD~D  [TPC12]  192.11 30.75 180 bottom
T88  PAD~D  [TPC12]  190.92 30.01 180 bottom
T89  PAD~D  [TPC12]  192.81 29.57 180 bottom
T90  PAD~D  [TPC12]  194.26 29.78 180 bottom
T91  PAD~D  [TPC12]  192.48 28.13 180 bottom
T92  PAD~D  [TPC12]  191.21 28.33 180 bottom
T178  PAD~D  [TPC12]  170.69 26.09 90 top
T179  PAD~D  [TPC12]  265.34 107.41 180 bottom
T180  PAD~D  [TPC12]  263.46 108.06 180 bottom
T181  PAD~D  [TPC12]  259.25 107.6 180 bottom
T184  PAD~D  [TPC12]  268.12 102.65 0 top
T185  PAD~D  [TPC12]  282.84 96.6 180 bottom
T189  PAD~D  [TPC12]  261.09 107.52 0 top
T190  PAD~D  [TPC12]  283.3 79.51 180 bottom
T194  PAD~D  [TPC12]  215.11 111.97 0 top
T199  PAD~D  [TPC12]  268.81 82.48 180 bottom
T258  PAD~D  [TPC12]  171.52 27.11 0 top
T268  PAD~D  [TPC12]  177.81 25.84 180 bottom
T269  PAD~D  [TPC12]  171.66 35.96 0 top
T281  PAD~D  [TPC12]  215.99 109.14 0 top
T284  PAD~D  [TPC12]  119.3 19.99 0 top
T285  PAD~D  [TPC12]  208.43 111.55 180 bottom
T286  PAD~D  [TPC12]  199.49 31.32 0 top
T287  PAD~D  [TPC12]  180.91 31.98 180 bottom
T288  PAD~D  [TPC12]  188.18 46.85 180 bottom
T289  PAD~D  [TPC12]  191.37 40.5 270 bottom
T290  PAD~D  [TPC12]  189.08 21.19 180 bottom
T291  PAD~D  [TPC12]  187.64 26.78 180 bottom
T292  PAD~D  [TPC12]  190.53 27.08 270 bottom
T293  PAD~D  [TPC12]  189.92 28.27 270 bottom
T294  PAD~D  [TPC12]  181.83 36.21 270 bottom
T295  PAD~D  [TPC12]  182.12 37.52 270 bottom
T297  PAD~D  [TPC12]  270.19 109.31 180 bottom
T298  PAD~D  [TPC12]  216.16 86.03 180 bottom
T299  PAD~D  [TPC12]  211.88 87.32 180 bottom
T300  PAD~D  [TPC12]  211.01 116.72 0 top
T301  PAD~D  [TPC12]  212 86.71 0 top
T302  PAD~D  [TPC12]  262.23 83.93 180 bottom
T303  PAD~D  [TPC12]  261.72 85.18 180 bottom
T304  PAD~D  [TPC12]  212.14 115.61 0 top
T305  PAD~D  [TPC12]  211.28 88.07 0 top
T306  PAD~D  [TPC12]  170.45 32.87 270 top
T307  PAD~D  [TPC12]  171.76 32.76 270 top
T309  PAD~D  [TPC12]  141.83 23.55 0 top
T313  PAD~D  [TPC12]  191.35 42.44 180 bottom
T314  PAD~D  [TPC12]  192.65 42.47 180 bottom
T315  PAD~D  [TPC12]  63.24 29.75 0 top
T316  PAD~D  [TPC12]  142.43 38.84 0 top
T317  PAD~D  [TPC12]  169.33 24.55 0 top
T318  PAD~D  [TPC12]  177.84 28.35 180 bottom
T319  PAD~D  [TPC12]  166.68 25.84 0 top
TL1  MHPC_NS692417  [MHPC_NS692417_24P]  179.63 141.77 0 top
UA1  -  [ALC3281-CG_MQFN48_6X6]  342.41 25.43 0 top
UC1  CFL-H_BGA1440  [CFL-H_BGA_1440P-T]  218.53 87.59 270 top
UC3  -  [TC7SH09FU_SSOP5]  170.33 50.52 270 top
UC5  -  [W25Q256JVEIQ_WSON8_8X6]  127.94 41.19 90 bottom
UC6  -  [MX25L25645GM2I-10G_SO8]  125.11 29 90 top
UD1  -  [74AUP1G07GW_TSSOP5]  284.58 69.72 180 bottom
UE1  MEC5105_WFBGA169_11X11  [MEC5105_WFBGA_169P]  129.93 29.25 0 top
UE3  -  [MC74VHC1G08DFT2G_SC70-5]  159.59 17.82 90 top
UE4  -  [74AUP1G07GW_TSSOP5]  158.16 20.59 0 top
UE5  -  [MC74VHC1G08DFT2G_SC70-5]  161.35 21.87 270 top
UE11  -  [74AUP1G07GW_TSSOP5]  127.53 16.19 180 top
UE12  -  [IT8306FN-CX-R_QFN28_4X4]  11.35 14.46 180 bottom
UH1  CNP-H_BGA874  [CNP-H_BGA_874P-T]  196.26 43.21 270 top
UH7  -  [MC74VHC1G08DFT2G_SC70-5]  46.65 41.58 270 bottom
UI1  -  [SLGC55544CVTR_TQFN16_3X3]  349.61 48.21 0 top
UI2  -  [SLGC55544CVTR_TQFN16_3X3]  349.38 37.79 0 top
UL1  WGI219LM-SLKJ2-A0_QFN48_6X6~D  [WGI219LM-SLKJ2-A0_QFN48_6X6]  186.8 125.34 0 bottom
UL2  -  [SN74AHC1G08DCKR_SC70-5]  195.64 131.51 0 top
UR1  -  [RTS5243-GR_QFN48_6X6]  24.29 12.17 90 bottom
UR3  -  [W25X40CLSSIG_SO8]  16.6 19.53 180 bottom
UR4  -  [EM5201V_DFN3X3-8-X]  7.78 19.93 180 bottom
UT1  THUNDERBOLT_BGA337  [THUNDERBOLT_BGA_337P]  25.92 43.68 90 bottom
UT2  -  [W25Q80DVSSIG_SO8]  39.35 34.3 0 top
UT5  CYPD5225-96BZXI_BGA96_6X6  [CYPD5256-96BZXI_BGA_96P]  57.37 28.03 90 bottom
UT7  -  [RT9069-33GB_SOT23-5]  27.88 22.32 270 bottom
UT9  -  [DPS1113FIA-13_QFN18_4X4]  47.06 32.45 180 bottom
UT10  -  [74AUP1G02GW_TSSOP5]  45.73 26.65 270 bottom
UT11  -  [DPS1113FIA-13_QFN18_4X4]  60.54 25.62 180 bottom
UT12  -  [74AUP1G02GW_TSSOP5]  63.22 23.78 180 bottom
UT32  -  [TS5A3159ADCKR_SC70-6]  39.26 46.66 0 top
UT34  -  [MC74VHC1G08DFT2G_SC70-5]  119.07 14.56 270 top
UV8  -  [PS8338BQFN60GTR-A1_QFN60_5X9]  193.79 113.35 180 top
UV24  -  [G524B1T11U_SOT23-5]  95.88 20.71 270 top
UV60  -  [MC74VHC1G09DFT2G_SC70-5]  184.81 96.8 90 top
UV61  -  [SN74AHC1G08DCKR_SC70-5]  183.01 90.92 180 top
UV62  -  [SN74AHC1G08DCKR_SC70-5]  188.28 100.43 0 top
UV63  -  [SN74AHC1G08DCKR_SC70-5]  183.84 82.92 0 top
UV64  PS8331BQFN60GTR-A0_QFN60_5X9  [PS8331BQFN60GTR-A0_QFN60_5X9-S]  115.06 35.88 180 bottom
UV65  M74VHC1GT125DF2G_SC70-5  [P_M74VHC1GT125DF2G_SC70_5P]  136.02 46.3 90 top
UV66  -  [PS8461QFN66GTR-A0_QFN66_5X10]  71.26 36.26 270 top
UV67  -  [PS8461QFN66GTR-A0_QFN66_5X10]  150.7 45.3 270 top
UV68  M74VHC1GT125DF2G_SC70-5  [P_M74VHC1GT125DF2G_SC70_5P]  186.84 97.45 90 top
UV69  -  [74AUP1G07GW_TSSOP5]  185.07 92.53 90 top
UZ6  -  [MC74VHC1G08DFT2G_SC70-5]  118.62 11.28 180 top
UZ7  -  [AOZ1336DI_DFN8_2X2]  206.01 125.41 90 top
UZ9  -  [EM5209VF_DFN14_3X2]  88.24 28.02 270 top
UZ10  -  [MC74VHC1G08DFT2G_SC70-5]  314.89 41.56 0 top
UZ12  -  [NPCT750JABYX_QFN32_5X5]  117.29 25.41 0 top
UZ19  -  [EM5201V_DFN3X3-8-X]  191.19 92.25 0 top
UZ21  -  [EM5201V_DFN3X3-8-X]  192.01 90.79 180 top
UZ23  -  [AOZ1336DI_DFN8_2X2]  327.38 28.85 0 top
UZ26  -  [EM5201V_DFN3X3-8-X]  275.13 80.56 0 top
UZ34  -  [MC74VHC1G08DFT2G_SC70-5]  280.14 83.22 180 top
UZ35  -  [MC74VHC1G08DFT2G_SC70-5]  195.72 95.03 180 top
UZ40  -  [EM5209VF_DFN14_3X2]  338.74 42.43 0 top
UZ41  -  [EM5209VF_DFN14_3X2]  181.85 86.32 90 bottom
UZ42  -  [AOZ1336DI_DFN8_2X2]  106.63 23.85 180 bottom
UZ43  -  [AOZ1336DI_DFN8_2X2]  181.35 75.24 0 bottom
UZ44  -  [EM5209VF_DFN14_3X2]  324.79 22.58 0 top
UZ45  -  [AOZ1336DI_DFN8_2X2]  331.84 26.3 90 bottom
UZ58  -  [AOZ1336DI_DFN8_2X2]  319.78 12.17 90 top
UZ60  -  [SN74AHC1G08DCKR_SC70-5]  330.08 26.03 90 top
UZ61  -  [74AUP1G07GW_TSSOP5]  194.53 89.48 0 top
Y1  25MHZ_18PF_7V25000015  [Y_X3G025000DI1H-H_4P]  182.71 131.24 270 bottom
YE1  32.768KHZ_9PF_X1A000141000200  [Y_X1A000141000200_2P]  131.52 35.67 0 top
YH1  32.768KHZ_12.5PF_9H03200042  [Y_9H03200042_2P]  171.67 12.92 180 top
YH2  24MHZ_12PF_8Y24000034  [Y_8Y24000034_4P]  190.04 51.44 0 top
YT1  25MHZ_20PF_FL2500123Z  [Y_FL2500123Z_4P]  23.92 26 180 bottom

## Library data of the parts
