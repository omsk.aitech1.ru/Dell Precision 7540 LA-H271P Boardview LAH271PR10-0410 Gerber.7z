# Allegro board LAH271PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_CB4: length 58.5
  TOP w0.076: v2(247.26,93.77) UC1.AY10
  TOP w0.152: v2(254.77,55.35) 254.77,55.4 254.33,55.84 254.33,58.3 253.93,58.7 JDIMM4.87
  IN2 w0.076: 247.01,84.1 247.44,84.53 247.44,85.64 246.54,86.54 246.54,90.6 247.08,91.13 247.52,91.13 247.92,91.53 247.92,92 247.61,92.31 247.61,93.42 v2(247.26,93.77)
  IN2 w0.114: v2(254.77,55.35) 254.21,55.91 254.21,58.12 255.7,59.61 255.7,69.18 250.69,74.19 250.69,75.73 249.53,76.9 249.33,76.9 249.14,76.71 249.14,76.51 249.7,75.96 249.7,75.72 249.53,75.55 249.33,75.55 246.75,78.14 246.75,83.84 247.01,84.1
  BOTTOM w0.152: JDIMM3.87 253.93,52.37 254.32,52.76 254.84,52.76 255.49,53.41 255.49,54.64 v2(254.77,55.35)
DDR_B_CB5: length 59.9
  TOP w0.076: v2(246.34,93.77) UC1.AW10
  TOP w0.152: JDIMM4.105 249.43,58.93 249.54,58.81 250.01,58.81 250.12,58.71 250.12,58.06 250.03,57.97 249.72,57.97 249.41,58.29 249.27,58.29 249.08,58.09 249.08,57.73 249.98,56.83 v2(249.98,56.66)
  IN2 w0.076: v2(246.34,93.77) 245.89,93.32 245.89,92.41 244.76,91.28 244.29,91.28 243.47,90.45 243.47,90.44
  IN2 w0.114: 243.47,90.44 243.47,87.51 242.81,86.86 242.81,78.17 251.2,69.78 251.2,69.09 251.34,68.96 251.99,68.96 252.13,68.82 252.13,68.55 251.99,68.41 251.34,68.41 251.2,68.27 251.2,64.85 251.06,64.71 250.77,64.71 250.63,64.57 250.63,64.31 250.77,64.17 251.06,64.17 251.2,64.03 251.2,63.76 251.06,63.62 250.77,63.62 250.63,63.48 250.63,63.21 250.77,63.07 251.06,63.07 251.2,62.93 251.2,62.67 251.06,62.53 250.77,62.53 250.63,62.39 250.63,62.12 250.77,61.98 251.06,61.98 251.2,61.84 251.2,61.58 251.06,61.44 250.77,61.44 250.63,61.3 250.63,61.03 250.77,60.89 251.06,60.89 251.2,60.75 251.2,60.48 251.06,60.34 250.77,60.34 250.63,60.2 250.63,59.94 250.77,59.8 251.06,59.8 251.2,59.66 251.2,59.15 250.72,58.67 250.72,57.4 v2(249.98,56.66)
  BOTTOM w0.152: JDIMM3.105 249.43,52.61 250.36,53.55 250.36,56.28 v2(249.98,56.66)
DDR_B_CB6: length 59.8
  TOP w0.076: v2(247.26,91.82) UC1.AY7
  TOP w0.152: JDIMM4.100 250.68,52.43 250.22,52.89 250.22,53.11 250.36,53.25 250.51,53.25 250.98,52.78 252.3,52.78 252.41,52.89 252.41,53.14 252.31,53.24 252.02,53.24 251.92,53.33 251.92,53.54 251.99,53.61 251.99,53.8 251.84,53.95 251.7,53.95 251.61,53.86 251.61,53.53 251.46,53.38 251.22,53.38 251.1,53.49 251.1,53.7 v2(251.18,53.78)
  IN2 w0.076: v2(247.26,91.82) 247.26,91.79 245.81,90.34 245.81,90.17
  IN2 w0.114: v2(251.18,53.78) 252.73,53.78 253.48,54.53 253.48,58.42 254.88,59.83 254.88,68.96 245.99,77.85 245.99,82.86 245.61,83.24 245.61,85.84 245.81,86.05 245.81,90.17
  BOTTOM w0.152: v2(251.18,53.78) 250.79,54.17 250.79,55.19 251.1,55.51 251.36,55.51 251.58,55.73 251.58,58.31 250.68,59.22 JDIMM3.100
DDR_B_CB7: length 59.3
  TOP w0.076: v2(246.34,91.84) UC1.AW7
  TOP w0.152: v2(252.88,55.2) 251.67,56.42 251.67,56.6 250.43,57.84 JDIMM4.101
  IN2 w0.076: v2(246.34,91.84) 245.97,91.85 245.01,90.89 244.46,90.89 244.2,90.63 244.2,90.44
  IN2 w0.114: 244.2,90.44 244.2,87.21 243.61,86.62 243.61,78.41 253.03,68.99 253.03,64.71 252.89,64.57 252.62,64.57 252.48,64.71 252.48,65.62 252.34,65.76 252.07,65.76 251.93,65.62 251.93,60.72 252.07,60.58 252.55,60.58 252.69,60.44 252.69,60.17 252.55,60.03 252.07,60.03 251.93,59.89 251.93,58.84 251.46,58.37 251.46,56.89 251.62,56.73 251.62,56.46 v2(252.88,55.2)
  BOTTOM w0.152: JDIMM3.101 250.43,52.92 250.71,53.2 251.46,53.2 251.89,53.64 251.89,53.85 251.7,54.05 251.7,54.31 251.96,54.57 252.83,54.57 253,54.74 253,55.08 v2(252.88,55.2)
DDR_B_CKE0: length 54.4
  TOP w0.076: v2(244.51,92.47) UC1.AT8
  TOP w0.168: JDIMM4.109 248.43,58.61 248.8,58.24 248.8,57.61 249.5,56.92 249.5,55.84 v2(249.96,55.38)
  IN1 w0.076: 251.6,78.92 251.6,80.6 248.25,83.95 248.25,84.86 246.55,86.55 246.55,90.35 244.51,92.38 v2(244.51,92.47)
  IN1 w0.152: v2(249.96,55.38) 250.23,55.38 250.38,55.53 250.38,57.74 250.53,57.89 250.75,57.89 251.13,57.5 251.35,57.5 251.53,57.68 251.53,57.92 251.07,58.37 251.07,58.59 251.78,59.3 252.84,59.3 253.19,59.65 253.7,59.65 254.39,60.34 254.39,60.62 253.54,61.48 253.54,61.85 253.95,62.26 253.95,62.56 254.1,62.72 254.73,62.72 255.01,63 255.01,64.7 256.05,65.74 256.05,66.12 256.91,66.98 256.91,73.62 251.6,78.92
DDR_B_CKE1: length 53
  TOP w0.076: v2(244.51,93.77) UC1.AT10
  TOP w0.168: JDIMM4.110 248.18,52.67 249.31,53.8 v2(249.94,53.8)
  IN1 w0.076: 252.07,79.1 252.04,79.14 252.04,80.49 248.5,84.02 248.5,84.87 246.81,86.56 246.81,90.34 244.89,92.26 244.89,93.39 v2(244.51,93.77)
  IN1 w0.152: 252.07,79.1 257.37,73.81 257.37,66.79 256.5,65.93 256.5,65.55 255.47,64.51 255.47,62.53 255.22,62.28 255.22,60.49 253.52,58.8 252.54,58.8 251.9,58.16 251.9,57.46 251.45,57.02 251,57.02 250.71,56.72 250.71,54.57 v2(249.94,53.8)
DDR_B_CKE2: length 53.3
  TOP w0.076: v2(244.51,91.82) UC1.AT7
  IN1 w0.076: 251.42,78.46 251.17,78.71 251.17,79.85 247.91,83.11 247.91,84.93 246.18,86.66 246.18,90.36 244.72,91.82 v2(244.51,91.82)
  IN1 w0.152: 251.42,78.46 256.45,73.43 256.45,67.17 255.51,66.23 255.51,66.02 253.96,64.48 253.96,63.65 253.49,63.17 253.49,62.45 253.32,62.28 253.17,62.28 253,62.12 253,61.36 253.7,60.67 253.7,60.43 253.45,60.19 253.24,60.19 252.77,60.65 252.54,60.65 252.38,60.49 252.38,60.26 252.55,60.08 252.55,59.85 252.38,59.69 252.15,59.69 251.98,59.86 251.75,59.86 249.35,57.46 249.35,54.46 249.54,54.26 249.77,54.26 249.95,54.45 v2(249.95,54.74)
  BOTTOM w0.168: JDIMM3.109 248.43,52.45 249.53,53.56 249.53,54.32 v2(249.95,54.74)
DDR_B_CKE3: length 53.6
  TOP w0.076: v2(244.51,94.42) UC1.AT11
  IN1 w0.076: 252.49,79.33 252.25,79.57 252.25,80.61 248.88,83.98 248.88,85.4 247.68,86.6 247.68,90.54 247.31,90.9 246.32,91.27 246.13,91.34 245.07,92.41 245.07,93.52 244.77,94.17 v2(244.51,94.42)
  IN1 w0.152: v2(251.15,55.94) 252.37,57.16 252.37,57.98 252.73,58.34 253.71,58.34 255.67,60.3 255.67,62.09 255.92,62.34 255.92,64.32 256.96,65.36 256.96,65.74 257.82,66.6 257.82,74 252.49,79.33
  BOTTOM w0.168: JDIMM3.110 248.18,58.78 249.87,57.09 250.29,57.09 250.75,56.63 250.75,56.34 v2(251.15,55.94)
DDR_B_CLK0: length 50.4
  TOP w0.076: v2(240.86,93.12) UC1.AM9
  TOP w0.109: JDIMM4.137 241.43,59.15 241.17,58.89 241.17,58.74 240.9,58.48 240.64,58.48 240.13,57.96 240.13,57.24 240.29,57.08 240.57,57.08 240.86,57.37 v2(240.86,57.48)
  IN1 w0.076: v2(240.86,93.12) 241.16,93.12 241.24,93.05 241.24,91.28 241.07,91.11 240.34,91.11 239.95,90.72 239.95,89.48 240.76,88.67 240.76,79.2 239.42,77.86 239.42,77.47 239.39,77.44 239.39,77.42
  IN1 w0.102: v2(240.86,57.48) 240.86,57.32 240.99,57.19 241.21,57.19 241.31,57.28 241.31,58.45 240.97,58.79 240.97,61.13 240.64,61.47 240.64,61.88 240.27,62.25 240.27,62.56 240.77,63.06 240.77,63.43 240.45,63.75 239.94,63.75 239.37,64.32 239.37,65.39 239.72,65.74 239.72,66.63 239.37,66.98 239.37,69.74 239.63,70.01 240.51,70.01 241.02,70.52 241.02,70.8 241.32,71.09 241.59,71.09 241.77,71.27 241.77,71.53 241.59,71.7 241.29,71.7 241.02,71.97 241.02,72.42 241.32,72.72 241.79,72.72 241.97,72.9 241.97,73.15 241.79,73.33 240.74,73.33 240.45,73.62 240.45,74.68 239.87,75.26 239.6,75.26 239.38,75.48 239.38,76.01 239.64,76.28 239.64,76.83 239.39,77.08 239.39,77.42
DDR_B_CLK1: length 52.4
  TOP w0.076: v2(240.86,91.82) UC1.AM7
  TOP w0.109: JDIMM4.138 241.18,52.63 241.64,53.1 241.64,54.16 241.39,54.41 240.98,54.41 v2(240.88,54.5)
  IN1 w0.076: v2(240.86,91.82) 240.86,92.04 240.77,92.13 240.5,92.13 240.41,92.04 240.41,91.47 239.73,90.79 239.73,89.37 240.51,88.6 240.51,79.32 238.83,77.65 238.83,77.22 238.86,77.19 238.86,77.17
  IN1 w0.102: 238.86,77.17 238.86,74.93 239.04,74.74 239.64,74.74 239.94,74.45 239.94,74.02 239.64,73.73 239.04,73.73 238.86,73.55 238.86,73.3 239.04,73.12 240.21,73.12 240.51,72.82 240.51,72.4 240.21,72.1 239.04,72.1 238.86,71.92 238.86,71.67 239.04,71.49 240.19,71.49 240.49,71.19 240.49,70.77 240.24,70.53 239.09,70.53 238.86,70.29 238.86,64.11 239.61,63.36 239.61,61.63 240.41,60.83 240.41,54.21 240.51,54.1 240.64,54.1 240.88,54.35 v2(240.88,54.5)
DDR_B_CLK2: length 52.1
  TOP w0.076: v2(240.86,94.42) UC1.AM11
  IN1 w0.076: v2(240.86,94.42) 240.66,94.23 240.48,94.23 240.31,94.06 240.31,92.86 239.8,92.35 239.8,91.57 239.19,90.96 239.19,89.06 239.94,88.31 239.94,79.61 237.97,77.64 237.97,77.22 237.94,77.19 237.94,77.17
  IN1 w0.102: v2(240.72,49.14) 240.57,49.3 240.28,49.3 239.96,49.61 239.96,53.56 239.66,53.86 239.66,60.15 238.53,61.27 238.53,63.14 237.94,63.73 237.94,77.17
  BOTTOM w0.109: JDIMM3.137 241.43,49.62 241.09,49.28 240.86,49.28 v2(240.72,49.14)
DDR_B_CLK3: length 54.9
  TOP w0.076: v2(239.03,93.77) UC1.AJ10
  IN1 w0.076: v2(239.03,93.77) 239.03,93.88 239.15,94 239.33,94 239.41,93.92 239.41,91.68 238.8,91.06 238.8,88.83 239.55,88.07 239.55,79.86 237.25,77.55 237.25,77.22 237.22,77.19 237.22,77.17
  IN1 w0.102: 237.22,77.17 237.22,71.7 237.05,71.52 236.51,71.52 236.21,71.23 236.21,70.8 236.51,70.51 237.05,70.51 237.23,70.33 237.23,70.08 237.05,69.9 236.49,69.9 236.19,69.6 236.19,69.18 236.49,68.88 237.05,68.88 237.23,68.7 237.23,68.45 237.05,68.27 236.49,68.27 236.19,67.97 236.19,67.55 236.49,67.26 237.05,67.26 237.23,67.08 237.23,63.44 237.73,62.94 237.73,60.9 239.09,59.55 239.09,56.76 238.52,56.19 238.52,54.89 238.74,54.67 238.95,54.67 v2(239.13,54.49)
  BOTTOM w0.109: JDIMM3.138 241.18,58.75 240.92,58.5 240.51,58.5 240.21,58.2 240.21,54.81 239.89,54.49 v2(239.13,54.49)
DDR_B_CLK#0: length 50.4
  TOP w0.076: v2(241.77,93.12) 241.84,93.08 UC1.AN9
  TOP w0.109: JDIMM4.139 240.93,58.84 240.8,58.72 240.54,58.72 239.88,58.06 239.88,57.14 240.19,56.84 v2(240.86,56.84)
  IN1 w0.076: v2(241.77,93.12) 241.39,92.74 241.39,91.21 241.13,90.96 240.41,90.96 240.1,90.66 240.1,89.54 240.91,88.74 240.91,79.14 239.57,77.8 239.57,77.47 239.59,77.44 239.59,77.42
  IN1 w0.102: v2(240.86,56.84) 241,56.98 241.3,56.98 241.51,57.2 241.51,58.54 241.18,58.87 241.18,61.22 240.84,61.55 240.84,61.96 240.47,62.33 240.47,62.48 240.97,62.98 240.97,63.52 240.54,63.95 240.02,63.95 239.57,64.4 239.57,65.3 239.92,65.66 239.92,66.71 239.57,67.06 239.57,69.66 239.71,69.8 240.59,69.8 241.23,70.44 241.23,70.71 241.41,70.89 241.68,70.89 241.97,71.19 241.97,71.61 241.68,71.91 241.37,71.91 241.23,72.05 241.23,72.34 241.41,72.52 241.88,72.52 242.18,72.81 242.18,73.24 241.88,73.53 240.83,73.53 240.66,73.7 240.66,74.76 239.95,75.46 239.68,75.46 239.58,75.57 239.58,75.93 239.84,76.19 239.84,76.91 239.59,77.16 239.59,77.42
DDR_B_CLK#1: length 52.5
  TOP w0.076: v2(240.86,92.47) UC1.AM8
  TOP w0.109: v2(240.88,53.83) 240.88,54 241.05,54.17 241.29,54.17 241.4,54.06 241.4,53.2 240.68,52.47 JDIMM4.140
  IN1 w0.076: v2(240.86,92.47) 240.66,92.28 240.44,92.28 240.26,92.1 240.26,91.53 239.58,90.85 239.58,89.31 240.36,88.53 240.36,79.39 238.68,77.71 238.68,77.22 238.65,77.19 238.65,77.17
  IN1 w0.102: v2(240.88,53.83) 240.81,53.9 240.43,53.9 240.21,54.12 240.21,60.74 239.4,61.55 239.4,63.28 238.65,64.02 238.65,70.37 239.01,70.73 240.15,70.73 240.28,70.86 240.28,71.11 240.1,71.29 238.96,71.29 238.66,71.59 238.66,72.01 238.96,72.3 240.12,72.3 240.3,72.48 240.3,72.74 240.12,72.91 238.96,72.91 238.66,73.21 238.66,73.63 238.96,73.93 239.56,73.93 239.73,74.11 239.73,74.36 239.56,74.54 238.96,74.54 238.65,74.84 238.65,77.17
DDR_B_CLK#2: length 52.1
  TOP w0.076: v2(240.86,93.77) UC1.AM10
  IN1 w0.076: 238.14,77.17 238.14,77.19 238.12,77.22 238.12,77.57 240.09,79.55 240.09,88.37 239.34,89.12 239.34,90.89 239.95,91.51 239.95,92.29 240.46,92.8 240.46,94 240.54,94.08 240.78,94.08 240.86,94 v2(240.86,93.77)
  IN1 w0.102: 238.14,77.17 238.14,63.82 238.74,63.22 238.74,61.35 239.86,60.23 239.86,53.95 240.17,53.64 240.17,49.69 240.36,49.5 240.62,49.5 240.72,49.61 v2(240.72,50.02)
  BOTTOM w0.109: JDIMM3.139 240.93,50.96 241.18,50.7 241.18,49.72 240.99,49.52 240.83,49.52 240.72,49.63 v2(240.72,50.02)
DDR_B_CLK#3: length 54.9
  TOP w0.076: v2(239.03,94.42) UC1.AJ11
  IN1 w0.076: v2(239.03,94.42) 239.03,94.24 239.11,94.15 239.39,94.15 239.56,93.99 239.56,91.61 238.95,91 238.95,88.89 239.71,88.13 239.71,79.79 237.4,77.49 237.4,77.22 237.43,77.19 237.43,77.17
  IN1 w0.102: 237.43,77.17 237.43,71.61 237.13,71.32 236.59,71.32 236.41,71.14 236.41,70.89 236.59,70.71 237.13,70.71 237.43,70.41 237.43,69.99 237.13,69.69 236.57,69.69 236.39,69.52 236.39,69.26 236.57,69.08 237.13,69.08 237.43,68.79 237.43,68.37 237.13,68.07 236.57,68.07 236.39,67.89 236.39,67.64 236.57,67.46 237.13,67.46 237.43,67.16 237.43,63.52 237.93,63.02 237.93,60.99 239.29,59.63 239.29,56.67 238.73,56.11 238.73,54.97 238.83,54.87 239.02,54.87 239.13,54.97 v2(239.13,55.1)
  BOTTOM w0.109: JDIMM3.140 240.68,59.26 240.93,59 240.93,58.85 240.82,58.74 240.41,58.74 239.97,58.3 239.97,54.91 239.79,54.73 239.41,54.73 239.13,55.02 v2(239.13,55.1)
DDR_B_CS#0: length 57.3
  TOP w0.076: v2(236.28,94.42) UC1.AF11
  TOP w0.168: JDIMM4.149 236.43,58.93 237.21,58.14 237.21,56.33 v2(235.9,55.01)
  IN2 w0.076: v2(236.28,94.42) 236.81,93.9 236.81,91.54 236.76,91.48 236.76,90.9 236.51,90.65 234.73,90.65 234.3,90.22
  IN2 w0.127: 234.3,90.22 234.1,90.03 234.1,88.27 234.72,87.66 234.72,84.13 233.86,83.27 233.86,82.81 232.35,81.3 232.35,69.06 233.18,68.23 233.18,63.59 233.01,63.43 232.78,63.43 232.62,63.59 232.62,65.84 232.43,66.03 232.22,66.03 232.06,65.87 232.06,61.18 235.4,57.84 235.4,55.35 235.73,55.01 v2(235.9,55.01)
DDR_B_CS#1: length 54
  TOP w0.076: v2(236.23,91.19) 236.14,91.19 UC1.AE7
  TOP w0.168: v2(231.63,55.61) 234.43,58.4 JDIMM4.157
  IN1 w0.076: v2(236.23,91.19) 235.79,90.75 235.79,82.91 235.02,82.14
  IN1 w0.152: 235.02,82.14 231.14,78.26 231.14,76.75 226.05,71.66 226.05,69.11 226.22,68.95 226.45,68.95 226.61,69.11 226.61,71.42 226.77,71.58 227.01,71.58 227.17,71.42 227.17,68.73 229.18,66.71 229.18,65.49 229.68,64.99 229.68,64.1 230.25,63.53 230.25,60.22 231.57,58.9 231.57,57.87 232.1,57.35 232.1,56.3 231.63,55.84 v2(231.63,55.61)
DDR_B_CS#2: length 54.2
  TOP w0.076: UC1.AF10 v2(236.28,93.77)
  IN2 w0.076: v2(236.28,93.77) 236.64,93.41 236.64,91.6 236.59,91.55 236.59,90.97 236.44,90.82 234.27,90.82 233.94,90.49
  IN2 w0.127: 233.94,90.49 233.7,90.24 233.7,84.65 231.89,82.84 231.89,67.73 231.72,67.57 231.49,67.57 231.33,67.73 231.33,69.95 231.17,70.1 230.94,70.1 230.77,69.93 230.77,61.7 234.94,57.53 234.94,54.68 v2(235.91,53.71)
  BOTTOM w0.168: v2(235.91,53.71) 236.43,53.2 JDIMM3.149
DDR_B_CS#3: length 58
  TOP w0.076: v2(235.37,93.77) UC1.AE10
  IN2 w0.076: 233.58,91.31 234.38,92.11 234.62,92.11 234.98,92.47 234.98,93.51 235.25,93.77 v2(235.37,93.77)
  IN2 w0.127: 233.58,91.31 232.78,90.51 232.78,85.02 230.94,83.18 230.94,76.97 230.81,76.84 230.51,76.84 230.38,76.97 230.38,81.94 230.26,82.07 229.94,82.07 229.81,81.94 229.81,60.97 232.94,57.84 232.94,54.54 v2(233.91,53.58)
  BOTTOM w0.168: JDIMM3.157 234.43,53.24 234.09,53.58 v2(233.91,53.58)
DDR_B_D0: length 61.7
  TOP w0.076: v2(261.73,93.58) 261.56,93.4 261.34,93.18 260.93,93.18 260.27,93.84 259.87,93.84 259.67,94.04 UC1.BT11
  TOP w0.152: JDIMM4.7 273.93,59.02 274.41,58.54 274.41,57.97 274.71,57.67 v2(274.88,57.67)
  IN1 w0.076: 263.94,92.33 263.58,92.69 262.62,92.69 v2(261.73,93.58)
  IN1 w0.14: 263.94,92.33 278.49,77.78 278.49,65.16 278.3,64.97 278.14,64.97 277.98,65.13 277.98,68.6 277.82,68.76 277.5,68.76 277.31,68.57 277.31,62.75 276.62,62.06 276.62,60.82 274.44,58.64 274.44,58.1 v2(274.88,57.67)
  BOTTOM w0.152: JDIMM3.8 273.68,58.87 v2(274.88,57.67)
DDR_B_D1: length 63.4
  TOP w0.076: UC1.BR11 258.75,94.04 258.9,93.89 258.9,93.89 259.15,93.64 260.06,93.64 260.75,92.95 v1(261.74,92.95) v2(262.37,93.58)
  TOP w0.152: v2(274.98,54.39) 274.85,54.52 274.47,54.52 274.27,54.32 274.27,53.3 273.68,52.71 JDIMM4.8
  IN1 w0.076: 263.39,93.1 262.84,93.1 v2(262.37,93.58)
  IN1 w0.14: v2(274.98,54.39) 274.81,54.56 274.81,56.86 275.59,57.64 275.59,59.21 276.99,60.62 276.99,61.91 277.85,62.77 277.85,64.28 278.01,64.44 278.24,64.44 278.4,64.28 278.4,63.19 278.56,63.03 278.78,63.03 278.94,63.19 278.94,77.88 263.72,93.1 263.39,93.1
  BOTTOM w0.152: JDIMM3.7 273.93,52.49 274.18,52.74 274.56,52.74 275.39,53.57 275.39,53.98 275.09,54.28 v2(274.98,54.39)
DDR_B_D2: length 60.3
  TOP w0.076: UC1.BT9 v2(259.8,93.18)
  TOP w0.152: JDIMM4.17 271.43,58.91 271.34,58.83 271.34,57.81 v2(271.9,57.24)
  IN1 w0.076: v2(259.8,93.18) 260.23,93.18 260.57,92.84 260.57,92.16 262.43,90.3 263.33,90.3 263.68,89.95
  IN1 w0.14: v2(271.9,57.24) 271.45,57.69 271.45,58.3 274.19,61.04 274.19,62.3 275.42,63.53 275.42,74.08 275.58,74.24 275.81,74.24 275.97,74.08 275.97,70.59 276.13,70.43 276.35,70.43 276.51,70.59 276.51,77.12 263.69,89.95 263.68,89.95
  BOTTOM w0.152: JDIMM3.16 271.68,58.95 271.46,58.73 271.46,57.68 v2(271.9,57.24)
DDR_B_D3: length 63.3
  TOP w0.076: v2(262.08,91.53) 260.9,91.53 260.33,92.1 259.71,92.1 259.28,92.53 259.04,92.53 258.98,92.46 UC1.BR8
  TOP w0.152: v2(273.81,54.91) 273.7,54.8 272.4,54.8 270.68,53.08 JDIMM4.20
  IN1 w0.14: v2(262.08,91.53) 263.15,91.53 277.31,77.36 277.31,70.35 276.16,69.2 276.16,63.22 274.94,62.01 274.94,60.75 272.72,58.53 272.72,56.21 272.88,56.05 273.21,56.05 273.37,55.89 273.37,55.67 273.21,55.51 272.88,55.51 272.72,55.35 272.72,54.29 272.86,54.14 273.18,54.14 273.33,54.3 273.33,54.78 273.46,54.91 v2(273.81,54.91)
  BOTTOM w0.152: v2(273.81,54.91) 273.72,54.83 272.62,54.83 270.43,52.64 JDIMM3.21
DDR_B_D4: length 63.1
  TOP w0.076: UC1.BP11 258.09,94.04 258.39,94.33 259.79,94.33 260.03,94.08 260.59,94.08 v2(260.65,94.03)
  TOP w0.152: v2(275.94,54.24) 275.94,53.89 274.68,52.62 JDIMM4.4
  IN1 w0.14: v2(275.94,54.24) 275.94,54.5 275.29,55.16 275.29,56.68 276.01,57.4 276.01,58.97 277.42,60.37 277.42,61.67 278.24,62.49 278.47,62.49 278.63,62.33 278.63,62.1 278.33,61.81 278.33,61.58 278.49,61.42 278.72,61.42 279.31,62.02 279.31,78.04 263.06,94.28 260.9,94.28 v2(260.65,94.03)
  BOTTOM w0.152: JDIMM3.3 274.93,52.63 276.07,53.78 276.07,54.12 v2(275.94,54.24)
DDR_B_D5: length 63.2
  TOP w0.076: v2(260.2,94.48) 260.14,94.53 258.25,94.53 258.04,94.32 257.73,94.32 257.45,94.04 UC1.BN11
  TOP w0.152: v2(276.45,58.55) 276.28,58.38 275.45,58.38 274.93,58.91 JDIMM4.3
  IN1 w0.14: v2(276.45,58.55) 278.74,60.85 278.97,60.85 279.13,60.69 279.13,60.46 277.52,58.85 277.52,58.62 277.68,58.46 277.9,58.46 279.68,60.24 279.68,78.19 265.27,92.6 265.27,93.72 264.89,94.1 263.94,94.1 263.39,94.65 260.37,94.65 v2(260.2,94.48)
  BOTTOM w0.152: v2(276.45,58.55) 275.23,58.55 274.68,59.11 JDIMM3.4
DDR_B_D6: length 62.1
  TOP w0.076: UC1.BP8 258.15,92.76 259.41,92.76 259.85,92.31 260.45,92.31 260.83,91.93 v2(261.45,91.93)
  TOP w0.152: v2(273.78,53.69) 272.31,53.69 271.68,53.06 JDIMM4.16
  IN1 w0.076: 263.73,90.42 263.59,90.56 262.47,90.56 261.45,91.59 v2(261.45,91.93)
  IN1 w0.14: 263.73,90.42 276.95,77.21 276.95,70.5 275.79,69.35 275.79,63.38 274.56,62.14 274.56,60.88 272.34,58.67 272.34,53.59 273.19,52.74 273.42,52.74 273.58,52.9 273.58,53.12 273.24,53.46 273.24,53.69 273.4,53.85 273.63,53.85 v2(273.78,53.69)
  BOTTOM w0.152: JDIMM3.17 271.43,52.63 272.49,53.69 v2(273.78,53.69)
DDR_B_D7: length 63.6
  TOP w0.076: v2(260.18,92.71) 259.75,92.71 259.51,92.96 257.76,92.96 257.26,92.46 UC1.BN8
  TOP w0.152: JDIMM4.21 270.43,58.11 271.04,57.49 271.04,56.86 v2(271.9,55.99)
  IN1 w0.076: v2(260.18,92.71) 260.18,92.11 262.28,90.01 263.1,90.01 263.31,89.8
  IN1 w0.14: v2(271.9,55.99) 271.4,55.99 271.02,56.37 271.02,58.39 273.77,61.14 273.77,62.4 275.05,63.68 275.05,76.7 275.21,76.86 275.44,76.86 275.6,76.7 275.6,74.81 275.76,74.65 275.99,74.65 276.15,74.81 276.15,76.97 263.31,89.8
  BOTTOM w0.152: v2(271.9,55.99) 271.71,55.99 271.09,56.62 271.09,57.86 270.68,58.27 JDIMM3.20
DDR_B_D8: length 62.2
  TOP w0.076: UC1.BL12 255.91,94.76 v2(256.24,94.43)
  TOP w0.152: v2(270.64,56.73) 270.05,57.31 270.05,58.06 269.43,58.68 JDIMM4.25
  IN1 w0.076: 258.49,92.73 257.18,92.73 256.24,93.68 v2(256.24,94.43)
  IN1 w0.14: v2(270.64,56.73) 270.45,56.73 270.23,56.95 270.23,57.9 270.66,58.34 270.66,59.13 272.78,61.24 272.78,62.5 273.18,62.9 273.19,62.91 273.19,66.8 273.35,66.96 273.57,66.96 273.73,66.8 273.73,64.27 273.89,64.11 274.12,64.11 274.28,64.27 274.28,77.74 262.43,89.59 261.87,89.59 260.6,90.86 260.36,90.86 258.49,92.73
  BOTTOM w0.152: JDIMM3.24 269.68,58.56 270.14,58.09 270.14,57.03 270.45,56.73 v2(270.64,56.73)
DDR_B_D9: length 63
  TOP w0.076: UC1.BL11 v2(255.44,94.42)
  TOP w0.152: v2(270.64,55.48) 270.23,55.07 270.23,53.85 269.62,53.24 269.33,53.24 268.68,52.58 JDIMM4.28
  IN1 w0.076: 261.86,88.33 260.14,90.06 260.14,90.68 258.29,92.53 257.13,92.53 255.96,93.69 255.96,93.91 v2(255.44,94.42)
  IN1 w0.14: v2(270.64,55.48) 269.87,56.24 269.87,58.12 270.24,58.49 270.24,59.23 272.31,61.29 272.31,62.55 272.82,63.06 272.82,70.53 272.98,70.69 273.2,70.69 273.36,70.53 273.36,69.55 273.52,69.39 273.75,69.39 273.91,69.55 273.91,77.58 264.6,86.9 263.3,86.9 261.86,88.33
  BOTTOM w0.152: JDIMM3.29 268.43,52.92 269.89,54.38 269.89,54.83 270.54,55.48 v2(270.64,55.48)
DDR_B_D10: length 59.2
  TOP w0.076: UC1.BL8 v2(256.24,92.86)
  TOP w0.152: JDIMM4.24 269.68,52.68 270.76,53.76 270.76,54.11 v2(270.63,54.24)
  IN1 w0.076: 261.28,87.8 259.96,89.12 259.68,89.12 259.4,89.4 259.4,90.31 258.27,91.44 258.27,91.45 257.44,92.28 256.81,92.28 v2(256.24,92.86)
  IN1 w0.14: 261.28,87.8 261.48,87.8 262.88,86.4 264.57,86.4 273.54,77.43 273.54,71.5 273.38,71.34 273.16,71.34 273,71.5 273,72.6 272.84,72.76 272.61,72.76 272.45,72.6 272.45,63.21 271.94,62.7 271.94,61.45 269.87,59.38 269.87,58.52 269.6,58.25 269.6,55.75 270.1,55.25 270.1,54.77 v2(270.63,54.24)
  BOTTOM w0.152: JDIMM3.25 269.43,53.03 v2(270.63,54.24)
DDR_B_D11: length 60.3
  TOP w0.076: v2(254.57,92.47) UC1.BJ8
  TOP w0.152: JDIMM4.37 266.43,58.92 267.61,57.74 267.61,57.37 v2(267.47,57.24)
  IN1 w0.076: 262.21,84.31 261.53,84.31 257.99,87.84 257.99,89.35 256.49,90.85 255.95,90.85 255.06,91.74 255.06,91.99 v2(254.57,92.47)
  IN1 w0.14: 262.21,84.31 264.03,84.31 270.54,77.79 270.54,77.22 270.08,76.77 270.08,76.35 270.54,75.89 270.54,66.42 270.11,65.98 268.87,64.75 268.87,64.52 269.03,64.36 269.26,64.36 270.2,65.3 270.42,65.3 270.58,65.14 270.58,64.91 269.19,63.52 269.19,63.1 269.03,62.94 268.8,62.94 268.64,63.1 268.64,63.93 268.48,64.09 268.26,64.09 268.1,63.93 268.1,62.58 268.26,62.42 268.6,62.42 268.76,62.26 268.76,62.03 268.6,61.87 268.26,61.87 268.1,61.71 268.1,61.49 268.26,61.33 268.61,61.33 268.77,61.17 268.77,60.94 268.61,60.78 268.26,60.78 268.09,60.61 268.09,60.33 267.73,59.97 267.73,58.83 267.47,58.58 v2(267.47,57.24)
  BOTTOM w0.152: v2(267.47,57.24) 266.81,57.91 266.81,58.4 266.18,59.04 JDIMM3.38
DDR_B_D12: length 63.3
  TOP w0.076: v2(254.57,93.77) UC1.BJ11
  TOP w0.152: JDIMM4.38 266.18,52.51 267.96,54.3 v2(269.23,54.3)
  IN1 w0.076: v2(254.57,93.77) 254.98,93.36 254.98,92.93 255.14,92.78 255.14,92.34 255.39,92.09 255.39,91.75 256.02,91.12 256.51,91.12 258.32,89.31 258.32,87.85 261.4,84.77 262.37,84.77
  IN1 w0.14: 262.37,84.77 264.08,84.77 270.95,77.9 270.95,64.73 269.72,63.5 269.72,61.37 268.13,59.78 268.13,58.75 267.9,58.51 267.9,54.09 268.78,53.21 268.97,53.21 269.12,53.36 269.12,53.56 268.53,54.16 268.53,54.46 268.69,54.62 268.91,54.62 v2(269.23,54.3)
  BOTTOM w0.152: v2(269.23,54.3) 269.21,54.3 269.2,54.29 267.76,54.29 266.43,52.95 JDIMM3.37
DDR_B_D13: length 62.5
  TOP w0.076: v2(254.57,93.12) UC1.BJ10
  TOP w0.152: v2(267.45,54.69) 266.89,54.13 266.2,54.13 265.18,53.11 JDIMM4.42
  IN1 w0.076: 262.47,83.47 261.71,83.47 257.35,87.83 257.35,89.25 256.42,90.18 256.04,90.18 254.79,91.42 254.46,91.42 254.16,91.73 254.16,92.71 v2(254.57,93.12)
  IN1 w0.14: v2(267.45,54.69) 267.22,54.47 267.22,52.44 267.08,52.3 266.77,52.3 266.63,52.44 266.63,56.54 266.76,56.66 266.76,60.23 267.36,60.84 267.36,64.28 269.81,66.72 269.81,75.56 269.08,76.29 269.08,77.15 265.61,80.62 265.61,81.59 263.73,83.47 262.47,83.47
  BOTTOM w0.152: v2(267.45,54.69) 266.61,54.69 265.43,53.51 JDIMM3.41
DDR_B_D14: length 58.1
  TOP w0.076: v2(256.2,92.04) UC1.BL7
  TOP w0.152: JDIMM4.29 268.43,58.5 v2(269.21,57.71)
  IN1 w0.076: 262.02,85.92 259.23,88.7 259.23,90.22 257.41,92.04 v2(256.2,92.04)
  IN1 w0.14: 262.02,85.92 264.53,85.92 273.17,77.28 273.17,73.7 273.01,73.54 272.79,73.54 272.63,73.7 272.63,76.91 272.47,77.08 272.24,77.08 272.08,76.92 272.08,63.42 271.49,62.83 271.49,61.55 269.35,59.4 269.35,58.57 269.21,58.43 v2(269.21,57.71)
  BOTTOM w0.152: v2(269.21,57.71) 269.33,57.84 269.33,58.23 268.68,58.88 JDIMM3.28
DDR_B_D15: length 61.8
  TOP w0.076: v2(254.57,91.82) UC1.BJ7
  TOP w0.152: JDIMM4.41 265.43,59.09 266.5,58.02 266.5,56.46 267,55.96 v2(267.48,55.96)
  IN1 w0.076: 262.16,83.87 261.63,83.87 257.67,87.83 257.67,89.29 256.39,90.57 255.92,90.57 254.67,91.82 v2(254.57,91.82)
  IN1 w0.14: v2(267.48,55.96) 267.05,56.39 267.05,58.61 267.24,58.8 267.24,60.2 267.73,60.68 267.73,64.12 269.85,66.24 270.17,66.57 270.17,75.74 269.57,76.34 269.57,76.84 270.09,77.36 270.09,77.58 269.93,77.74 269.7,77.74 269.46,77.51 269.24,77.51 269.08,77.67 269.08,77.89 269.4,78.21 269.4,78.41 269.24,78.57 269.02,78.57 268.73,78.28 268.46,78.28 268.3,78.44 268.3,78.66 268.61,78.97 268.61,79.2 268.45,79.36 268.23,79.36 267.92,79.05 267.69,79.05 267.53,79.21 267.53,79.44 267.84,79.75 267.84,79.97 267.68,80.13 267.4,80.13 267.12,79.85 266.89,79.85 266.74,80 266.74,80.2 267.05,80.5 267.05,80.73 266.89,80.89 266.67,80.89 266.37,80.6 266.15,80.6 265.97,80.77 265.97,81.78 263.88,83.87 262.16,83.87
  BOTTOM w0.152: JDIMM3.42 265.18,59.01 265.54,58.64 265.85,58.64 266.33,58.16 266.33,57.16 267.48,56.02 v2(267.48,55.96)
DDR_B_D16: length 59.8
  TOP w0.076: v2(252.74,94.41) UC1.BG11
  TOP w0.152: v2(265.79,56.6) 265.44,56.6 264.98,57.06 264.98,57.53 263.43,59.08 JDIMM4.49
  IN1 w0.076: 261.27,83.51 257.04,87.75 257.04,88.27 255.94,89.37 255.94,89.98 254.72,91.2 254.45,91.2 253.55,92.09 253.5,92.09 253.29,92.3 253.29,93.52 253.12,93.69 253.12,94.03 v2(252.74,94.41)
  IN1 w0.14: 261.27,83.51 262.08,82.7 262.51,82.7 262.77,82.96 263.03,82.96 263.22,82.76 263.22,82.57 263,82.35 263,82.12 263.2,81.93 263.42,81.93 263.69,82.19 263.91,82.19 264.07,82.03 264.07,81.8 263.81,81.54 263.81,81.32 263.97,81.16 264.2,81.16 264.44,81.4 264.67,81.4 264.83,81.24 264.83,81.02 264.58,80.77 264.58,80.54 268.3,76.82 268.3,75.97 269.03,75.24 269.03,67.04 268.16,66.17 267.94,66.17 267.71,66.41 267.48,66.41 267.32,66.25 267.32,66.02 267.55,65.79 267.55,65.56 266.48,64.49 266.48,61.05 265.98,60.55 265.98,59.3 266.21,59.08 266.21,57.02 v2(265.79,56.6)
  BOTTOM w0.152: JDIMM3.50 263.18,59.05 265.63,56.6 v2(265.79,56.6)
DDR_B_D17: length 58
  TOP w0.076: v2(252.74,93.77) UC1.BG10
  TOP w0.152: JDIMM4.45 264.43,58.81 265.37,57.87 265.66,57.87 v2(265.81,58.02)
  IN1 w0.076: v2(252.74,93.77) 253.12,93.39 253.12,92.2 253.54,91.78 253.54,91.61 254.31,90.84 254.31,88.4 254.52,88.19 255.26,88.19 255.35,88.1
  IN1 w0.14: 255.35,88.1 261.58,81.88 262.73,81.88 267.93,76.67 267.93,75.82 268.66,75.09 268.66,71.79 268.5,71.63 268.14,71.63 267.98,71.47 267.98,71.25 268.14,71.09 268.5,71.09 268.66,70.93 268.66,70.7 268.5,70.54 268.1,70.54 267.94,70.38 267.94,70.16 268.1,70 268.5,70 268.66,69.84 268.66,69.6 268.5,69.44 268.11,69.44 267.95,69.28 267.95,69.06 268.11,68.9 268.5,68.9 268.66,68.74 268.66,67.69 268.53,67.56 267.81,66.84 267.58,66.84 267.42,67 267.42,67.22 268.09,67.89 268.09,68.12 267.93,68.28 267.7,68.28 266.84,67.42 266.84,65.37 266.11,64.64 266.11,61.2 265.61,60.71 265.61,59.06 265.81,58.87 v2(265.81,58.02)
  BOTTOM w0.152: v2(265.81,58.02) 265.2,58.02 264.18,59.04 JDIMM3.46
DDR_B_D18: length 57.9
  TOP w0.076: v2(252.74,92.47) UC1.BG8
  TOP w0.152: v2(265.78,55.4) 264.18,53.8 JDIMM4.46
  IN1 w0.076: v2(252.74,92.47) 252.74,92.33 253.27,91.8 253.27,91.48 254.11,90.64 254.11,88.37 254.52,87.96 254.98,87.96 255.09,87.84
  IN1 w0.14: 255.09,87.84 261.42,81.51 262.57,81.51 267.56,76.52 267.56,75.19 267.72,75.03 268.14,75.03 268.3,74.87 268.3,74.64 268.14,74.48 267.72,74.48 267.56,74.32 267.56,74.1 267.72,73.94 268.14,73.94 268.3,73.78 268.3,73.55 268.14,73.39 267.72,73.39 267.56,73.23 267.56,73 267.72,72.84 268.14,72.84 268.3,72.68 268.3,72.46 268.14,72.3 267.72,72.3 267.56,72.14 267.56,68.91 266.47,67.82 266.47,65.52 265.7,64.76 265.7,61.32 265.25,60.86 265.25,55.94 v2(265.78,55.4)
  BOTTOM w0.152: v2(265.78,55.4) 265.58,55.4 264.43,54.25 JDIMM3.45
DDR_B_D19: length 58.5
  TOP w0.076: v2(251.83,92.47) UC1.BF8
  TOP w0.152: JDIMM4.58 261.18,54.47 261.85,55.15 v2(262.01,55.15)
  IN1 w0.076: 253.17,86.68 253.07,86.79 253.07,90.13 251.85,91.34 251.8,91.34 251.44,91.7 251.44,91.95 251.83,92.34 v2(251.83,92.47)
  IN1 w0.14: 253.17,86.68 253.17,86.64 260.22,79.59 261.78,79.59 265.7,75.68 265.7,73.2 265.54,73.04 265.31,73.04 265.15,73.2 265.15,74.72 265,74.87 264.76,74.87 264.58,74.69 264.58,66.27 263.48,65.18 263.48,64.2 262.63,63.35 262.63,61.54 263,61.17 263,56.13 v2(262.01,55.15)
  BOTTOM w0.152: JDIMM3.59 260.93,54.06 v2(262.01,55.15)
DDR_B_D20: length 62.8
  TOP w0.076: v2(251.83,94.41) UC1.BF11
  TOP w0.152: JDIMM4.62 260.18,52.68 260.04,52.81 260.04,53.67 260.49,54.12 260.49,55.48 261.33,56.31 261.33,56.96 v2(262.03,57.66)
  IN1 w0.076: v2(251.83,94.41) 251.39,93.97 251.39,93.7 251.29,93.6 251.29,92.36 251.07,92.15 251.07,91.57 252.62,90.02 252.62,86.19 252.65,86.16
  IN1 w0.14: v2(262.03,57.66) 262.03,61.1 261.89,61.23 261.89,63.65 262.75,64.51 262.75,65.48 263.84,66.58 263.84,74.93 260.93,77.84 260.93,78.06 261.09,78.22 261.32,78.22 262.59,76.95 262.82,76.95 262.98,77.11 262.98,77.34 261.53,78.79 259.98,78.79 252.65,86.12 252.65,86.16
  BOTTOM w0.152: v2(262.03,57.66) 261.33,56.96 261.33,56.02 260.53,55.23 260.53,54.32 259.93,53.71 JDIMM3.63
DDR_B_D21: length 61.3
  TOP w0.076: v2(251.83,93.77) UC1.BF10
  TOP w0.152: v2(262.01,56.36) 262.49,56.83 262.49,57.82 262.18,58.13 260.84,58.13 259.93,59.05 JDIMM4.63
  IN1 w0.076: v2(251.83,93.77) 251.47,93.42 251.47,92.24 251.25,92.03 251.25,91.64 252.84,90.06 252.84,86.49 252.91,86.42
  IN1 w0.14: 252.91,86.42 252.91,86.38 260.09,79.2 261.64,79.2 265.07,75.77 265.07,75.54 264.91,75.38 264.68,75.38 263.36,76.7 263.16,76.7 263.02,76.56 263.02,76.34 264.21,75.15 264.21,66.42 263.12,65.33 263.12,64.35 262.26,63.5 262.26,61.38 262.51,61.13 262.51,56.86 v2(262.01,56.36)
  BOTTOM w0.152: v2(262.01,56.36) 262.59,56.94 262.59,57.85 262.35,58.09 261,58.09 260.18,58.91 JDIMM3.62
DDR_B_D22: length 55.4
  TOP w0.076: v2(252.74,91.82) UC1.BG7
  TOP w0.152: v2(263.73,53.73) 263.18,53.18 JDIMM4.50
  IN1 w0.076: v2(252.74,91.82) 252.97,91.6 252.97,91.41 253.93,90.45 253.93,89.96 253.93,88.28 254.52,87.68 254.73,87.68 254.97,87.44
  IN1 w0.14: v2(263.73,53.73) 263.99,53.99 264.21,53.99 265.47,52.74 265.69,52.74 265.85,52.9 265.85,53.12 264.38,54.6 264.38,54.89 264.88,55.39 264.88,61.01 265.34,61.47 265.34,64.91 266.1,65.68 266.1,68.03 267.08,69.01 267.2,69.13 267.2,76.37 262.42,81.14 261.27,81.14 254.97,87.44
  BOTTOM w0.152: JDIMM3.49 263.43,52.69 263.87,53.13 263.87,53.59 v2(263.73,53.73)
DDR_B_D23: length 58.5
  TOP w0.076: v2(251.83,91.82) UC1.BF7
  TOP w0.152: v2(263.66,57.19) 263.48,57.19 262.27,58.4 261.47,58.4 260.93,58.94 JDIMM4.59
  IN1 w0.076: v2(251.83,91.82) 251.83,91.64 253.29,90.18 253.29,87.08 253.43,86.94
  IN1 w0.14: v2(263.66,57.19) 263.6,57.26 263.6,63.23 264.01,63.65 264.01,65.19 264.97,66.15 264.97,72.51 265.13,72.67 265.36,72.67 265.52,72.51 265.52,69.65 265.68,69.49 265.91,69.49 266.07,69.65 266.07,75.83 261.94,79.96 260.38,79.96 253.43,86.9 253.43,86.94
  BOTTOM w0.152: JDIMM3.58 261.18,58.85 261.67,58.35 262.8,58.35 263.66,57.49 v2(263.66,57.19)
DDR_B_D24: length 56
  TOP w0.076: v2(249.09,94.42) UC1.BB11
  TOP w0.152: v2(254.76,58.02) 254.93,58.18 JDIMM4.83
  IN1 w0.076: v2(249.09,94.42) 248.62,93.96 248.62,93.67 248.53,93.59 248.53,92.35 248.24,92.06 248.24,91.16 248.37,91.03 248.37,87.26 249.77,85.86 249.77,84.49 252.93,81.33 252.93,80.85
  IN1 w0.14: v2(254.76,58.02) 254.76,58.28 256.7,60.22 256.7,63.87 257.74,64.9 257.74,65.42 258.6,66.28 258.6,67.92 259.65,68.97 259.65,72.91 259.49,73.07 259.3,73.07 259.16,72.93 259.16,69.31 259,69.15 258.77,69.15 258.61,69.31 258.61,74.31 252.93,79.99 252.93,80.85
  BOTTOM w0.152: v2(254.76,58.02) 254.78,58.04 254.78,58.92 254.68,59.03 JDIMM3.84
DDR_B_D25: length 56.8
  TOP w0.076: v2(250,94.41) UC1.BC11
  TOP w0.152: JDIMM4.66 259.18,53.03 259.34,53.19 259.34,53.96 259.81,54.43 v2(259.99,54.43)
  IN1 w0.076: v2(250,94.41) 250.45,93.96 250.45,93.66 250.56,93.56 250.56,92.39 250.85,92.1 250.85,91.43 251.01,91.28 251.01,90.13 251.74,89.39 251.74,85.91 256.3,81.35
  IN1 w0.14: v2(259.99,54.43) 259.99,53.09 260.13,52.95 260.44,52.95 260.58,53.09 260.58,54.11 261.24,54.76 261.24,60.79 261.12,60.91 261.12,63.97 261.97,64.83 261.97,65.81 263.07,66.9 263.07,74.59 256.3,81.35
  BOTTOM w0.152: v2(259.99,54.43) 258.93,53.37 JDIMM3.67
DDR_B_D26: length 57.9
  TOP w0.076: v2(249.09,92.47) UC1.BB8
  TOP w0.152: v2(256.38,55.45) 257.22,56.3 257.22,57.48 255.93,58.78 JDIMM4.79
  IN1 w0.076: 253.61,80.36 253.61,81.48 253.19,81.9 252.9,81.9 250.15,84.64 250.15,86.02 248.75,87.42 248.75,91.27 248.7,91.33 248.7,91.98 248.93,92.2 249.09,92.36 v2(249.09,92.47)
  IN1 w0.14: 253.61,80.36 260.39,73.58 260.39,68.66 259.34,67.62 259.34,65.97 258.49,65.13 258.49,64.61 257.44,63.56 257.44,59.83 256.91,59.3 256.91,58.93 257.35,58.49 257.35,58.29 257.16,58.1 256.95,58.1 256.59,58.47 256.07,58.47 255.64,58.04 255.64,55.38 255.82,55.2 256.13,55.2 v2(256.38,55.45)
  BOTTOM w0.152: v2(256.38,55.45) 257.08,56.16 257.08,57.43 255.68,58.84 JDIMM3.80
DDR_B_D27: length 56
  TOP w0.076: v2(250,92.47) UC1.BC8
  TOP w0.152: v2(259.97,57.04) 259.59,57.04 257.93,58.71 JDIMM4.71
  IN1 w0.076: v2(250,92.47) 250,92.36 250.15,92.2 250.16,92.2 250.38,91.98 250.38,91.98 250.42,91.93 250.42,91.21 250.65,90.98 250.65,89.72 251.21,89.16 251.21,85.91 255.46,81.66 255.46,81.15 255.88,80.73
  IN1 w0.14: 255.88,80.73 262.26,74.35 262.26,67.89 262.06,67.69 262.06,67.48 262.22,67.31 262.22,67.1 262.07,66.94 261.85,66.94 261.69,67.11 261.47,67.11 261.24,66.87 261.24,65.13 260.38,64.28 260.38,63.43 259.87,62.92 259.87,61.43 259.38,60.93 259.38,60.57 259.52,60.43 260.29,60.43 260.46,60.25 260.46,59.97 260.29,59.8 259.52,59.8 259.34,59.62 259.34,59.38 259.48,59.24 260.36,59.24 260.5,59.1 260.5,58.83 260.35,58.68 259.48,58.68 259.34,58.54 259.34,58.28 259.49,58.13 260.36,58.13 260.5,57.99 260.5,57.71 260.36,57.57 260.11,57.57 259.97,57.43 v2(259.97,57.04)
  BOTTOM w0.152: JDIMM3.70 258.18,58.83 258.65,58.36 259.21,58.36 259.66,57.91 259.66,57.36 v2(259.97,57.04)
DDR_B_D28: length 58
  TOP w0.076: v2(250,93.77) UC1.BC10
  TOP w0.152: JDIMM4.67 258.93,59 259.76,58.16 259.95,58.16 260.68,57.44 260.68,56.49 v2(259.99,55.8)
  IN1 w0.076: v2(250,93.77) 250.38,93.39 250.38,92.29 250.65,92.01 250.65,91.29 250.83,91.11 250.83,89.96 251.54,89.25 251.54,85.84 255.77,81.61 255.77,81.36 256.06,81.07
  IN1 w0.14: 256.06,81.07 262.7,74.43 262.7,67.05 261.61,65.96 261.61,64.98 260.75,64.13 260.75,63.07 260.24,62.56 260.24,60.99 260.87,60.36 260.87,54.92 260.73,54.78 260.48,54.78 260.4,54.87 260.4,55.4 v2(259.99,55.8)
  BOTTOM w0.152: v2(259.99,55.8) 260.3,55.8 260.7,56.21 260.7,57.53 259.18,59.05 JDIMM3.66
DDR_B_D29: length 56.9
  TOP w0.076: v2(249.09,93.77) UC1.BB10
  TOP w0.152: JDIMM4.80 255.68,52.84 256.38,53.54 256.38,54.08 256.38,54.08 v2(256.38,54.13)
  IN1 w0.076: 253.29,81.3 253.29,81.44 253.09,81.63 252.9,81.63 249.97,84.57 249.97,85.94 248.57,87.34 248.57,91.14 248.43,91.27 248.43,91.99 248.7,92.26 248.7,93.39 v2(249.09,93.77)
  IN1 w0.14: 253.29,81.3 253.29,80.15 260.02,73.42 260.02,68.82 258.97,67.77 258.97,66.12 258.11,65.27 258.11,64.75 257.07,63.71 257.07,60.07 255.27,58.27 255.27,54.97 255.44,54.8 255.65,54.8 255.8,54.65 255.8,54.43 255.65,54.28 255.44,54.28 255.27,54.11 255.27,52.95 255.42,52.8 255.84,52.8 255.98,52.94 255.98,53.73 v2(256.38,54.13)
  BOTTOM w0.152: JDIMM3.79 255.93,52.83 256.52,53.42 256.52,53.99 v2(256.38,54.13)
DDR_B_D30: length 52.7
  TOP w0.076: v2(250,91.82) UC1.BC7
  TOP w0.152: v2(258.55,53.86) 258.66,53.75 258.66,53.02 258.18,52.53 JDIMM4.70
  IN1 w0.076: 255.46,80.63 254.99,81.1 254.99,81.64 253.42,83.22 252.76,83.22 250.99,84.99 250.99,88.93 250.48,89.43 250.48,90.83 250,91.32 v2(250,91.82)
  IN1 w0.14: 255.46,80.63 261.89,74.2 261.89,68.04 260.84,66.99 260.84,65.26 260.01,64.43 260.01,63.81 259.5,63.3 259.5,61.58 258.97,61.05 258.97,57.94 259.5,57.41 259.5,53 259.33,52.83 259.04,52.83 258.9,52.97 258.9,53.51 v2(258.55,53.86)
  BOTTOM w0.152: v2(258.55,53.86) 258.55,53.22 257.93,52.6 JDIMM3.71
DDR_B_D31: length 57.8
  TOP w0.076: v2(249.09,91.82) UC1.BB7
  TOP w0.152: JDIMM4.84 254.68,52.65 255.88,53.86 255.88,56.24 v2(256.38,56.75)
  IN1 w0.076: 253.97,80.51 253.97,81.47 253.2,82.25 252.87,82.25 250.36,84.76 250.36,86.1 248.98,87.49 248.98,91.71 v2(249.09,91.82)
  IN1 w0.14: 253.97,80.51 260.76,73.73 260.76,68.51 259.71,67.46 259.71,65.72 258.86,64.88 258.86,64.46 257.84,63.44 257.84,57.95 257.61,57.72 257.61,56.55 257.46,56.4 257.18,56.4 257.04,56.54 257.04,57.44 256.52,57.97 256.26,57.97 256.1,57.81 256.1,57.59 256.38,57.3 v2(256.38,56.75)
  BOTTOM w0.152: v2(256.38,56.75) 256.2,56.75 255.74,56.29 255.74,53.32 254.93,52.5 JDIMM3.83
DDR_B_D32: length 61
  TOP w0.076: v2(232.63,94.42) UC1.AA11
  TOP w0.152: JDIMM4.186 227.18,52.53 226.91,52.8 226.89,52.8 v2(224.15,55.53)
  IN1 w0.076: v2(232.63,94.42) 232.08,93.88 232.08,92.38 232.08,92.37 232.08,92.26 231.77,91.95 231.77,91.39 231.36,90.99 231.36,85.83 227.9,82.36
  IN1 w0.14: 227.9,82.36 227.9,81.65 218.88,72.63 218.88,68.35 219.1,68.13 219.96,68.13 220.15,67.94 220.15,66.11 223.43,62.83 223.43,61.63 223.67,61.38 223.67,61.01 223.53,60.86 222.98,60.86 222.82,60.7 222.82,60.48 222.98,60.32 223.53,60.32 223.67,60.17 223.67,59.56 223.84,59.4 223.84,58.94 224.54,58.24 224.54,57.25 225.06,56.73 225.06,55.5 224.79,55.23 224.46,55.23 v2(224.15,55.53)
  BOTTOM w0.152: v2(224.15,55.53) 224.15,54.8 226.21,52.74 226.56,52.74 226.93,52.37 JDIMM3.187
DDR_B_D33: length 63.1
  TOP w0.076: v2(232.63,93.77) UC1.AA10
  TOP w0.152: v2(225.56,57.68) 225.17,57.29 225.17,55.05 226.89,53.33 227.28,53.33 228.18,52.44 JDIMM4.182
  IN1 w0.076: 228.14,82.26 228.14,82.35 231.53,85.74 231.53,90.92 231.93,91.33 231.93,91.88 232.24,92.2 232.24,92.31 232.24,92.31 232.24,93.39 v2(232.63,93.77)
  IN1 w0.14: v2(225.56,57.68) 225.56,57.57 225.28,57.29 225.01,57.29 224.88,57.41 224.88,57.78 225.09,57.99 225.09,58.2 224.2,59.09 224.2,59.55 224.04,59.72 224.04,61.59 223.88,61.75 223.88,61.75 223.8,61.83 223.8,62.21 224.04,62.45 224.04,62.74 220.52,66.26 220.52,68.4 220.25,68.67 219.49,68.67 219.32,68.85 219.32,71.1 219.67,71.46 219.67,71.92 219.32,72.28 219.32,72.54 219.51,72.74 219.74,72.74 220.05,72.44 220.27,72.44 220.43,72.6 220.43,72.82 220.13,73.13 220.13,73.36 228.14,81.37 228.14,82.26
  BOTTOM w0.152: v2(225.56,57.68) 225.14,57.25 225.14,54.83 227.08,52.89 227.57,52.89 227.93,52.54 JDIMM3.183
DDR_B_D34: length 57.3
  TOP w0.076: v2(233.54,94.42) UC1.AC11
  TOP w0.152: JDIMM4.174 230.18,53.06 229.79,53.44 229.13,53.44 v2(228.6,53.97)
  IN1 w0.076: v2(233.54,94.42) 234.08,93.88 234.08,92.29 234.25,92.12 234.25,91.53 233.76,91.04 233.76,84.75 232.82,83.81 232.82,83.4 231.57,82.15
  IN1 w0.14: v2(228.6,53.97) 228.31,53.67 228.31,53.32 228.51,53.12 228.8,53.12 229.28,53.6 229.28,55.08 229.42,55.22 229.42,57.34 228.69,58.07 228.69,58.95 227.45,60.19 227.45,63.88 223.9,67.43 223.9,69.38 223.53,69.75 223.53,72.18 229.19,77.84 229.19,78.97 231.57,81.34 231.57,82.15
  BOTTOM w0.152: v2(228.6,53.97) 229.12,53.97 230.43,52.66 JDIMM3.173
DDR_B_D35: length 58.1
  TOP w0.076: v2(233.54,93.77) UC1.AC10
  TOP w0.152: JDIMM4.170 231.18,53 229.01,55.16 v2(228.56,55.16)
  IN1 w0.076: v2(233.54,93.77) 233.92,93.4 233.92,92.22 234.09,92.05 234.09,91.6 233.53,91.04 233.53,84.8 232.57,83.83 232.57,83.53 231.02,81.98
  IN1 w0.14: v2(228.56,55.16) 228.84,55.16 229.05,55.37 229.05,57.19 228.32,57.92 228.32,58.79 227.08,60.03 227.08,63.72 223.41,67.4 223.41,67.58 223.53,67.7 223.53,67.88 223.43,67.98 223.25,67.98 223.13,68.11 223.13,68.39 223.27,68.53 223.4,68.53 223.53,68.66 223.53,69.23 223.4,69.36 223.23,69.36 223.13,69.46 223.13,72.64 223.35,72.86 223.69,72.86 224.11,73.28 224.11,73.62 224.32,73.84 224.66,73.84 224.88,74.05 224.88,74.39 225.09,74.61 225.44,74.61 225.65,74.83 225.65,75.17 225.87,75.38 226.21,75.38 226.74,75.91 226.74,76.25 226.95,76.47 227.29,76.47 228.72,77.89 228.72,79.04 231.02,81.33 231.02,81.98
  BOTTOM w0.152: JDIMM3.169 231.43,52.56 228.82,55.16 v2(228.56,55.16)
DDR_B_D36: length 58.9
  TOP w0.076: v2(232.63,91.82) UC1.AA7
  TOP w0.152: JDIMM4.183 227.93,59.04 226.38,57.49 226.38,56.53 226.12,56.27 226.12,55.57 225.75,55.2 v2(225.58,55.2)
  IN1 w0.076: v2(232.63,91.82) 232.5,91.7 232.5,85.16 229,81.66 229,81.19 226.46,78.64
  IN1 w0.14: 226.46,78.64 221.26,73.45 221.26,71.03 221.04,70.82 221.04,70.6 221.26,70.38 221.26,69.5 221.07,69.31 221.07,68.95 221.26,68.76 221.26,66.6 224.78,63.08 224.78,60.02 224.94,59.86 224.94,59.4 226.48,57.86 226.48,54.26 226.25,54.04 225.81,54.04 225.58,54.28 v2(225.58,55.2)
  BOTTOM w0.152: JDIMM3.182 228.18,59.03 226.29,57.14 226.29,56.39 225.98,56.08 225.98,55.6 v2(225.58,55.2)
DDR_B_D37: length 57.7
  TOP w0.076: v2(232.63,92.47) UC1.AA8
  TOP w0.152: JDIMM4.187 226.93,58.95 226.09,58.11 226.09,56.73 225.77,56.41 v2(225.58,56.41)
  IN1 w0.076: 226.19,78.89 228.38,81.09 228.38,82.35 231.69,85.67 231.69,90.85 232.1,91.26 232.1,91.82 232.63,92.34 v2(232.63,92.47)
  IN1 w0.14: v2(225.58,56.41) 225.91,56.08 226.07,56.08 226.17,56.18 226.17,56.5 225.98,56.69 225.98,57.08 226.17,57.28 226.17,57.64 224.57,59.25 224.57,59.71 224.41,59.87 224.41,62.89 220.89,66.41 220.89,68.59 220.66,68.82 220.66,69.13 220.5,69.29 219.96,69.29 219.8,69.45 219.8,69.68 219.96,69.84 220.73,69.84 220.89,70 220.89,70.22 220.73,70.38 219.96,70.38 219.8,70.54 219.8,70.77 219.96,70.93 220.63,70.93 220.89,71.19 220.89,71.33 220.73,71.49 220.29,71.49 220.13,71.65 220.13,71.87 220.3,72.04 220.73,72.04 220.89,72.2 220.89,73.6 226.19,78.89
  BOTTOM w0.152: v2(225.58,56.41) 225.99,56.82 225.99,57.76 227.18,58.94 JDIMM3.186
DDR_B_D38: length 57.8
  TOP w0.076: v2(233.54,92.47) UC1.AC8
  TOP w0.152: JDIMM4.169 231.43,59.08 229.61,57.26 229.61,57.03 229.89,56.74 229.89,56.51 229.72,56.35 229.49,56.35 229.21,56.63 228.86,56.63 v2(228.6,56.37)
  IN1 w0.076: v2(233.54,92.47) 233.75,92.26 233.75,92.15 233.92,91.98 233.92,91.67 233.3,91.05 233.3,84.8 230.57,82.07 230.57,81.38 228.25,79.06 228.25,78.56
  IN1 w0.14: 228.25,78.56 228.25,77.94 228.07,77.76 227.68,77.76 227.47,77.56 227.47,77.17 227.27,76.96 226.9,76.96 226.32,76.39 226.32,76.02 226.06,75.75 225.68,75.75 223.73,73.8 223.73,73.45 223.59,73.3 223.24,73.3 222.76,72.82 222.76,69.29 223.03,69.02 223.03,68.82 222.76,68.56 222.76,67.92 222.94,67.74 222.94,67.57 222.76,67.38 222.76,67.26 223.08,66.94 223.35,66.94 223.78,66.5 223.78,66.23 224.03,65.98 224.3,65.98 224.55,65.73 224.55,65.46 224.8,65.21 225.08,65.21 225.33,64.96 225.33,64.69 225.59,64.42 225.86,64.42 226.04,64.24 226.04,63.93 226.19,63.78 226.5,63.78 226.72,63.57 226.72,59.74 227.96,58.5 227.96,57.64 228.27,57.33 228.39,57.33 228.68,57.04 228.68,56.46 v2(228.6,56.37)
  BOTTOM w0.152: JDIMM3.170 231.18,58.95 229.57,57.34 229.57,57.11 229.92,56.76 229.92,56.53 229.75,56.37 229.52,56.37 229.17,56.71 228.94,56.71 v2(228.6,56.37)
DDR_B_D39: length 57.6
  TOP w0.076: v2(233.54,91.82) UC1.AC7
  TOP w0.152: v2(227.63,54.7) 228.13,55.2 228.13,56.62 230.43,58.91 JDIMM4.173
  IN1 w0.076: v2(233.54,91.82) 233.54,91.56 233.11,91.13 233.11,85.1 233.11,84.91 230.11,81.91 230.11,81.3 227.88,79.07 227.88,78.56
  IN1 w0.14: 227.88,78.56 227.88,78.47 222.39,72.98 222.39,67.07 226.35,63.11 226.35,59.59 227.59,58.35 227.59,57.49 228.14,56.93 228.14,55.26 227.63,54.75 v2(227.63,54.7)
  BOTTOM w0.152: JDIMM3.174 230.18,58.91 228.09,56.83 228.09,54.96 227.83,54.7 v2(227.63,54.7)
DDR_B_D40: length 66.3
  TOP w0.076: v2(230.8,92.47) UC1.W8
  TOP w0.152: v2(222.81,57.59) 223.76,56.64 223.76,55.37 224.12,55.01 224.26,55.01 226.18,53.09 JDIMM4.190
  IN1 w0.076: v2(230.8,92.47) 230.8,92.41 231.18,92.03 231.18,91.56 230.82,91.21 230.82,86.13 226.03,81.34 225.42,81.34 225.02,80.93
  IN1 w0.14: 225.02,80.93 224.65,80.57 224.65,80.36 224.5,80.21 224.26,80.21 224,79.95 224,79.7 223.73,79.44 223.49,79.44 223.22,79.17 223.22,78.93 223.06,78.77 222.82,78.77 222.64,78.59 222.64,78.34 222.26,77.97 220.57,77.97 216.24,73.64 216.24,67.69 216.38,67.55 216.65,67.55 216.79,67.69 216.79,69.49 216.93,69.62 217.2,69.62 217.34,69.49 217.34,67.54 217.13,67.33 217.13,66.81 219.13,64.81 219.46,64.81 221.28,62.98 221.28,60.54 221.42,60.4 221.42,59.85 222.28,59 222.28,57.53 222.4,57.41 222.63,57.41 v2(222.81,57.59)
  BOTTOM w0.152: JDIMM3.191 225.93,52.38 223.62,54.69 223.62,57.13 223.16,57.59 v2(222.81,57.59)
DDR_B_D41: length 64.4
  TOP w0.076: v2(230.8,91.82) UC1.W7
  TOP w0.152: v2(222.83,56.37) 223.36,55.85 223.36,55.43 224.13,54.65 224.23,54.65 225.47,53.41 225.47,52.82 225.18,52.53 JDIMM4.194
  IN1 w0.076: v2(230.8,91.82) 230.63,91.65 230.63,86.18 225.99,81.54 224.54,81.54 224.34,81.34
  IN1 w0.14: 224.34,81.34 224.34,81.05 224.08,80.79 223.79,80.79 223.56,80.57 223.56,80.13 223.37,79.93 223.2,79.93 223.07,80.06 222.91,80.06 222.68,79.82 222.68,79.67 222.8,79.54 222.8,79.48 222.8,79.35 222.63,79.18 222.44,79.18 222.27,79.35 222.12,79.35 221.87,79.1 221.87,78.95 222.18,78.63 222.18,78.46 222.06,78.34 221.81,78.34 221.57,78.57 221.37,78.57 221.14,78.34 220.42,78.34 215.87,73.79 215.87,67.54 216.27,67.14 216.61,67.14 216.76,67 216.76,66.66 218.97,64.44 219.3,64.44 219.46,64.28 219.46,63.96 219.62,63.79 219.95,63.79 220.12,63.63 220.12,63.38 220.27,63.23 220.52,63.23 220.7,63.04 220.7,62.83 220.54,62.67 220.54,62.49 220.65,62.38 220.8,62.38 220.91,62.27 220.91,61.98 220.77,61.84 220.66,61.84 220.52,61.7 220.52,61.43 220.66,61.29 220.77,61.29 220.91,61.15 220.91,60.89 220.77,60.75 220.64,60.75 220.52,60.62 220.52,60.39 220.63,60.28 220.91,60.28 221.06,60.13 221.06,59.7 221.91,58.85 221.91,57.13 222.02,57.02 222.21,57.02 222.41,56.83 222.41,56.66 222.25,56.5 222.01,56.5 221.91,56.41 221.91,55.98 222.1,55.79 222.26,55.79 222.83,56.36 v2(222.83,56.37)
  BOTTOM w0.152: v2(222.83,56.37) 223.04,56.37 223.25,56.16 223.25,53.64 223.84,53.06 224.36,53.06 224.93,52.5 JDIMM3.195
DDR_B_D42: length 64
  TOP w0.076: v2(229.88,93.77) UC1.V10
  TOP w0.152: v2(220.78,54.36) 221.34,54.36 222.68,53.03 JDIMM4.204
  IN1 w0.076: 222.48,82.35 222.63,82.5 224.63,82.5 228.81,86.68 228.81,90.89 228.93,91.01 228.93,91.74 229.51,92.33 229.51,93.41 v2(229.88,93.77)
  IN1 w0.14: 222.48,82.35 220.33,80.2 219.65,80.2 212.92,73.47 212.92,70.49 214.01,69.4 214.01,66.72 217.63,63.09 217.63,61 218.36,60.27 218.36,59.72 219.98,58.11 219.98,55.82 219.41,55.25 219.41,53.48 219.72,53.18 221.4,53.18 221.54,53.31 221.54,53.88 221.33,54.09 221.05,54.09 v2(220.78,54.36)
  BOTTOM w0.152: v2(220.78,54.36) 221.15,54.36 222.93,52.59 JDIMM3.203
DDR_B_D43: length 65.2
  TOP w0.076: v2(229.88,94.42) UC1.V11
  TOP w0.152: v2(219.48,57.74) 220.32,57.74 220.42,57.84 221,57.84 221.93,58.76 JDIMM4.207
  IN1 w0.076: v2(229.88,94.42) 229.35,93.89 229.35,92.4 228.77,91.81 228.77,91.08 228.61,90.92 228.61,86.71 224.56,82.67 222.28,82.67 222.2,82.59
  IN1 w0.14: v2(219.48,57.74) 219.48,58.09 217.98,59.58 217.98,60.13 217.26,60.84 217.26,62.94 213.31,66.9 213.31,67.13 213.64,67.46 213.64,69.25 213.5,69.39 213.23,69.39 213.09,69.25 213.09,67.66 212.95,67.52 212.69,67.52 212.55,67.66 212.55,69.52 212.88,69.85 212.88,69.99 212.55,70.32 212.55,73.62 216.59,77.67 216.59,77.87 216.36,78.1 216.36,78.3 216.55,78.48 216.75,78.48 216.98,78.25 217.18,78.25 217.36,78.44 217.36,78.64 217.13,78.87 217.13,79.07 217.32,79.26 217.52,79.26 217.75,79.02 217.95,79.02 218.14,79.21 218.14,79.41 217.9,79.64 217.9,79.84 218.09,80.03 218.29,80.03 218.52,79.8 218.72,79.8 218.91,79.99 218.91,80.18 218.68,80.42 218.68,80.61 218.87,80.8 219.06,80.8 219.3,80.57 220.18,80.57 222.2,82.59
  BOTTOM w0.152: JDIMM3.208 221.68,58.58 220.94,57.84 220.72,57.84 220.48,57.6 219.62,57.6 v2(219.48,57.74)
DDR_B_D44: length 65
  TOP w0.076: UC1.W11 v2(230.8,93.77)
  TOP w0.152: JDIMM4.191 225.93,58.96 224.71,57.75 224.71,57.22 224.32,56.83 v2(224.15,56.83)
  IN1 w0.076: v2(230.8,93.77) 231.18,93.39 231.18,92.27 231.35,92.1 231.35,91.49 230.99,91.14 230.99,86.01 226.05,81.08 225.89,81.08 225.52,80.71
  IN1 w0.14: v2(224.15,56.83) 223.88,56.83 223.77,56.72 223.77,56.19 223.65,56.07 223.39,56.07 223.29,56.16 223.29,57.97 222.82,58.45 222.82,58.98 221.79,60.01 221.79,60.56 221.65,60.7 221.65,63.13 219.61,65.18 219.28,65.18 217.76,66.7 217.76,73.28 217.62,73.42 217.35,73.42 217.21,73.28 217.21,70.13 217.07,69.99 216.8,69.99 216.66,70.13 216.66,73.54 220.73,77.6 222.41,77.6 225.52,80.71
  BOTTOM w0.152: JDIMM3.190 226.18,59.1 224.6,57.52 224.6,57.27 v2(224.15,56.83)
DDR_B_D45: length 62.9
  TOP w0.076: UC1.W10 v2(231.71,93.77)
  TOP w0.152: JDIMM4.195 224.93,58.53 224.46,58.06 v2(224.14,58.06)
  IN1 w0.076: v2(231.71,93.77) 231.34,93.41 231.34,92.34 231.51,92.17 231.51,91.43 231.2,91.11 231.2,86 231.15,85.95 231.15,85.91 227.52,82.28 227.52,82.18 225.91,80.57
  IN1 w0.14: 225.91,80.57 222.56,77.23 221.02,77.23 217.89,74.1 217.89,73.9 218.07,73.71 218.27,73.71 221.23,76.66 221.42,76.66 221.61,76.48 221.61,76.28 218.24,72.9 218.24,68.08 218.58,67.74 218.58,67.55 218.12,67.09 218.12,66.9 218.31,66.71 218.51,66.71 219,67.2 219.18,67.2 219.38,67 219.38,66.85 218.9,66.37 218.9,66.08 219.43,65.55 219.8,65.55 222.02,63.32 222.02,63.01 222.14,62.89 222.34,62.89 222.48,62.75 222.48,62.48 222.34,62.34 222.16,62.34 222.02,62.2 222.02,61.94 222.16,61.8 222.36,61.8 222.5,61.66 222.5,61.39 222.36,61.25 222.16,61.25 222.02,61.11 222.02,60.85 222.16,60.71 222.16,60.16 223.19,59.13 223.19,58.61 223.73,58.06 v2(224.14,58.06)
  BOTTOM w0.152: JDIMM3.194 225.18,58.97 224.27,58.06 v2(224.14,58.06)
DDR_B_D46: length 64.4
  TOP w0.076: v2(229.88,91.82) UC1.V7
  TOP w0.152: v2(220.78,57.23) 220.62,57.23 220.33,56.95 220.33,53.9 221.68,52.56 JDIMM4.208
  IN1 w0.076: 223.18,82 223.29,82.12 225.63,82.12 230.04,86.53 230.04,91.67 v2(229.88,91.82)
  IN1 w0.14: v2(220.78,57.23) 220.78,58.35 219.19,59.94 219.19,60.48 218.88,60.79 218.88,62.94 214.74,67.07 214.74,72.81 214.6,72.95 214.34,72.95 214.2,72.81 214.2,70.8 214.06,70.66 213.79,70.66 213.65,70.8 213.65,73.17 219.95,79.47 220.64,79.47 223.18,82
  BOTTOM w0.152: JDIMM3.207 221.93,52.64 220.33,54.24 220.33,56.78 v2(220.78,57.23)
