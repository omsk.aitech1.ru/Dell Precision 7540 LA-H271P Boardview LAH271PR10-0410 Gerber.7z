# Allegro board LAH271PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PME#: length 4.2
  TOP w0.102: T178.1 170.77,26.01 174.1,26.01 174.13,26.04 174.54,26.04 UH1.BE36
POA_WAKE#_R: length 8.4
  TOP w0.109: RZ364.2 192.27,2.67 v1(192.15,2.78) 190.82,4.12 187.52,4.12 187.1,3.7 JUSH1.23
POWER_SW#_MB: length 477.4
  TOP w0.109: JPB1.1 319.05,43.75 318.74,43.45 CZ541.1 317.38,42.94 317.63,42.69 318.14,42.69 318.43,42.4 PWRSW1.1 318.9,41.84 320.33,40.41 323.51,40.41 324.59,39.33 SW3.4 SW3.2 329.57,40.24 329.57,44.4 v2(331.26,46.08) ; JAPS1.11 18.36,4.67 v2(18.26,4.57) ; v2(192.05,62.04) 192.75,62.04 195.86,65.15 195.86,73.22 196.77,74.13 196.77,76.08 197.76,77.07 197.76,79.59 199.12,80.94 202.33,80.94 213.17,70.11 235.96,70.11 239.62,66.44 241.58,66.44 246.26,71.12 264.9,71.12 265.35,71.57 277.37,71.57 279.2,69.74 279.2,69.22 282.01,66.41 289.43,66.41 290.06,65.78 v2(294.78,65.78)
  IN2 w0.081: v2(192.05,62.04) 191.48,62.62 191.48,63.17 191.74,63.43 192.15,63.43 192.62,63.9 192.62,64.4 191.73,65.29 181.08,65.29 176.33,60.55 174.41,60.55 167.83,53.96 167.83,52.85 167.98,52.69 167.98,51.87 161.89,45.77 160.72,45.77 158.26,43.31 156.61,43.31 155.59,42.29 154.88,42.29 153.95,41.36 151.28,41.36 150.69,40.76 141.69,40.76 141.24,41.21 140,41.21 137.41,38.63 136.31,38.63 135.97,38.97 135.97,40.96 135.16,41.77 129.92,41.77 128.45,40.3 v2(128.45,39.7) 126.95,38.2 122.5,38.2 120.28,35.98 117.75,35.98 116.26,34.49 109.55,34.49 107.07,36.96 107.07,38.24 106.31,39.01 102.81,39.01 102.42,39.4 99.84,39.4 99.19,40.06 99.19,40.72 97.27,42.64 91.51,42.64 90.76,41.89 84.07,41.89 83.36,42.59 82.34,42.59 81.93,43 81.39,43 80.78,43.61 78.56,43.61 78.35,43.82 77.43,43.82 75.36,45.9 71.98,45.9 71.4,45.32 71.4,44.07 70.27,42.94 70.12,42.94 69.83,42.65 69.83,42.12 67.42,39.71 66.19,39.71 65.56,39.08 65.56,37.64 66.8,36.39 71.36,36.39 73.15,34.6 73.15,32.44 73.37,32.22 73.37,31.45 73.95,30.87 73.95,30.32 72.56,28.94 72.56,26.81 76.04,23.33 76.04,22.37 75.54,21.87 67.57,21.87 66.62,22.82 65.4,22.82 64.94,22.36 64.37,22.36 64.19,22.53 63.46,22.53 63.08,22.14 63.08,21.65 62.84,21.41 60.98,21.41 60.87,21.51 60.8,21.59 60.8,22.18 60.35,22.63 59.6,22.63 59.5,22.73 58.9,22.73 58.51,22.73 57.78,22 57.78,21.25 56.98,20.45 54.4,20.45 53.06,19.12 48.19,19.12 47.88,19.42 46.73,19.42 46.05,18.74 46.05,17.64 44.89,16.47 40.68,16.47 39.89,17.26 38.09,17.26 35.75,19.6 35.75,20.28 34.9,21.14 32.38,21.14 31.75,20.5 31.75,19.82 32.17,19.39 33.95,19.39 34.95,18.39 36.2,18.39 36.6,17.99 36.6,13.39 35.36,12.14 34.3,12.14 33.24,13.2 31.29,13.2 29.86,11.77 28.36,11.77 25.97,9.37 19.39,9.37 17.58,7.56 17.58,5.26 v2(18.26,4.57) ; v2(294.78,65.78) 298.44,62.12 299.92,62.12 313.73,48.32 329.03,48.32 v2(331.26,46.08)
  BOTTOM w0.109: RE33.2 CE10.1 v2(128.45,39.7) ; v2(294.78,65.78) 294.78,65.78 v3(295.51,65.05) ; v3(191.7,61.22) 191.7,61.68 v2(192.05,62.04) 192.93,62.04 v3(193.17,62.28)
POWER_SW_IN#: length 49.3
  TOP w0.102: UE1.D5 v2(133.53,26.45)
  TOP w0.109: v2(134.6,14.28) 134.13,14.28 133.72,13.87 133.72,11.8 134.16,11.36 137.1,11.36 QZ22.3
  IN4 w0.102: v2(134.6,14.28) 134.24,13.92 130.63,13.92 130.29,14.27 130.29,14.98 131.31,16 131.31,16.68 130.88,17.11 128.45,17.11 128.01,17.55 128.01,19.79 127.23,20.57 127.23,22.61 127.86,23.24 127.86,24.82 128.57,25.53 129.13,25.53 130.47,26.86 132.95,26.86 133.36,26.45 v2(133.53,26.45)
  BOTTOM w0.102: v2(133.53,26.45) 133.53,26.64 133.12,27.05 133.12,28.1 133.11,28.12 133.11,28.21 132.75,28.57 132.75,30.25 133.25,30.74 133.25,31.91 v1(133.05,32.11) 133.05,32.42 132.51,32.96
  BOTTOM w0.109: RE33.1 RE31.2 CE12.1 131.14,37.23 130.11,36.2 130.11,35.34 131.08,34.38 131.5,34.38 131.88,34 131.88,33.59 132.51,32.96
PRIM_PWRGD: length 70.3
  TOP w0.109: v2(120.37,7.01) 120.37,6.16 v1(120.66,5.87) 120.94,5.59 PR906.1 ; UE1.L7 v2(134.33,20.85)
  TOP w0.254: v2(156.73,9.65) 155.63,9.65 PR812.1
  IN3 w0.081: v2(134.33,20.85) 134.33,20.65 135.28,19.7 135.28,18.71 134.56,17.98 134.56,16.67 135.1,16.12 135.1,15.27 134.74,14.91 133.65,14.91 133.56,14.82 132.81,14.82 131.22,13.23 130.89,13.23 130.21,12.55 128.78,12.55 127.84,11.6 126.45,11.6 v2(125.62,12.44) ; v2(143.12,14.3) 143.93,13.49 143.93,10.2 144.92,9.21 156.3,9.21 v2(156.73,9.65)
  BOTTOM w0.109: v2(143.12,14.3) 143.19,14.23 143.19,12.55 142.78,12.14 141.17,12.14 140.16,11.13 139.71,11.13 139.51,11.32 138.83,11.32 138.22,10.71 135.69,10.71 134.6,11.8 134.6,13.68 134.03,14.25 134.03,14.86 133.69,15.2 133.69,17.34 133.43,17.6 133.43,19.91 134.33,20.81 v2(134.33,20.85) ; v2(125.62,12.44) 125.62,11.69 124.45,10.53 123.85,10.53 122.78,9.46 121.11,9.46 120.37,8.72 v2(120.37,7.01)
PROCHOT#: length 617.4
  TOP w0.104: RE288.2 v2(142.97,27.1)
  TOP w0.109: PR1110.2 268.5,151.41 v2(268.74,151.65) ; JIO1.28 58.55,2.45 58.31,2.7 58.31,3.13 60.43,5.25 61.03,5.25 v2(61.21,5.07) ; UV69.2 185.93,93.18 186.48,93.73 186.48,95 186.72,95.24 186.72,95.56 187.12,95.96 v2(187.63,95.96) ; v2(281.07,30.81) 281.52,30.36 282.36,30.36 PR718.1 ; RC84.1 266.66,107.17 266.83,107 CC324.1 267.28,107.57 267.25,107.59 RC83.2 267.25,108.7 267.33,108.77 267.33,110.01 266.91,110.43 v2(266.91,111.38) ; v2(269.76,18.41) 269.55,18.62 266.5,18.62 266.29,18.42 262.77,18.42 254.22,9.87 254.22,7.8 v3(253.58,7.16) 252.66,6.24 250.13,6.24 249.96,6.41 248.47,6.41 248.16,6.1 248.16,4.2 247.53,3.57 246.95,3.57 v2(246.45,3.07)
  IN1 w0.102: v2(269.76,18.41) 271.04,19.69 274.39,19.69 280.46,25.76 280.46,30.2 v2(281.07,30.81)
  IN2 w0.081: v2(268.74,151.65) 269,151.39 v2(270.28,151.39) ; v2(187.63,95.96) 188.19,95.96 188.43,95.72 188.43,94.53 188,94.09 188,91.05 187.84,90.9 187.84,88.15 188.11,87.88 189.14,87.88 189.87,87.15 189.87,77.84 190.55,77.16 190.55,74.67 192.6,72.62 192.6,65.25 193.08,64.77 193.08,63.05 v2(192.57,62.54)
  IN3 w0.081: 289.04,38.56 280.65,38.56 274.51,32.41 263.16,32.41 262,31.26 232.88,31.26 232.64,31.49 231.37,31.49 230.7,32.16 228.46,32.16 227.59,33.04 222.8,33.04 221.67,34.16 220.95,34.16 220.25,34.86 216.01,34.86 212.85,38.01 209.81,38.01 206.73,41.08 206.73,43.3 206.82,43.39 206.82,47.38 206.82,47.57 203.34,51.05 202.83,51.05 200.07,53.81 199.84,53.81 198.9,54.75 198.9,54.83 197.92,55.81 197.49,55.81 195.58,57.71 195.58,60.1 193.73,61.95 193.16,61.95 v2(192.57,62.54) ; 289.04,38.56 289.04,38.22 286.55,35.73 286.55,33.99 284.21,31.65 281.9,31.65 v2(281.07,30.81) ; 289.04,38.56 289.37,38.89 289.37,42.8 v2(289.52,42.95) ; v2(82.3,20.89) 83.11,20.89 83.4,21.19 83.77,21.19 84.31,21.73 89.63,21.73 89.94,22.05 92.89,22.05 94.08,20.86 98.33,20.86 98.9,20.29 100.78,20.29 101.66,21.17 101.66,22.76 102.1,23.19 105.02,23.19 106.59,24.76 106.59,25.12 109.06,27.59 109.06,28.62 110.03,29.59 110.96,29.59 111.59,28.96 118.99,28.96 121.01,30.98 125.17,30.98 125.39,30.76 126.7,30.76 127.64,31.71 128.87,31.71 129.43,31.15 130.29,31.15 130.81,30.63 131.2,30.63 132.27,31.71 134.66,31.71 137.34,29.03 139.07,29.03 139.98,28.12 140.47,28.12 140.74,28.39 141.99,28.39 142.97,27.4 v2(142.97,27.1)
  IN4 w0.102: v2(246.45,3.07) 246.13,2.74 241.33,2.74 241.05,3.03 241.05,5.42 236.17,10.3 236.17,10.63 235.93,10.87 229.34,10.87 228.61,11.6 220.93,11.6 219.11,9.77 210.05,9.77 208.67,8.39 205.36,8.39 205.07,8.68 202.1,8.68 198.89,11.88 197.04,11.88 196.76,11.6 195.3,11.6 194.56,10.87 186.38,10.87 185.56,11.69 181.56,11.69 181.33,11.92 181.33,12.39 181.09,12.63 179.34,12.63 178.32,13.64 178.32,14.28 176.4,16.2 174.2,16.2 174.06,16.34 173.8,16.34 173.43,16.71 172.83,16.71 171.72,17.83 171.01,17.83 169.91,18.93 168.53,18.93 167.78,19.68 167,19.68 166.6,20.08 166.6,20.74 164.91,22.42 164.55,22.42 164.3,22.67 164.3,24.53 162.29,26.55 162.04,26.55 161.12,27.47 161.12,27.95 159.71,29.36 151.59,29.36 150.19,27.95 143.47,27.95 142.97,27.45 v2(142.97,27.1) ; v2(75.24,6.53) 74.65,6.53 73.78,7.4 70.3,7.4 67.07,4.17 65.8,4.17 64.94,3.31 64.51,3.31 64.19,2.99 62.82,2.99 62.41,3.4 62.41,4.77 61.99,5.19 61.32,5.19 v2(61.21,5.07) ; v2(270.28,151.39) 271.47,151.39 272.25,150.62 272.25,145.05 276.6,140.7 276.6,121.18 273.75,118.33 268.13,118.33 266.19,116.39 266.19,112.95 266.91,112.24 v2(266.91,111.38) 267.76,110.53 278.23,110.53 284.24,104.53 284.24,96.22 285.63,94.83 285.63,80.46 286.78,79.31 287.46,79.31 290.54,76.23 290.54,73.2 293.38,70.36 293.38,66.18 294.11,65.46 294.11,55.65 289.92,51.46 289.92,46.05 289.52,45.65 v2(289.52,42.95)
  BOTTOM w0.109: v2(82.3,20.89) 82.29,20.89 82.29,19.91 82.56,19.64 82.56,17.97 81.95,17.37 80.48,17.37 79.92,16.8 79.92,10.56 78.54,9.18 76.67,9.18 75.24,7.76 v2(75.24,6.53) ; PR1103.2 268.5,151.41 v2(268.74,151.65)
PROCHOT#_R: length 1.8
  TOP w0.203: PR718.2 283.61,30.7 PU700.10
PROCHOT#_R1: length 4
  TOP w0.109: UE1.H13 139.88,23.99 140.31,23.99 141.58,25.27 141.58,25.9 RE288.1
PS_ID: length 96.4
  TOP w0.109: v2(62.01,7.32) 62.05,7.28 JIO1.13 ; v2(74.74,7.09) v1(75.44,7.09) ; UE1.J8 135.53,22.82 v2(135.9,22.45)
  IN3 w0.081: v2(135.9,22.45) 135.16,21.71 135.16,20.36 135.7,19.82 135.7,18.53 134.98,17.81 134.98,16.84 136.17,15.64 136.17,15.18 135.84,14.85 135.74,14.85 134.61,13.72 132.36,13.72 131.41,12.77 131.07,12.77 130.4,12.09 128.97,12.09 128.03,11.15 125.73,11.15 124.62,12.26 119.54,12.26 119.12,12.68 112.9,12.68 112.28,13.3 95.67,13.3 92.39,10.02 91.51,10.02 91.29,9.81 86.21,9.81 86.02,9.62 83.19,9.62 82.05,8.48 82.05,8.12 81.72,7.79 81.72,7.69 79.97,5.94 77.67,5.94 76.51,7.09 v2(74.74,7.09)
  IN4 w0.102: v2(74.74,7.09) 74.21,7.63 70.2,7.63 66.98,4.4 65.71,4.4 64.93,3.63 64.42,3.63 64.21,3.42 63.54,3.42 63.26,3.7 63.26,4.55 62.01,5.8 v2(62.01,7.32)
PSID_DISABLE#: length 120.5
  TOP w0.102: UE1.D7 v2(134.33,27.25)
  TOP w0.109: v2(64.58,4.12) 64.58,3.73 63.05,2.2 JIO1.10
  IN3 w0.081: v2(64.58,4.12) 62.82,2.37 57.35,2.37 55.31,4.41 55.31,4.58 52.62,7.27 52.62,8.2 54.93,10.52 54.93,14.01 55.65,14.74 55.98,14.74 56.34,15.09 56.34,16.47 58.32,18.46 60.08,18.46 61.03,19.41 62.51,19.41 63.68,20.57 64.49,20.57 64.76,20.84 73.01,20.84 73.38,21.21 75.53,21.21 77.09,19.66 78.14,19.66 79.94,17.86 82.88,17.86 85.15,20.13 89.01,20.13 90.59,18.56 92.98,18.56 94.63,16.91 102.95,16.91 104.9,18.85 111.77,18.85 112.47,19.54 116.02,19.54 117.46,20.99 122.18,20.99 122.95,20.21 124.6,20.21 125.21,20.83 125.21,21.56 125.61,21.96 126.91,21.96 127.54,22.59 127.54,23.66 127.85,23.98 128.7,23.98 129.97,25.25 133.67,25.25 133.95,25.53 133.95,26.87 v2(134.33,27.25)
  BOTTOM w0.109: v2(64.58,4.12) 64.58,3.84 v1(64.9,3.52)
PTP_DISABLE#: length 167.5
  TOP w0.109: v2(139.27,17.03) 139.42,17.17 RE748.1 139.92,18.38 138.73,19.57 UE1.N12 ; v2(272.62,1.94) 272.81,1.75 279.34,1.75 280.06,2.47 RZ1484.2
  IN4 w0.102: v2(272.62,1.94) 271.86,1.17 260.38,1.17 259.38,2.17 254.98,2.17 254.05,3.1 247.32,3.1 247.09,2.87 247.09,2.28 246.93,2.11 240.95,2.11 240.59,2.47 240.59,5.23 236.38,9.45 235.56,9.45 234.6,10.41 229.04,10.41 228.32,11.14 221.12,11.14 219.3,9.32 210.8,9.32 209.3,7.82 209.3,6.79 208.93,6.41 207.95,6.41 207.32,5.78 204.96,5.78 203.52,7.22 201.62,7.22 199.81,9.03 196.19,9.03 195.88,9.33 187.8,9.33 187.14,8.67 181.23,8.67 179.12,10.79 178.59,10.79 176.32,13.06 174.24,13.06 172.54,14.77 170.87,14.77 170.62,15.02 166.55,15.02 164.67,16.9 163.18,16.9 162.68,17.4 161.45,17.4 160.55,18.3 158.27,18.3 157.8,18.78 156.2,18.78 153.59,21.39 153.08,21.39 152.9,21.57 151.77,21.57 150.89,22.45 149.04,22.45 146.42,19.83 146.42,19.33 143.74,16.65 140.83,16.65 140.45,17.03 v2(139.27,17.03)
  BOTTOM w0.109: v2(139.27,17.03) v1(139.85,17.03)
PWM1_1PH/ICCMAX1: length 59.1
  TOP w0.203: PU1100.44 264.18,149.09 v2(264.19,149.1)
  TOP w0.254: PU1800.1 217.6,132.65 v3(218.51,133.57) 218.66,133.71 218.66,133.86 v2(219.09,134.3)
  IN4 w0.254: v2(264.19,149.1) 264.46,148.83 264.46,148.28 264.11,147.92 262.14,147.92 261.68,148.38 254.64,148.38 253.81,147.55 248.33,147.55 246.58,145.8 231.87,145.8 225.8,139.73 225.8,136.77 223.92,134.89 219.69,134.89 v2(219.09,134.3)
  BOTTOM w0.203: v2(264.19,149.1) 264.34,149.1 264.92,148.52 264.92,148.42 PR1120.1
PWM1_2PH/ICCMAX2: length 17.5
  TOP w0.203: v2(264.61,139.91) 265.06,140.36 265.06,140.78 264.58,141.26 PU1100.23
  TOP w0.254: v2(269.9,130.2) 269,130.2 268.69,130.51 268.69,132.37 v3(267.41,133.64) 264.61,136.45 v2(264.61,139.91)
  BOTTOM w0.203: PR1152.1 265.07,140.81 265.07,140.37 v2(264.61,139.91)
  BOTTOM w0.305: v2(269.9,130.2) 269.61,129.91 PU1700.1
PWM1_4PH/ICCMAX4: length 17.1
  TOP w0.203: PU1100.18 262.58,140.46 v2(262.65,140.39)
  TOP w0.254: v2(252.06,139.99) 252.06,139.83 251.84,139.62 PU1200.1
  IN2 w0.254: v2(252.06,139.99) 252.44,139.61 253.72,139.61 254.26,139.06 261.32,139.06 v2(262.65,140.39)
  BOTTOM w0.109: v1(252.58,140.5) 252.06,139.99 v2(252.06,139.99)
  BOTTOM w0.203: PR1155.1 261.39,140.72 261.7,140.72 262.02,140.39 v2(262.65,140.39)
PWM2_2PH/ROSC1: length 2.3
  TOP w0.203: PU1100.22 264.18,141.19 264.61,140.76 v2(264.61,140.57)
  BOTTOM w0.203: PR1171.1 264.65,140.61 v2(264.61,140.57)
PWM2_4PH/ADDR: length 24.5
  TOP w0.203: v2(263.26,140.34) 263.26,140.55 v1(263.02,140.8) 262.98,140.84 PU1100.19
  TOP w0.254: v2(244.32,139.89) 244.32,139.69 244.14,139.51 PU1201.1
  IN2 w0.254: v2(263.26,140.34) 263.26,140.48 262.82,140.92 259.91,140.92 259.24,140.26 252.61,140.26 252.19,140.67 245.1,140.67 v2(244.32,139.89)
  BOTTOM w0.203: v2(263.26,140.34) 263.26,140.45 262.85,140.86 262.38,140.86 PR1156.1
PWM3_4PH/VBOOT: length 35.3
  TOP w0.203: PU1100.20 263.37,141.97 263.37,141.04 263.74,140.67 263.74,139.98 v2(263.69,139.93)
  TOP w0.254: PU1202.1 236.41,139.51 236.61,139.72 v2(236.61,139.88)
  IN2 w0.254: v2(236.61,139.88) 238.18,141.44 252.18,141.44 252.42,141.68 253.65,141.68 253.88,141.44 257.76,141.44 258.25,140.96 259.13,140.96 259.55,141.38 262.93,141.38 263.81,140.5 263.81,140.05 v2(263.69,139.93)
  BOTTOM w0.109: v1(237.05,140.44) 237.05,140.31 v2(236.61,139.88)
  BOTTOM w0.203: v2(263.69,139.93) 263.82,140.06 263.82,140.51 263.53,140.8 263.38,140.8 262.77,141.41 PR1157.1
PWM4_4PH/ROSCM: length 52.1
  TOP w0.203: PU1100.21 263.78,141.12 264.15,140.75 264.15,139.73 v2(263.74,139.32)
  TOP w0.254: PU1203.1 228.51,137.05 228.82,137.36 v2(228.82,137.47)
  IN4 w0.254: v2(253.77,142.15) 253.14,142.15 252.32,141.32 231.77,141.32 228.82,138.37 v2(228.82,137.47)
  BOTTOM w0.203: PR1158.1 264.15,140.89 264.15,139.73 v2(263.74,139.32)
  BOTTOM w0.254: v2(263.74,139.32) 264.31,138.75 264.31,137.08 262.99,135.75 258.39,135.75 v3(257.63,136.5) 256.7,137.44 254.63,137.44 253.99,138.08 253.99,141.54 253.77,141.76 v2(253.77,142.15)
PWM_FAN1: length 245.9
  TOP w0.102: UE1.L10 v2(136.73,20.85)
  TOP w0.109: v2(274.14,85.29) 273.74,84.89 270.15,84.89 259.47,74.21 214.87,74.21 205.04,84.04 199.5,84.04 190.92,75.47 190.92,71.91 191.23,71.61 191.23,68.85 182.97,60.59 182.97,58.07 v2(183.45,57.59) ; RZ505.2 v2(302.45,52.02) 303.79,52.02 304.72,51.09 304.72,50.34 304.03,49.65 JFAN1.2
  IN2 w0.081: v2(136.73,20.85) 136.73,20.87 136.31,21.3 136.31,22.74 136.42,22.85 136.86,22.85 137.11,23.1 137.11,23.47 137.51,23.87 138.94,23.87 139.82,24.74 141.38,24.74 142.26,25.62 145.37,25.62 149.54,29.79 155.68,29.79 159.03,33.14 159.03,33.88 160.42,35.27 162.92,35.27 163.78,36.14 166.07,36.14 166.36,36.42 167.17,36.42 168.09,37.34 168.09,37.79 168.55,38.25 169.84,38.25 172.35,40.76 172.35,40.86 174.11,42.63 174.11,43.63 173.63,44.12 173.63,45.3 174.11,45.78 174.91,45.78 175.72,46.59 175.72,47.86 176.67,48.81 176.67,50.64 183.45,57.42 v2(183.45,57.59) ; v2(274.14,85.29) 274.14,85.24 274.17,85.21 274.17,79.29 277.97,75.49 286.85,75.49 288.94,73.39 288.94,67.84 298.15,58.64 299.88,58.64 302.45,56.06 v2(302.45,52.02)
  BOTTOM w0.109: v2(183.45,57.59) v3(183.45,56.84)
PWM_FAN2: length 88.9
  TOP w0.102: UE1.L11 v2(137.53,20.85)
  TOP w0.109: v2(81.19,39.15) 80.69,39.65 80.69,42.66 81.65,43.63 81.65,46.17 82.03,46.54 82.03,48.7 81.68,49.05 81.1,49.05 v2(79.48,50.67) ; JFAN2.2 77.95,54.03 v2(78.03,53.95)
  IN1 w0.102: v2(137.53,20.85) 137.15,20.46 133.07,20.46 132.22,19.62 131.72,19.62 131.28,20.06 130.47,20.06 129.39,18.98 128.76,18.98 128.11,19.63 125.54,19.63 125.29,19.39 v2(125.29,19.37)
  IN2 w0.081: v2(81.19,39.15) 81.87,39.15 82.46,38.56 87.95,38.56 88.26,38.25 91.73,38.25 97.17,32.82 97.87,32.82 98.87,31.82 98.87,30.09 100.66,28.3 101.82,28.3 104.15,25.97 108.56,25.97 109.16,25.36 114.38,25.36 118.01,21.73 119.03,21.73 119.49,21.28 120.25,21.28 120.77,20.76 122.09,20.76 122.54,20.3 122.54,20.3 123.1,19.74 124.92,19.74 v2(125.29,19.37)
  BOTTOM w0.109: v2(79.48,50.67) v3(77.3,52.85) 77.3,53.27 77.52,53.5 77.52,54.3 RZ504.2 78.03,54.7 v2(78.03,53.95)
REFCLK_CNV: length 181.3
  TOP w0.102: v2(189.71,40.83) 189.31,40.83 UH1.R6
  IN2 w0.081: v2(320.53,13.6) 320.53,13.2 321.05,12.69 321.05,12.17 320.48,11.6 320.48,10.75 319.31,9.59 313.52,9.59 312.96,9.03 309.58,9.03 308.83,9.79 299.96,9.79 299.53,10.22 290.51,10.22 287.69,13.03 278.88,13.03 276.27,15.64 276.27,16.76 270.29,22.74 243.42,22.74 241.8,21.12 239.11,21.12 238.55,21.68 233.23,21.68 231.35,23.56 219.44,23.56 v2(217.31,21.43)
  IN3 w0.081: v2(217.31,21.43) 216.88,21.86 210.9,21.86 209.26,23.5 208.18,23.5 206.26,25.42 200.17,25.42 198.13,27.45 198.13,32.11 196.33,33.91 196.33,35.93 194.8,37.46 193.09,37.46 192.45,38.1 191.06,38.1 190.72,38.44 190.72,39.18 189.71,40.19 v2(189.71,40.83)
  IN4 w0.102: v2(320.53,13.6) 320.53,13.96 320.85,14.28 321.96,14.28 323.78,16.1 329.15,16.1 v2(332.69,19.64)
  BOTTOM w0.109: v2(332.69,19.64) 332.84,19.79 v1(332.84,20.43) 332.84,22.17 333.02,22.35 RZ371.2 ; RH110.2 191.49,45.44 191.49,43.95 190.87,43.32 190.87,41.3 190.4,40.83 v2(189.71,40.83)
REG_OUT:
  vias: v3(27.35,18.88)
REM_DIODE1_N: length 319.8
  TOP w0.254: v2(247.92,149.81) 248,149.89 248,151.93 249.14,153.07 250.37,153.07 250.97,152.48 250.97,151.55 CE339.1 251.42,151.11 QE26.2 250.77,149.54 QE26.1 ; UE1.A8 135.39,29.39 135.39,30.17 135.56,30.34 135.56,31.27 CE24.1 135.56,31.67 135.56,33.02 135.78,33.24 135.78,33.84 136.34,34.4 136.91,34.4 v2(137,34.49)
  IN1 w0.254: v2(244.91,99.24) 245.01,99.14 245.01,98.48 244.51,97.98 230.9,97.98 230.76,97.84 226.14,97.84 224.92,99.06 224.57,99.41 223.85,99.41 223.21,98.78 223.21,96.88 222.91,96.57 219.1,96.57 218.62,96.09 216.23,96.09 213.8,93.67 212.99,93.67 210.97,91.65 210.97,88.49 199.92,77.45 199.92,75.63 198.09,73.8 196.02,73.8 189.57,67.35 189.57,64.08 189.91,63.75 189.91,63.39 v2(189.81,63.3)
  IN2 w0.254: v2(186.66,118.15) 186.73,118.23 186.73,118.67 187.54,119.47 188.17,119.47 188.69,119.99 188.69,120.55 189.78,121.64 193.99,121.64 194.83,122.49 194.83,128.97 194.63,129.18 194.63,130.77 195.69,131.83 198.07,131.83 199.01,130.89 203.22,130.89 203.94,131.62 206.72,131.62 208.46,133.37 213.3,133.37 214.48,132.19 217.77,132.19 218.25,132.67 218.25,133.21 217.94,133.52 217.94,134.85 223.95,140.86 226.92,140.86 234.22,148.16 243.3,148.16 244.24,147.21 247.16,147.21 248,148.05 248,149.44 247.92,149.52 v2(247.92,149.81) ; v2(137,34.49) 137.69,34.49 138.19,34.99 146.74,34.99 146.87,35.13 147.53,35.13 148.23,34.43 150.93,34.43 151.25,34.75 153.56,34.75 156.58,37.77 156.93,37.77 161.02,41.87 162.55,41.87 162.89,42.2 163.11,42.2 164.66,43.75 164.66,44.31 174.03,53.68 174.03,55.55 182.28,63.8 189.72,63.8 189.91,63.61 189.91,63.4 v2(189.81,63.3)
  IN4 w0.254: v2(186.66,118.15) 186.73,118.08 186.73,112.14 189.09,109.78 189.09,109.42 190.2,108.31 190.65,108.31 190.96,108 190.96,107.22 194.11,104.07 194.11,102.22 190.76,98.87 190.76,96.99 191.59,96.16 194.7,96.16 195.09,95.76 196.04,95.76 198.99,92.81 198.99,88.91 198.75,88.67 198.75,80.61 197.59,79.45 197.59,73.75 191.3,67.46 191.3,66.75 190.18,65.62 190.18,65.09 189.87,64.79 189.87,63.36 v2(189.81,63.3)
  BOTTOM w0.254: QE3.3 244.78,100.03 CE35.2 245.01,99.8 245.01,99.35 v2(244.91,99.24)
REM_DIODE1_P: length 320.2
  TOP w0.254: QE26.3 250.12,151.21 CE339.2 250.46,151.55 250.46,152.27 250.16,152.57 249.35,152.57 248.5,151.72 248.5,149.89 v2(248.58,149.81) ; v2(137,35.17) 136.96,35.17 136.7,34.91 136.13,34.91 v1(136.12,34.9) 135.27,34.05 135.27,33.45 135.05,33.23 135.05,31.67 CE24.2 135.05,31.27 135.05,30.55 134.88,30.38 134.88,29.39 UE1.A7
  IN1 w0.254: v2(245.62,99.24) 245.52,99.14 245.52,98.27 244.72,97.47 231.11,97.47 230.97,97.33 225.93,97.33 224.35,98.91 224.06,98.91 223.72,98.57 223.72,96.67 223.12,96.07 219.32,96.07 218.83,95.58 216.44,95.58 214.01,93.16 213.2,93.16 211.48,91.44 211.48,88.28 200.43,77.23 200.43,75.42 198.3,73.29 196.23,73.29 190.08,67.14 190.08,64.29 190.41,63.96 190.41,63.41 v2(190.52,63.3)
  IN2 w0.254: v2(248.58,149.81) 248.58,149.52 248.5,149.44 248.5,147.84 247.37,146.7 244.03,146.7 243.09,147.65 234.43,147.65 227.13,140.35 224.16,140.35 218.45,134.64 218.45,133.73 218.76,133.42 218.76,132.46 217.98,131.68 214.27,131.68 213.09,132.86 208.67,132.86 206.93,131.11 204.16,131.11 203.43,130.39 198.8,130.39 197.86,131.32 195.9,131.32 195.14,130.56 195.14,129.39 195.34,129.18 195.34,122.28 194.2,121.14 189.99,121.14 189.19,120.34 189.19,119.78 188.38,118.97 187.75,118.97 187.24,118.45 187.24,118.23 v2(187.32,118.15) ; v2(137,35.17) 137.04,35.17 137.21,35 137.48,35 137.98,35.5 146.52,35.5 146.66,35.64 147.74,35.64 148.44,34.94 150.72,34.94 151.04,35.26 153.35,35.26 156.37,38.28 156.72,38.28 160.81,42.38 162.34,42.38 162.68,42.71 162.9,42.71 164.15,43.96 164.15,44.52 173.52,53.89 173.52,55.76 182.08,64.32 189.94,64.32 190.42,63.84 190.42,63.4 v2(190.52,63.3)
  IN4 w0.254: v2(187.32,118.15) 187.24,118.08 187.24,112.35 189.6,109.99 189.6,109.63 190.41,108.82 190.86,108.82 191.47,108.21 191.47,107.43 194.62,104.28 194.62,102.01 191.26,98.66 191.26,97.2 191.8,96.66 194.91,96.66 195.3,96.27 196.25,96.27 199.5,93.02 199.5,88.7 199.26,88.46 199.26,80.4 198.1,79.24 198.1,73.54 191.81,67.25 191.81,66.54 190.69,65.41 190.69,64.88 190.38,64.58 190.38,63.35 190.44,63.3 v2(190.52,63.3)
  BOTTOM w0.254: QE3.1 246.08,102.36 QE3.2 245.73,100.77 CE35.1 245.52,99.77 245.52,99.35 v2(245.62,99.24)
REM_DIODE2_N: length 95
  TOP w0.127: UE1.A10 136.93,29.45 136.93,30.25 137.36,30.67 137.36,32.01 CE26.1 137.19,32.63 137.19,33 v2(137.31,33.13)
  IN2 w0.127: v2(69.61,40.65) 69.7,40.56 70.34,40.56 71.4,41.62 71.4,42.46 72.49,43.54 75.36,43.54 76.74,42.16 80.18,42.16 80.75,41.59 81.22,41.59 82,40.81 82.99,40.81 83.34,40.46 91.39,40.46 91.69,40.76 93.57,40.76 94.61,39.71 96.82,39.71 99.34,37.2 100.49,37.2 101.6,36.09 102.03,36.09 103.49,34.63 103.49,34.13 105.16,32.46 107.8,32.46 110.67,29.59 114.87,29.59 118.65,25.81 119.86,25.81 120.49,25.19 120.49,24.91 121.03,24.37 121.96,24.37 122.47,24.88 123.41,24.88 125.4,22.89 127.26,22.89 128.04,23.67 128.04,25.02 130.7,27.67 130.7,29.09 131.65,30.04 131.65,30.33 131.93,30.61 131.93,30.97 132.43,31.47 134.7,31.47 135.06,31.83 136.63,31.83 137.14,32.34 137.14,32.95 v2(137.31,33.13)
  BOTTOM w0.127: v2(69.61,40.65) 69.56,40.7 69.56,41.11 CE46.2 68.82,40.78 QE7.1 68.53,39.72 68.53,38.9 69.32,38.12 QE7.2
REM_DIODE2_P: length 94.6
  TOP w0.127: UE1.A9 136.33,29.25 136.55,29.47 136.55,30.4 136.97,30.83 136.97,31.93 CE26.2 136.81,32.38 136.81,32.91 v2(136.6,33.12)
  IN2 w0.127: v2(70.13,41.06) 71.02,41.95 71.02,42.61 72.33,43.92 75.52,43.92 76.9,42.54 80.34,42.54 80.91,41.97 81.38,41.97 82.16,41.19 83.15,41.19 83.5,40.84 91.24,40.84 91.53,41.14 93.72,41.14 94.77,40.1 96.98,40.1 99.5,37.58 100.65,37.58 101.76,36.47 102.19,36.47 103.87,34.79 103.87,34.29 105.32,32.84 107.96,32.84 110.82,29.97 115.02,29.97 118.81,26.19 120.02,26.19 120.87,25.34 120.87,25.07 121.19,24.75 121.8,24.75 122.32,25.26 123.57,25.26 125.56,23.27 127.1,23.27 127.66,23.83 127.66,25.17 130.32,27.83 130.32,29.25 131.27,30.2 131.27,30.49 131.55,30.77 131.55,31.13 132.27,31.85 134.55,31.85 134.9,32.21 136.47,32.21 136.76,32.5 136.76,32.95 v2(136.6,33.12)
  BOTTOM w0.127: v2(70.13,41.06) 69.89,41.3 69.89,41.69 69.65,41.92 69.05,41.92 CE46.1 68.44,40.72 68.15,40.43 68.15,38.75 68.17,38.72 QE7.3
REM_DIODE3_N: length 87
  TOP w0.127: UE1.B9 v2(135.93,28.85) ; v2(188.47,60.26) 188.57,60.15 188.57,59.74 189.3,59 192.48,59 192.94,59.46 196.35,59.46 196.79,59.01 196.79,58.41 197.77,57.44 197.77,57.29 CE272.2 197.57,56.11 QE104.3
  IN2 w0.127: v2(135.93,28.85) 135.73,29.05 135.73,29.3 138.39,31.97 138.39,33.25 138.71,33.57 141.1,33.57 141.9,32.78 142.92,32.78 143.15,33.01 151.44,33.01 151.77,33.35 154.06,33.35 157.02,36.31 157.43,36.31 161.07,39.95 162.39,39.95 163.01,40.57 163.39,40.57 163.63,40.81 165.61,40.81 166.47,41.67 166.91,41.67 167.49,42.26 167.49,43.12 168.67,44.3 169.18,44.3 170.6,45.72 170.6,48.36 175.44,53.2 175.44,55.07 182.13,61.76 187.8,61.76 188.7,60.86 188.7,60.48 v2(188.47,60.26)
  BOTTOM w0.127: v2(135.93,28.85) 135.77,29.01 135.77,29.36 CE270.1
REM_DIODE3_P: length 90.7
  TOP w0.127: v2(189.18,60.26) 189.09,60.26 188.95,60.11 188.95,59.89 189.46,59.38 192.33,59.38 192.78,59.84 v4(195.1,59.84) 196.51,59.84 197.18,59.17 197.18,58.57 198.19,57.56 198.19,57.39 CE272.1 198.48,56.17 QE104.2 198.71,54.7 QE104.1 ; UE1.B8 135.49,28.45 v2(135.11,28.82)
  IN2 w0.127: v2(189.18,60.26) 189.08,60.36 189.08,61.02 187.95,62.14 181.97,62.14 175.06,55.23 175.06,53.36 170.22,48.52 170.22,45.88 169.02,44.68 168.51,44.68 167.11,43.28 167.11,42.42 166.75,42.05 166.31,42.05 165.45,41.19 163.47,41.19 163.23,40.95 162.85,40.95 162.23,40.33 160.92,40.33 157.27,36.69 156.87,36.69 153.9,33.73 151.61,33.73 151.28,33.39 142.99,33.39 142.76,33.16 142.05,33.16 141.26,33.95 138.55,33.95 138.01,33.41 138.01,32.12 135.35,29.46 135.35,29.06 v2(135.11,28.82)
  BOTTOM w0.127: CE270.2 135.24,29.29 135.24,28.95 v2(135.11,28.82)
REM_DIODE4_N: length 208.2
  TOP w0.127: UE1.A11 137.91,29.27 137.91,29.83 139.01,30.93 139.01,31.47 CE27.1 139.16,31.96 139.16,32.27 139.41,32.52 139.41,32.82 v2(139.62,33.03) ; QE6.3 278.46,12.59 278.46,13.62 CE39.2 278.02,14.06 277.57,14.06 276.95,13.44 275.84,13.44 274.23,15.06 274.23,17.07 275.54,18.39 275.54,23.61 274.12,25.03 269.43,25.03 266.54,27.92 263.41,27.92 261.05,25.56 259.12,25.56 258.31,24.74 251.23,24.74 250.86,25.12 235.43,25.12 233.78,26.76 233.78,28.28 231.54,30.51 228.15,30.51 227.78,30.14 220.58,30.14 213.58,23.14 213.58,17.45 212.66,16.54 212.66,12.48 211.27,11.09 211.27,10.07 209.94,8.73 209.94,6.79 210.51,6.23 210.51,2.91 208.98,1.39 199.05,1.39 196.79,3.65 196.79,6.16 196.58,6.37 196.38,6.37 v2(196.19,6.18)
  IN4 w0.127: v2(196.19,6.18) 195.95,6.42 194.99,6.42 194.47,6.94 193.67,6.94 193.23,6.49 191.93,6.49 191.46,6.02 189.81,6.02 189.04,6.79 178.94,6.79 175.91,9.82 174.81,9.82 174.35,10.28 168.36,10.28 167.25,11.38 166.61,11.38 163.79,14.2 163.59,14.2 163.05,14.74 159.71,14.74 158.88,15.57 158.88,15.91 158.55,16.23 156.58,16.23 156.13,16.68 154.77,16.68 153.24,18.21 153.24,18.63 152.74,19.12 150.05,19.12 149.26,19.92 149.26,20.72 v2(149.06,20.92)
  BOTTOM w0.127: v2(139.62,33.03) 139.39,33.26 139.39,33.49 139.99,34.09 142.93,34.09 143.8,33.22 145.48,33.22 148.4,30.31 148.4,22.42 149.27,21.55 149.27,21.13 v2(149.06,20.92)
REM_DIODE4_P: length 213.2
  TOP w0.127: QE6.1 279.1,11.28 279.75,11.93 QE6.2 278.84,13.48 278.84,14.15 CE39.1 278.06,14.46 278.03,14.46 278.02,14.44 277.42,14.44 276.79,13.82 276,13.82 274.61,15.21 274.61,16.91 275.93,18.23 275.93,23.77 274.28,25.41 269.59,25.41 266.7,28.3 263.25,28.3 260.89,25.94 258.96,25.94 258.15,25.12 251.39,25.12 251.02,25.5 235.58,25.5 234.16,26.92 234.16,28.43 231.7,30.89 227.99,30.89 227.62,30.52 220.42,30.52 213.2,23.3 213.2,17.61 212.28,16.69 212.28,12.63 210.89,11.25 210.89,10.22 209.56,8.89 209.56,6.64 210.13,6.07 210.13,3.07 208.82,1.77 199.21,1.77 197.17,3.81 197.17,6.32 196.73,6.75 196.33,6.75 v2(196.19,6.89) ; UE1.B10 137.13,28.63 137.52,29.01 137.52,29.25 137.53,29.27 137.53,29.99 138.63,31.09 138.63,31.57 CE27.2 138.77,32.15 138.77,32.43 139.03,32.68 139.03,32.91 v2(138.91,33.03)
  IN4 w0.127: v2(196.19,6.89) 196.1,6.8 195.15,6.8 194.63,7.32 193.51,7.32 193.07,6.88 191.77,6.88 191.3,6.41 189.97,6.41 189.2,7.17 179.09,7.17 176.07,10.2 174.97,10.2 174.51,10.66 168.51,10.66 167.41,11.76 166.77,11.76 163.95,14.58 163.74,14.58 163.21,15.12 159.87,15.12 159.26,15.73 159.26,16.07 158.71,16.62 156.74,16.62 156.29,17.06 154.93,17.06 153.62,18.37 153.62,18.78 152.9,19.5 150.21,19.5 149.64,20.08 149.64,20.79 v2(149.77,20.92)
  BOTTOM w0.127: v2(138.91,33.03) 139.01,33.13 139.01,33.65 139.84,34.47 143.09,34.47 143.96,33.6 145.64,33.6 148.78,30.47 148.78,22.58 149.65,21.7 149.65,21.04 v2(149.77,20.92)
RES_BIAS: length 4.1
  BOTTOM w0.109: UL1.12 186.43,129.74 186.15,130.03 186.15,130.52 185.38,131.28 RL13.1 v1(184.37,132.62)
RESET_IN#: length 9.3
  TOP w0.102: UE1.C1 129.93,27.71 129.36,28.28
  TOP w0.109: 129.36,28.28 128.84,28.79 v2(128.79,28.79)
  BOTTOM w0.109: RE362.1 124.67,32.81 127.1,30.38 127.1,29.92 127.34,29.68 v1(127.69,29.68) 127.96,29.68 128.79,28.85 v2(128.79,28.79)
RF_+1VSP: length 3.5
  TOP w0.109: PR804.1 156.39,15.23 156.07,15.55 v1(155.74,15.55)
  TOP w0.254: PR804.1 155.29,13.55 PU800.5
RING2: length 8.6
  TOP w0.203: UA1.30 348.84,23.03 349.55,22.32 350.39,22.32 v1(350.45,22.26)
  TOP w0.381: RA5.2 352.74,22 v2(352.59,22) v2(352,22) 350.89,22 350.63,22.26 v1(350.45,22.26)
  IN1 w1.016: 352.34,21.17 352.36,21.15 352.36,18.06
  vias: v2(351.58,18.12) v2(351.58,17.52)
RING2_R: length 13.7
  IN2 w1.016: JHP1.3 369.11,20.6 366.22,17.7 361.99,17.7 360.65,19.05 358.88,19.05
  BOTTOM w0.109: v2(357.94,18.67) 358.63,18.67 v3(358.8,18.84)
  vias: v2(357.32,18.67)
RJ45_MDIN0: length 34.4
  TOP w0.267: TL1.23 180.9,150.46 180.43,150 180.43,149.46 v2(180.57,149.33)
  IN1 w0.241: v2(180.57,149.33) 180.42,149.18 180.42,148.92 180.71,148.62 181.38,148.62 184.2,151.44 192.32,151.44 202.37,141.38 204.67,141.38 205.23,140.82 205.23,140.82 JLOM1.2
RJ45_MDIN1: length 36.5
  TOP w0.267: TL1.19 185.98,150.47 185.52,150.02 185.52,149.09 v2(185.66,148.95)
  IN3 w0.229: JLOM1.6 210.68,140.82 210.68,139.39 210.22,138.93 210.22,137.89 209.64,137.3 207.78,137.3 206.69,138.4 204.91,138.4 203.14,140.16 201.32,140.16 193.99,147.49 191.94,147.49 189.49,149.94 185.92,149.94 185.52,149.54 185.52,149.09 v2(185.66,148.95)
RJ45_MDIN2: length 30.8
  TOP w0.267: v2(188.21,148.43) 188.06,148.57 188.06,149.88 188.52,150.33 TL1.17
  IN4 w0.241: JLOM1.5 209.36,140.01 209.08,140.01 208.91,139.84 208.91,139.09 208.2,138.38 204.28,138.38 203.4,139.27 201.28,139.27 194.11,146.44 191.78,146.44 189.18,149.04 188.25,149.04 188.07,148.86 188.07,148.57 v2(188.21,148.43)
RJ45_MDIN3: length 31.3
  TOP w0.267: v2(192.1,148.65) 192.19,148.74 193.13,148.74 193.6,149.21 TL1.13
  IN2 w0.229: JLOM1.8 212.71,140.29 212.73,140.27 213.15,139.86 213.15,138.98 212.57,138.41 204.65,138.41 202.73,140.33 202,140.33 193.63,148.7 192.14,148.7 v2(192.1,148.65)
RJ45_MDIP0: length 34.4
  TOP w0.267: v2(179.91,149.33) 180.05,149.48 180.05,150.01 179.63,150.44 TL1.24
  IN1 w0.241: JLOM1.1 205.57,139.95 204.51,141 202.22,141 192.16,151.06 184.36,151.06 181.54,148.24 180.56,148.24 180.04,148.76 180.04,149.2 v2(179.91,149.33)
RJ45_MDIP1: length 36.6
  TOP w0.267: TL1.20 184.71,150.45 185.14,150.01 185.14,149.1 v2(185,148.95)
  IN3 w0.229: JLOM1.3 208.36,139.72 209.85,138.23 209.85,138.04 209.49,137.67 207.94,137.67 206.84,138.76 205.06,138.76 203.29,140.53 201.47,140.53 194.15,147.86 192.09,147.86 189.64,150.3 185.76,150.3 185.15,149.69 185.15,149.11 v2(185,148.95)
RJ45_MDIP2: length 30.8
  TOP w0.267: v2(187.55,148.43) 187.68,148.56 187.68,149.93 187.25,150.36 TL1.18
  IN4 w0.241: JLOM1.4 208.53,140.72 208.53,139.25 208.04,138.76 204.44,138.76 203.56,139.65 201.44,139.65 194.27,146.82 191.94,146.82 189.34,149.42 188.09,149.42 187.68,149.02 187.68,148.56 v2(187.55,148.43)
RJ45_MDIP3: length 31.2
  TOP w0.267: v2(192.1,149.51) 192.1,149.25 192.23,149.12 192.97,149.12 193.22,149.37 193.22,149.71 192.96,149.97 192.55,149.97 192.33,150.19 TL1.14
  IN2 w0.229: v2(192.1,149.51) 192.1,149.29 192.33,149.06 193.78,149.06 202.15,140.69 202.88,140.69 204.8,138.77 212.42,138.77 212.78,139.13 212.78,139.71 212.56,139.92 212.42,139.92 212.37,139.98 211.94,139.98 JLOM1.7
RREF: length 3
  BOTTOM w0.254: UR1.44 26.14,14.62 26.42,14.34 v1(26.66,14.34)
  BOTTOM w0.305: RR205.1 27.74,14.34 v1(26.66,14.34)
RTC_DET#: length 81.3
  TOP w0.109: v2(175.74,34.45) 175.66,34.53 175.49,34.53 174.93,35.09 174.51,35.09 174.26,34.84 UH1.BF18 ; v2(146.74,28.36) v1(146.74,26.8) 148.04,25.5 148.04,24.74 PQ26.1 ; RH734.2 132.23,10.62 v2(132.21,10.65)
  IN2 w0.081: v2(134.33,21.65) 134.71,22.03 134.71,22.83 135.51,23.63 136.22,23.63 136.86,24.26 138.39,24.26 138.74,24.61 138.74,25.07 138.94,25.27 139.45,25.27 139.6,25.12 140.9,25.12 141.45,25.67 141.45,26.43 143.38,28.36 v2(146.74,28.36) ; v2(162.24,27.43) 162.24,28.48 162.57,28.8 162.83,28.8 164.57,30.54 164.57,31.04 165.11,31.58 166.68,31.58 166.99,31.89 166.99,32.65 167.38,33.04 167.85,33.04 169.43,34.62 170.7,34.62 172.08,36 173.74,36 175.29,34.45 v2(175.74,34.45)
  IN3 w0.081: v2(134.33,21.65) 133.92,21.24 133.92,19.71 134.04,19.59 134.83,19.59 135.08,19.34 135.08,18.79 134.35,18.07 134.35,16.67 133.56,15.88 132.93,15.88 131.16,14.1 129,14.1 128.48,13.58 127.65,13.58 v2(127.2,13.13)
  IN4 w0.102: v2(146.74,28.36) 146.87,28.22 150.13,28.22 151.5,29.59 159.81,29.59 161.41,27.98 161.69,27.98 v2(162.24,27.43) ; v2(132.21,10.65) 132.21,10.8 131.93,11.08 130.01,11.08 129.42,11.67 127.82,11.67 127.2,12.3 v2(127.2,13.13)
RTCRST_ON: length 21
  TOP w0.102: UE1.F11 v2(137.53,24.85)
  TOP w0.109: RE93.1 152.96,32.74 QE12.2 152.12,32.35 148.18,32.35 146.32,30.48 146.32,30.2 v1(145.85,29.74) 145.55,29.44 v2(144.66,29.44)
  BOTTOM w0.102: v2(137.53,24.85) 137.95,25.27 137.95,25.81 138.17,26.03 138.43,26.03 138.7,26.3 138.7,26.76 140.34,28.39 143.62,28.39 v2(144.66,29.44)
RTCRST_ON_POWER: length 13.1
  TOP w0.109: RE747.2 147.44,26.92 147.24,27.12 147.24,28.49 146.74,29 144.48,29 144.35,29.13 143.77,29.13 143.5,29.39 143.5,30.55 143.31,30.75 141.98,30.75 141.6,31.13 v1(141.45,31.13) 141.2,31.13 140.95,30.88 140.95,30.34 140.15,29.55 140.15,29.03 139.98,28.86 139.57,28.45 UE1.B13
RTCRST_ON_R: length 5.1
  TOP w0.109: v1(147.33,30.52) 147.91,29.95 DE2.2 148.61,29.14 CE65.1 149.49,28.26 RE543.1 149.83,27.83 149.98,27.69 QE17.2
RTCRST_ON_R1: length 12.5
  TOP w0.109: CE64.1 151.22,31.9 QE15.2 148.91,31.35 DE2.1 147.94,31.65 146.69,30.4 146.69,29.61 v1(147.06,29.23) 147.6,28.69 147.6,27.94 RE747.1 RE543.2 RE541.2
RTD3_CIO_PWR_EN: length 188
  TOP w0.109: v2(46.14,39.72) 46.14,38.92 45.57,38.35 43.69,38.35 42.53,37.19 38.69,37.19 RT392.2 ; UH1.AE43 184,22.79 v2(183.32,22.11)
  IN2 w0.081: v2(183.32,22.11) 183.24,22.11 182.01,20.87 178.52,20.87 178.11,20.46 176.11,20.46 175.61,20.96 173.48,20.96 173.12,21.31 171.76,21.31 170.73,20.28 167.88,20.28 167.76,20.16 167.76,20 167.27,19.51 166.89,19.51 165.78,20.63 165.14,20.63 164.66,21.11 161.32,21.11 160.54,21.88 v2(158.79,21.88)
  IN3 w0.081: v2(46.14,39.72) 46.14,39.43 46.28,39.29 46.88,39.29 47.22,38.95 48.89,38.95 50.12,40.17 54.21,40.17 54.43,39.95 56.54,39.95 56.86,39.63 65.64,39.63 65.81,39.8 66.34,40.33 66.89,40.33 69.91,43.35 70.48,43.35 71.13,44 75.52,44 77.15,42.37 80.2,42.37 81.55,41.01 88.07,41.01 88.25,41.19 90.9,41.19 91.45,41.74 91.92,41.74 95.7,45.53 106.38,45.53 107.15,44.76 114.89,44.76 117.63,42.02 123.8,42.02 125.46,43.67 136.22,43.67 136.79,44.24 137.34,44.24 137.92,44.82 138.75,44.82 139.51,44.06 140.18,44.06 141.1,43.15 149.41,43.15 150.36,42.19 150.8,42.19 151.18,41.81 153.54,41.81 157.07,38.28 157.07,34.99 158.96,33.11 160.11,33.11 160.38,32.84 160.38,31.08 161.13,30.33 161.13,27.82 160.28,26.97 160.28,25.13 160.8,24.61 160.8,23.11 160.11,22.42 159.7,22.42 159.16,21.88 v2(158.79,21.88)
  BOTTOM w0.109: RH730.2 181.92,17.24 181.92,18.44 v1(182.18,18.71) 182.41,18.94 182.95,18.94 183.25,19.25 183.25,20.47 183.25,21.5 183.32,21.57 v2(183.32,22.11)
RTD3_CIO_PWR_EN_R: length 13.3
  TOP w0.109: v2(37.02,37.08) 37.07,37.14 RT614.1 37.07,38.1 37.59,38.63 RT392.1 37.84,38.78 37.48,39.13 RT643.1 37.48,39.8 RT372.1
  IN2 w0.081: v2(37.02,37.08) 36.62,37.48 33.02,37.48 32.55,37.96 32.55,38.81 33.11,39.38 33.11,41.03 v2(32.61,41.54)
  BOTTOM w0.109: UT1.T5 v2(32.61,41.54)
RTD3_SELECT: length 72.3
  TOP w0.109: v2(37.77,51.27) 38.04,51.54 v1(38.33,51.54) 38.42,51.54 38.65,51.31 38.65,50.3 38.88,50.07 RT447.2 39.41,49.86 39.41,49.15 39.26,49 UT32.6
  IN2 w0.081: v2(37.77,51.27) 37.58,51.45 37.4,51.63 37.26,51.68 37.06,51.68 36.65,51.76 36.19,51.95 35.85,52.09 35.63,52.13 35.45,52.17 35.42,52.17 35.36,52.18 35.35,52.18 34.09,52.29 32.21,52.29 31.16,53.35 30.7,53.35 29.76,52.41 29.32,52.41 28.27,51.35 28.27,49.78 26.66,48.16 25.51,48.16 25.07,47.73 v2(25.07,45.03)
  IN3 w0.081: v2(25.07,45.03) 19.91,45.03 18.65,43.78 18.65,42.08 16.59,40.01 16.59,36.63 16.39,36.43 16.39,31.45 17.56,30.28 17.56,28.7 15.52,26.66 13.41,26.66 12.57,25.82 10.35,25.82 10.04,26.13 7.63,26.13 6.83,25.33 6.36,25.33 5.92,24.88 5.92,24.29 6.54,23.67 6.54,18.33 6.17,17.97 6.17,15.82 6.28,15.71 v2(6.28,15.26)
  BOTTOM w0.109: v2(6.28,15.26) 6.28,15 6.82,14.46 UE12.21
RTD3_USB_PWR_EN: length 6.7
  TOP w0.109: RT591.1 36.9,38.5 36.73,38.33 35.78,38.33 35.65,38.46 35.65,39.01 35.25,39.41 35.25,39.42 RT26.1 35.19,39.54 34.77,39.96 33.7,39.96 33.26,40.41 v2(33.26,41.54)
  BOTTOM w0.109: UT1.V5 v2(33.26,41.54)
RUN_ON: length 749
  TOP w0.109: RE280.2 RE292.1 162.1,19.57 v2(162.58,20.05) 162.58,20.33 162.82,20.57 UE5.4 ; PR304.1 267.41,96 v2(266.46,95.05) 266.2,95.05 265.63,94.48 265.63,93.87 264.5,92.74 264.5,84.55 257.46,77.5 217.11,77.5 206.86,87.75 205.22,87.75 204.48,87.01 200.92,87.01 197.83,90.1 197.83,94.16 195.95,96.04 195.12,96.04 ; v2(252.73,28.55) 252.25,28.07 235.59,28.07 231.5,32.16 227.26,32.16 v2(226.13,31.03) ; UZ35.2 195.07,95.99 195.12,96.04 ; 195.12,96.04 194.46,96.04 194.29,95.86 193.61,95.86 v2(193.41,95.66) ; RZ549.1 v2(180.98,84.97) ; v2(293.38,61.36) 290.72,58.69 290.72,45.09 290.02,44.39 v2(290.02,41.42) ; RZ510.1 331.87,40.06 330.02,38.22 323.68,38.22 323.38,38.52 323.38,39.66 v2(323.19,39.85) 319.77,39.85 318.04,38.12 318.04,35.92 318.6,35.36 321.05,35.36 322.76,33.65 329.8,33.65 330.29,33.15 330.29,29.41 331.26,28.45 331.26,27.58 331,27.32 v2(331,27.3) 330.38,26.68 UZ60.2 ; v2(110.73,20.18) 113.77,20.18 115.49,18.46 v1(115.83,18.46) 116.5,18.46 116.76,18.72 117.45,18.72 117.7,18.46 QE2.2
  IN1 w0.102: v2(186.71,76.52) 184.63,76.52 183.22,77.93 182.64,77.93 180.46,80.12 180.46,84.44 v2(180.98,84.97)
  IN2 w0.081: v2(162.58,20.05) 162.3,19.77 161.48,19.77 161.17,20.08 160.44,20.08 160.11,20.41 159.14,20.41 158.01,21.53 156.87,21.53 156.83,21.49 152.13,21.49 150.89,20.25 149.77,20.25 149.39,19.88 147.21,19.88 145.57,18.23 144.47,18.23 143.18,16.94 142.36,16.94 139.43,14 137.08,14 136.69,13.61 133.43,13.61 133.35,13.69 130.38,13.69 129.75,13.07 128.75,13.07 128.08,13.74 126.43,13.74 126.05,14.12 124.82,14.12 124.47,13.78 121.42,13.78 120.71,14.49 118.4,14.49 117,15.88 113.52,15.88 112.31,17.09 112.31,18.71 110.84,20.18 v2(110.73,20.18) 110.38,20.18 110.11,19.92 103.8,19.92 103.47,20.25 99.15,20.25 98.43,20.97 98.43,25.88 v2(98.14,26.18)
  IN3 w0.081: v2(162.58,20.05) 162.58,20.49 162.38,20.69 161.77,20.69 158.78,17.7 158.78,15.49 158.43,15.14 158.43,13.49 159.96,11.96 160.71,11.96 162.01,10.66 165.67,10.66 166.49,11.48 167.62,11.48 168.2,10.89 177.73,10.89 179.89,13.06 182.32,13.06 183.35,12.03 188.17,12.03 189.75,13.62 195.73,13.62 196.46,14.35 197.99,14.35 198.58,14.94 209.33,14.94 209.86,14.41 227.55,14.41 232.08,18.94 247.1,18.94 252.44,24.28 252.44,28.26 v2(252.73,28.55) ; v2(193.41,95.66) 192.92,95.17 192.92,92.83 193.87,91.88 193.87,89.84 192.9,88.88 192.9,87.37 193.51,86.76 193.51,80.75 190.08,77.32 v2(190.08,76.59) 189.28,75.79 189.28,73.63 183.09,67.44 183.09,64.43 184.46,63.06 184.46,61.76 185.55,60.67 185.55,59.79 186.72,58.62 189.28,58.62 190.44,59.77 192.28,59.77 193.62,58.43 194.22,58.43 196.25,56.39 196.25,55.8 197.46,54.59 197.46,53.95 199.78,51.63 199.78,50.29 200.07,50 201.04,50 201.41,50.37 203.31,50.37 206.36,47.33 206.36,43.57 206.28,43.49 206.28,40.89 209.62,37.55 212.46,37.55 215.85,34.17 215.85,34.01 216.23,33.62 219.57,33.62 222.69,30.5 225.6,30.5 v2(226.13,31.03)
  IN4 w0.102: v2(293.38,61.36) 293.38,65.09 292.7,65.76 292.7,69.41 291.59,70.53 289.47,70.53 289.22,70.78 289.22,73.62 287.05,75.79 282.01,75.79 278.89,78.9 278.89,80.06 279.62,80.79 280.93,80.79 281.19,81.04 281.19,81.42 280.43,82.18 280.43,83.51 278.73,85.21 278.73,85.51 278.09,86.15 277.02,86.15 275.48,87.69 275.48,91.42 273.35,93.54 270.96,93.54 270.6,93.19 268.09,93.19 267.73,93.54 266.79,93.54 266.56,93.77 266.56,94.53 266.46,94.63 v2(266.46,95.05) ; v2(323.19,39.85) 323.19,41.12 322.98,41.33 319.33,41.33 318.99,41.67 315.25,41.67 314.38,42.55 308.1,42.55 307.7,42.14 290.74,42.14 v2(290.02,41.42) ; v2(98.14,26.18) 97.71,25.75 88.26,25.75 86.94,24.43 84.78,24.43 83.77,23.42 81.08,23.42 79,25.5 71.51,25.5 70.07,24.06 64.46,24.06 63.89,23.49 62.21,23.49 61.68,24.02 60.65,24.02 59.05,22.42 55.49,22.42 53.88,20.81 52.64,20.81 52.39,21.05 52.39,23.11 51.72,23.78 50.6,23.78 49.23,25.14 48.32,25.14 48.05,24.87 45.6,24.87 45.58,24.88 43.77,24.88 43.5,24.61 43.5,23.58 41.52,21.61 38.93,21.61 38.41,21.09 38.41,14.8 40.43,12.78 40.43,11.54 39.49,10.6 36.57,10.6 35.51,9.54 29.64,9.54 29.17,10.01 25.1,10.01 24.82,9.73 24.82,8.36 24.61,8.16 14.95,8.16 11.33,11.78 11.33,14.14 10.15,15.32 7.84,15.32 7.38,15.78 v2(7.38,16.19) ; v2(190.08,76.59) 189.97,76.47 186.77,76.47 v2(186.71,76.52)
  BOTTOM w0.109: UZ45.3 v2(331,27.3) ; v2(186.71,76.52) 182.47,76.52 182.35,76.4 UZ43.3 ; UR4.4 5.08,19.18 5.08,17.28 6.17,16.19 v2(7.38,16.19)
RUN_ON#: length 236.8
  TOP w0.109: v2(210.83,6.83) 210.56,7.1 210.56,8.45 211.91,9.79 211.91,10.84 214.45,13.39 214.45,17.52 214.21,17.76 v2(214.21,21.24) ; QE2.5 QE2.6 120,19.34 119.84,19.49 119.14,19.49 v2(119.1,19.44) 118.84,19.18 118.84,17.11 RE68.1 v1(120.54,16.55) ; QZ21.2 297.69,58.29 v2(295.85,58.29)
  IN2 w0.081: v2(295.85,58.29) 295.85,57.19 289.78,51.11 288.72,51.11 283.47,45.86 283.47,39.84 281.15,37.53 281.15,36.57 277.57,32.98 270.29,32.98 265.88,28.57 258.41,28.57 257.98,28.14 249.14,28.14 248.85,27.84 218.95,27.84 214.21,23.1 v2(214.21,21.24)
  IN4 w0.102: v2(210.83,6.83) 210.83,6.5 210.25,5.91 210.25,4.7 209.24,3.69 205.79,3.69 205.51,3.97 193.51,3.97 193.35,4.12 183.41,4.12 182.69,3.4 178.31,3.4 176.98,4.73 174.55,4.73 171.25,8.02 165.58,8.02 165.03,8.57 163.02,8.57 162.51,8.07 161.29,8.07 158.12,11.24 157.06,11.24 155.53,12.77 153.66,12.77 153.47,12.96 153.07,12.96 152.87,12.77 151.85,12.77 151.37,13.24 149.49,13.24 147.89,11.64 147.1,11.64 145.79,10.33 142,10.33 140.82,9.15 137.06,9.15 136.74,8.84 134.88,8.84 134.28,8.24 131.01,8.24 128.95,10.31 125.95,10.31 119.86,16.4 119.86,17.39 118.77,18.47 118.77,19.12 v2(119.1,19.44)
RUN_ON_EC: length 49.1
  TOP w0.102: UE1.E8 v2(135.93,26.45)
  TOP w0.109: v2(148.66,20.46) 149.08,20.05 v1(149.08,19.86) 149.65,19.28 149.65,17.89 RE738.2 ; RE292.2 160.71,20.1 160.55,20.25 v2(160.55,20.53) 160.55,20.59 161.18,21.22 UE5.2
  IN2 w0.081: v2(160.55,20.53) 160.47,20.62 159.25,20.62 158.11,21.76 152.11,21.76 150.8,20.46 148.66,20.46 v2(148.66,20.46)
  BOTTOM w0.109: v2(135.93,26.45) 135.54,26.84 135.54,27.45 135.72,27.63 136.96,27.63 137.12,27.79 137.12,28.4 137.59,28.87 138.65,28.87 139.31,29.52 139.31,31.2 139.65,31.54 140.14,31.54 141.16,32.56 143.16,32.56 143.38,32.33 145.09,32.33 146.96,30.46 146.96,29.17 147.34,28.79 147.34,26.04 145.76,24.45 145.76,23.36 v2(148.66,20.46)
RUN_ON_R: length 4.7
  TOP w0.109: v1(339.32,40.59) 339.51,40.78 340.1,40.78 RZ510.2 ; RZ510.2 340.47,41.16 340.47,41.77 340.34,41.9 UZ40.5 ; RZ510.2 340.06,41.2 339.68,41.2 339.49,41.39 339.49,42.06 339.54,42.12 UZ40.3
RUNPWROK: length 35.8
  TOP w0.102: UE1.G3 v2(131.13,24.85)
  TOP w0.109: QE2.3 118.35,17.81 118.6,18.06 118.6,19.76 118.08,20.27 v2(118.06,20.27) 117.53,20.27 RE67.1
  BOTTOM w0.102: v2(118.06,20.27) v1(118.6,20.8) 118.97,21.18 121.93,21.18 122.32,21.57 122.32,22.17 124.15,24 124.15,24.75 123.02,25.89 123.02,26.69 123.59,27.27 123.59,27.68 123.15,28.11 123.15,29.41 124.01,30.27 124.01,31.72 124.11,31.82 124.25,31.82 125.87,30.2 125.87,26.51 125.6,26.24 125.6,25.78 126.02,25.36 126.19,25.36 127.38,24.17 128.07,24.17 128.27,23.97 128.86,23.97 129.49,24.6 130.4,24.6 130.65,24.85 v2(131.13,24.85)
S3_1.2V: length 4.3
  TOP w0.109: PR210.2 200.34,12.99 199.89,13.44 198.53,13.44 v1(198.41,13.33)
  TOP w0.203: PR210.2 201.38,11.93 PU200.7
S5_1.2V: length 2.7
  TOP w0.203: PR208.2 200.34,12.07 PC213.1 200.71,11.2 201.04,11.53 PU200.8
SA_SW:
  vias: v2(219.27,128.53) v2(219.29,127.87) v3(220.7,127.54)
SATAGP0: length 9
  TOP w0.109: RH344.2 185.53,16.84 v1(184.89,17.48) 184.66,17.7 184.66,21.89 184.67,21.9 184.67,22.91 184.66,22.92 184.66,22.98 184.56,23.09 183.14,23.09 UH1.AH41
SATAGP5: length 3.1
  TOP w0.102: UH1.AM43 v2(180.56,22.76)
  BOTTOM w0.109: v2(180.56,22.76) 181.14,22.18 v1(181.14,22.03) 181.14,20.72 RH325.2
SATAGP6: length 4.8
  TOP w0.109: UH1.AM47 180.85,20.44 180.58,20.17 180.58,19.57 180.25,19.24 180.25,18.15 v1(179.87,17.76) 179.36,17.26 179.36,16.68 RH326.2
SATALED#: length 446.8
  TOP w0.109: v2(190.92,2.44) 190.92,2.3 192,1.22 194.64,1.22 195.47,2.05 v2(195.47,5.94) ; RN218.2 356.39,11.87 354.93,13.32 352.44,13.32 351.67,14.1 350.1,14.1 349.69,13.69 349.69,13.03 349.47,12.81 344.99,12.81 344.79,12.61 342.1,12.61 341.48,13.23 341.48,14.89 340.26,16.11 339.2,16.11 338.87,16.44 337.3,16.44 335.51,18.23 335.51,20.43 335.73,20.64 335.73,21.55 335.59,21.68 335.59,23.68 334.99,24.29 332.5,24.29 v2(332.17,23.96) ; v2(80.3,48.96) 80.6,48.96 80.74,48.81 81.58,48.81 81.79,48.6 81.79,46.64 81.42,46.26 81.42,43.73 80.32,42.63 80.32,39.68 v2(79.97,39.34) ; v2(83,25.29) 83,25.19 83.3,24.88 83.3,23.17 82.86,22.73 82.86,19.15 83.06,18.95 83.06,13.67 81.76,12.37 81.76,9.93 82.02,9.67 82.02,8.84 v2(82.5,8.36) ; UH1.AK48 182.22,19.99 182.18,19.96 182.18,18.97 183.07,18.08 183.07,18 184.04,17.03 184.04,15.11 184.51,14.65 v2(184.61,14.65) ; v2(139.59,8.52) 139.62,8.5 139.62,5.36 139.03,4.77 139.03,2.56 137.75,1.28 v3(119.93,1.28) 93.52,1.28 92.64,2.17 92.64,5.41 93.95,6.73 v2(93.95,8.4)
  IN1 w0.102: v2(252.13,28.57) 252.55,28.99 261.54,28.99 265.12,25.4 270.56,25.4 272.69,27.53 272.69,33.2 273.69,34.2 273.69,35.74 274.23,36.28 274.65,36.28 282.9,44.52 288.72,44.52 291.88,47.69 293.41,47.69 297.11,51.38 300.1,51.38 300.91,52.2 301.68,52.2 306.16,47.71 307.31,47.71 311.13,43.9 311.88,43.9 312.7,43.07 317.35,43.07 321.7,38.72 321.7,30.87 325.54,27.03 328.41,27.03 329.8,25.64 331.17,25.64 332.17,24.64 v2(332.17,23.96)
  IN3 w0.081: v2(252.13,28.57) 252.13,24.29 247.06,19.22 223.57,19.22 220.8,16.45 217.64,16.45 217.32,16.77 203.8,16.77 202.83,17.74 201.62,17.74 200.38,16.5 186.61,16.5 184.75,14.65 v2(184.61,14.65) ; v2(139.59,8.52) 140.62,7.5 143.14,7.5 143.59,7.94 145.67,7.94 146.71,8.98 158.31,8.98 160.26,7.03 164.78,7.03 165.96,8.21 171.72,8.21 175.14,4.8 178.46,4.8 181.05,2.22 190.69,2.22 v2(190.92,2.44)
  BOTTOM w0.109: v2(80.3,48.96) 80.72,49.38 80.72,50.31 81.02,50.6 81.02,50.96 RN217.2 ; v2(184.61,14.65) 184.61,14.53 184.79,14.35 RH380.2 185.12,13.19 185.12,12.39 185.94,11.58 187.85,11.58 188.55,12.28 190.14,12.28 195.47,6.94 v2(195.47,5.94) ; v2(82.5,8.36) 83.46,8.36 84.19,9.09 84.59,9.09 85.07,9.57 92.79,9.57 v2(93.95,8.4) ; v2(79.97,39.34) 80.11,39.2 80.11,38.8 80.1,38.79 80.1,36.88 79.52,36.31 79.52,34.95 80.66,33.81 80.66,32.52 81.56,31.62 81.88,31.62 82.78,30.73 82.79,30.68 82.85,30.59 83.16,30.28 83.16,25.46 v2(83,25.29) 83,25.22 83.11,25.11 85.8,25.11 87.63,23.28 87.72,23.28 88.03,22.98 88.03,22.05 87.88,21.91 RN216.2
SBIOS_TX: length 153.9
  TOP w0.089: v2(175.84,32.45) 175.84,32.21 UH1.BB24
  IN1 w0.102: v2(175.84,32.45) 175.39,32.9 172.12,32.9 170.87,34.15 166.79,34.15 166.17,33.53 163.71,33.53 162.69,32.52 161.83,32.52 161.28,33.07 160.37,33.07 160.09,32.78 159.82,32.78 159.03,31.99 159.03,31.59 156.54,29.1 155.15,29.1 154.67,28.63 152.95,28.63 v2(152.74,28.42)
  IN2 w0.081: v2(67,6.36) 67.07,6.43 68.51,6.43 69.59,7.51 69.96,7.51 70.42,7.97 76.71,7.97 78,6.69 79.73,6.69 80.28,7.24 80.28,9.35 79.12,10.51 79.12,16.78 80.12,17.78 82.23,17.78 82.77,18.31 82.77,22.25 v2(82.42,22.59)
  IN3 w0.081: v2(152.74,28.42) 152.43,28.73 152.43,31.36 149.83,33.96 146.13,33.96 143.28,36.8 137.11,36.8 135.41,38.51 127.6,38.51 126.7,37.6 126.7,37.33 124.88,35.51 123.05,35.51 122.04,34.51 120.23,34.51 120.15,34.43 106.15,34.43 105.38,33.66 104.43,33.66 103.33,34.75 100.83,34.75 98.51,32.43 97.3,32.43 94.96,30.09 88.45,30.09 87.87,29.5 87.87,27.73 88.33,27.27 88.33,26.44 87.92,26.03 87.92,25.31 87.08,24.47 84.77,24.47 83.43,23.13 82.95,23.13 v2(82.42,22.59)
  BOTTOM w0.109: v2(67,6.36) 67.41,5.94 67.41,4.97 67.19,4.75 v1(66.21,4.75) 65.38,4.75 RE306.1
SCK: length 16.3
  IN1 w0.102: v2(17.77,13.95) 17.27,13.95 16.08,15.14 16.08,20.66 15.15,21.58 15.15,23.13 v2(13.92,24.36)
  BOTTOM w0.109: v2(13.92,24.36) 13.92,24.67 14.06,24.81 UR3.6 ; v2(17.77,13.95) 18.43,14.62 UR1.17
SCS: length 24.4
  IN4 w0.102: v2(24.42,20.72) 24.42,21.42 22.4,23.45 16.92,23.45 v2(16.42,22.95)
  BOTTOM w0.109: UR1.34 23.49,18.64 24.17,19.32 v1(24.17,20.16) 24.17,20.18 24.17,20.19 24.17,20.47 v2(24.42,20.72) ; RR239.2 17.5,20.71 17.5,20.07 16.97,19.53 UR3.1 16.59,19.55 16.59,22.78 v2(16.42,22.95) 16.17,23.19 RR236.1
SD_1_CD#: length 19.6
  TOP w0.109: v2(26.69,12.58) 27.33,12.58 28.79,14.04 28.79,14.68 29.62,15.5 29.62,19.96 28.34,21.23 28.34,24.63 29.82,26.1 JSD1.17
  BOTTOM w0.109: v2(26.69,12.58) v1(26.32,12.95) 25.85,13.42 UR1.47
SD_1_CLK: length 40.9
  TOP w0.109: JSD1.5 30.13,24.6 v2(30,24.46)
  IN4 w0.102: v2(14.54,18.42) 15.71,18.42 17.8,20.51 19.07,20.51 20.02,21.46 20.87,21.46 21.77,22.36 22.62,22.36 23.66,21.32 23.66,20.37 24.41,19.62 26.22,19.62 27.18,18.67 27.43,18.67 27.61,18.85 27.61,19.1 26.65,20.05 26.65,20.31 26.83,20.48 27.09,20.48 28.74,18.83 29.03,18.83 29.21,19.01 29.21,19.22 27.52,20.92 27.52,21.17 29.04,22.69 29.29,22.69 30.01,21.97 30.26,21.97 30.44,22.15 30.44,22.4 29.72,23.12 29.72,23.37 29.9,23.55 30.15,23.55 31.78,21.92 32.06,21.92 32.22,22.09 32.22,22.23 v2(30,24.46)
  BOTTOM w0.109: v1(29.15,24.27) 29.81,24.27 v2(30,24.46) ; RR213.2 15.94,17.98 CR200.1 14.66,18.42 v2(14.54,18.42)
SD_1_CLK_R: length 3.4
  BOTTOM w0.109: UR1.23 17.51,17.02 17.2,16.71 16.36,16.71 RR213.1
SD_1_CMD: length 38.6
  TOP w0.109: v2(32.77,15.12) 32.29,15.6 JSD1.2
  IN1 w0.102: v2(19.01,22.37) 18.63,22.37 18.48,22.52 18.48,22.88 18.72,23.12 19.31,23.12 20.72,21.71 20.72,21.57 20.54,21.4 20.13,21.4 19.95,21.22 19.95,20.96 20.13,20.79 20.54,20.79 20.72,20.61 20.72,20.36 20.54,20.18 20.13,20.18 19.95,20 19.95,19.75 20.13,19.57 20.65,19.57 20.72,19.49 20.72,19.24 20.01,18.53 20.01,18.28 20.19,18.1 20.44,18.1 21.19,18.85 21.37,18.85 21.47,18.75 21.47,17.76 21.65,17.58 21.9,17.58 22.08,17.76 22.08,18.61 22.26,18.78 22.51,18.78 22.69,18.61 22.69,17.76 22.86,17.58 23.12,17.58 23.3,17.76 23.3,18.61 23.47,18.78 23.73,18.78 23.91,18.61 23.91,17.81 24.08,17.63 24.34,17.63 24.52,17.81 24.52,19.78 24.92,20.18 25.37,20.18 26.44,19.11 26.44,16.4 27.04,15.81 30.39,15.81 31.26,14.94 31.26,14.08 31.41,13.93 31.66,13.93 31.84,14.11 31.84,14.94 32.02,15.12 v2(32.77,15.12)
  BOTTOM w0.109: RR230.2 19.01,21.53 v2(19.01,22.37)
